# Allegro board LA-F711P R05-0112.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+1.2V_DDRP on BOTTOM (solid shape): 61.33,8.81 62.06,8.81 62.08,8.81 62.08,9.36 62.53,9.36 62.53,8.81 63.33,8.81 64.36,8.81 64.5,8.95 65.13,8.95 65.17,8.91 65.17,7.31 65.16,7.3 65.16,5.45 64.84,5.13 56,5.13 55.67,5.46 55.67,8.99 55.88,9.19 58.72,9.19 59.13,8.79 59.72,8.79 59.74,8.8 60.2,8.8 60.2,8.81 60.86,8.81 60.88,8.81 60.88,9.36 61.33,9.36
+1.2V_DDRP on IN2 (solid shape): 65.05,8.76 65.05,6.2 64.92,6.07 63.8,6.07 63.47,6.4 63.47,9.02 63.67,9.22 64.59,9.22
+1.2V_DDRP on IN2 (solid shape): 51.13,11.35 51.13,10.9 51.1,10.87 49.88,10.87 49.48,10.46 49.48,9.96 48.59,9.07 48.23,9.07 48.1,9.19 48.1,10.74 49.22,11.86 50.62,11.86
+1.2V_LDO on TOP (solid shape): 16.93,66.26 16.93,65.31 15.93,64.31 15.56,64.31 15.39,64.13 15.39,63.77 15.34,63.72 14.45,63.72 14.45,64.36 14.96,64.86 16.1,64.86 16.68,65.44 16.68,66.26 16.74,66.32 16.87,66.32
+1.2V_LDO on TOP (solid shape): 18.52,66.26 18.52,65.37 19.41,64.48 19.98,64.48 20.17,64.29 20.17,63.72 20.04,63.59 18.58,63.59 18.52,63.66 18.52,64.93 18.33,65.12 18.33,66.26 18.39,66.32 18.45,66.32
+1.2V_MEM on TOP (solid shape): 102.22,31.46 94.22,31.46 94.22,39.46 102.22,39.46
+1.2V_MEM on TOP (solid shape): 115.17,31.46 107.17,31.46 107.17,39.46 115.17,39.46
+1.2V_MEM on TOP (solid shape): outline of 26680 points within 29.64,9.74 172.72,61.81
+1.2V_MEM on BOTTOM (solid shape): 142.54,53.06 142.54,49.63 137.33,49.63 136.7,50.27 136.7,52.79 136.7,52.79 136.77,53.13 136.8,53.47 137.16,53.82 141.78,53.82
+1.2V_MEM on BOTTOM (solid shape): 64.69,11.2 64.69,10.08 64.44,9.83 64.44,9.07 64.31,8.94 62.66,8.94 62.66,9.49 61.95,9.49 61.95,8.94 61.46,8.94 61.46,9.49 60.75,9.49 60.75,8.94 60.08,8.94 60.08,8.93 59.7,8.93 58.59,10.03 58.59,10.82 59.36,11.58 64.31,11.58
+1.2V_MEM on BOTTOM (solid shape): 71.32,64.15 71.32,61.74 71.17,61.59 71.17,60.64 71.17,60.64 71.52,60.3 71.5,60.25 71.5,59.43 72.26,59.43 72.26,59.46 72.85,59.46 72.98,59.59 73.3,59.59 73.5,59.38 73.5,58.29 73.45,58.24 70.62,58.24 69.55,59.31 69.55,60.92 68.82,61.65 68.82,62.79 68.95,62.91 69.44,62.91 69.72,63.19 69.72,64.12 69.82,64.22 71.25,64.22
+1.2V_MEM on BOTTOM (solid shape): 66.14,51.31 66.14,49.12 65.6,48.59 62,48.59 61.11,49.48 61.11,51.41 63.37,51.41 63.37,51.36 63.38,51.3 63.39,51.25 63.42,51.21 63.45,51.16 63.48,51.12 63.52,51.09 63.57,51.06 63.62,51.04 63.67,51.03 63.72,51.03 63.78,51.03 63.83,51.04 63.88,51.06 63.93,51.09 63.97,51.12 64,51.16 64.03,51.21 64.06,51.25 64.07,51.3 64.08,51.36 64.08,51.41 64.07,51.46 64.06,51.51 64.03,51.56 64,51.61 63.97,51.65 63.93,51.68 63.88,51.71 63.83,51.72 63.78,51.74 63.72,51.74 63.67,51.74 63.62,51.72 63.57,51.71 63.52,51.68 63.48,51.65 63.45,51.61 63.42,51.56 63.39,51.51 63.38,51.46 63.37,51.41 61.11,51.41 61.11,52.2 61.4,52.49 64.96,52.49
+1.2V_RUN on TOP (solid shape): 144.95,130.52 144.95,129.12 144.83,128.99 143.56,128.99 143.37,129.18 143.37,130.45 143.62,130.71 144.76,130.71
+1.2V_RUN on TOP (solid shape): 26.59,118.9 27.29,118.9 28.56,117.63 28.56,113.94 28.18,113.56 27.29,113.56 27.29,117.82 26.91,118.2 25.7,118.2 24.88,119.02 22.21,119.02 21.64,118.45 21.64,117.94 21.51,117.82 20.87,117.82 20.68,118.01 20.68,118.33 20.59,118.42 20.02,118.42 19.86,118.58 19.86,119.47 20.56,120.17 25.32,120.17
+1.2V_RUN on BOTTOM (solid shape): 21,119.72 21,118.71 20.68,118.39 19.92,118.39 19.86,118.45 19.86,119.79 20.05,119.98 20.75,119.98
+1.2V_RUN on IN2 (solid shape): 21.64,119.15 21.64,118.33 21.26,117.94 20.11,117.94 19.86,118.2 19.86,119.02 20.18,119.34 21.45,119.34
+1.2V_VDD_A1 on TOP (solid shape): 27.1,117.56 27.1,114.13 26.73,113.77 26.73,113.42 26.57,113.25 25.78,113.25 25.64,113.39 25.64,113.82 25.89,114.07 25.89,114.52 26.34,114.96 26.34,116.61 26.15,116.8 26.15,117.75 26.27,117.88 26.78,117.88
+1.2V_VDD_A2 on TOP: 18.97,112.1 19.22,111.85 20.05,111.85 20.43,112.23 20.43,113.56 20.94,114.07 20.94,115.79 21.64,116.48 21.64,117.18 21.51,117.31 20.62,117.31 19.86,116.55 19.86,114.45 19.6,114.2 19.6,112.8 19.41,112.61 19.1,112.61 18.97,112.48
+1.2V_VDD_DM_D1 on TOP (solid shape): 28.05,112.99 28.05,112.23 27.86,112.04 26.22,112.04 26.12,112.14 25.29,112.14 25.19,112.04 24.68,112.04 24.62,112.1 24.62,112.74 25,113.12 27.92,113.12
+1.2V_VDD_DM_D1 on IN2: 22.02,106.9 20.3,106.9 18.97,108.23 18.97,109.44 19,109.47 19.19,109.47 19.45,109.72 20.27,109.72 20.3,109.75 22.21,109.75 22.72,109.24 22.72,108.04 24.3,106.45 24.43,106.45 25.26,107.28 25.26,114.26 24.49,115.02 21.8,115.02 21.7,115.12 20.59,115.12 20.18,115.53 20.18,116.86 20.43,117.12 25.45,117.12 26.56,116.01 26.56,107.05 25.13,105.63 23.29,105.63
+1.2V_VDD_R1 on BOTTOM (solid shape): 22.97,119.28 22.97,116.17 22.72,115.91 22.4,115.91 21.22,117.09 21.22,119.75 21.32,119.85 22.4,119.85
+1.2V_VDD_R2 on TOP (solid shape): 24.05,118.71 24.05,116.55 23.96,116.46 23.69,116.29 23.67,115.97 23.67,115.91 23.48,115.72 23.03,115.72 22.91,115.85 22.91,116.1 22.34,116.67 22.34,118.52 22.65,118.83 23.92,118.83
+1.2V_VIN on TOP (solid shape): 153.56,130.73 153.56,129.15 153.01,129.15 153.01,128.71 153.56,128.71 153.56,128.27 152.95,127.66 150.1,127.66 149.97,127.79 149.97,128.04 150.92,128.99 150.92,130.83 151.24,131.15 153.15,131.15
+1.8V_3.3V_ALW_VTR3 on TOP (solid shape): 314.51,13.88 314.51,10.26 314.26,10 312.84,10 312.75,10.06 312.76,10.17 312.98,10.39 312.98,10.7 312.95,10.7 312.95,11.11 312.39,11.11 312.39,11.29 312.95,11.29 312.95,11.84 312.96,11.85 312.96,12.99 312.95,12.99 312.95,13.4 312.39,13.4 312.39,13.58 312.85,13.58 312.88,13.6 312.92,13.6 312.92,13.65 312.95,13.67 312.95,14.09 313.16,14.3 314.09,14.3
+1.8V_3.3V_ALW_VTR3 on BOTTOM: 314.4,26.31 314.4,28.3 314.69,28.58 315.9,28.58 316.02,28.46 316.02,27.89 315.98,27.81 315.89,27.79 315.47,27.65 315.52,27.2 315.52,26.02 315.02,25.94 315.11,25.44 315.11,25.1 315.11,25.09 315.11,24.87 315.01,24.76 314.38,24.76 314.18,24.97 314.18,26.1 314.4,26.31
+1.8V_ALW_PCHRES on TOP: 220.25,39.72 222.28,39.72 222.49,39.93 223.21,39.93 223.49,39.65 224.91,39.65 224.96,39.7 224.96,40.78 224.85,40.89 223.77,40.89 223.23,41.43 220.75,41.43 220.18,40.86 220.18,39.78
+1.8V_ALW_PCHRES on IN1: 215.9,32.18 208.52,32.18 207.53,31.19 207.53,29.34 207.97,28.89 208.44,28.89 209.01,29.46 209.01,29.7 209.27,29.96 217.67,29.96 223.26,35.55 223.26,36.22 222.59,36.89 220.61,36.89
+1.8V_ALW_PCHRES on IN3: 209.29,23.65 208.09,23.65 207.83,23.9 207.83,27.48 206.97,28.35 206.97,29.96 207.37,30.37 208.9,30.37 209.14,30.12 209.14,28.84 209.15,28.84 209.15,28.74 209.77,28.12 209.77,24.13
+1.8V_PHVLDO on TOP: outline of 98 points within 204.11,33.32 217.28,36.96
+1.8V_PRIM on TOP (solid shape): 332.28,49.68 332.28,48.54 332.02,48.28 331.14,48.28 331.01,48.41 331.01,49.55 331.26,49.81 332.15,49.81
+1.8V_PRIM on TOP (solid shape): 305.87,27.97 305.87,26.76 305.81,26.69 305.81,25.96 304.59,25.96 304.19,26.36 304.19,28.03 304.21,28.1 304.21,28.17 304.21,28.19 304.44,28.42 305.42,28.42
+1.8V_PRIM on BOTTOM (solid shape): 127.86,8.76 127.86,7.52 127.78,7.44 126.59,7.44 126.49,7.54 126.49,8.01 126.46,8.01 126.46,8.42 125.9,8.42 125.9,8.6 126.46,8.6 126.46,9.02 127.61,9.02
+1.8V_PRIM on IN2 (solid shape): 129.46,8.03 129.46,7.05 129.07,6.65 127.1,6.65 126.39,7.37 126.39,8.58 126.74,8.94 128.55,8.94
+1.8V_PRIM on TOP: 218.57,38.88 218.74,39.05 218.74,40.77 218.77,40.8 219.8,40.8 219.99,40.61 219.99,38.18 219.8,37.99 218.86,37.99 218.57,38.27
+1.8V_PRIM on TOP: 304.47,5.87 304.21,6.12 304.21,6.88 306.5,9.17 306.5,12.17 306.54,12.21 306.5,12.22 306.5,13.36 307.39,14.25 309.55,14.25 309.67,14.12 309.67,13.08 309.88,12.88 309.88,12.32 309.85,12.25 309.78,12.22 309.43,11.86 309.78,11.5 311.06,11.5 311.07,11.5 311.2,11.48 311.32,11.5 311.33,11.5 311.6,11.5 311.8,11.71 312.82,11.71 312.82,11.42 312.26,11.42 312.26,10.98 312.82,10.98 312.82,10.57 312.85,10.57 312.85,10.44 312.62,10.21 310.64,10.21 310.64,10.21 310.4,10.21 308.22,8.03 307.89,8.03 305.74,5.87
+1.8V_PRIM on IN2: 302.74,47.1 303.83,47.1 304.03,46.9 304.03,44.94 303.63,44.54 302.76,44.54 302.46,44.84 302.46,46.82
+1.8V_PRIM on IN2: 266.57,8.17 266.57,6.44 266.05,5.92 260.27,5.92 259.88,6.31 259.88,7.85 260.35,8.32 266.42,8.32
+1.8V_PRIM on IN2: 228.81,42.15 229.22,41.74 229.22,40.27 228.76,39.81 222.91,39.81 222.18,40.54 221.66,40.54 220.05,38.92 218.79,38.92 218.46,39.26 218.46,41.96 218.65,42.15
+1.8V_PRIM on IN2: 211.6,6.15 213.5,6.15 214.8,4.84 216.68,4.84 217,4.52 217,1.94 216.72,1.66 215.48,1.66 215.46,1.68 215.29,1.51 213.85,1.51 211.11,4.25 211.11,5.65
+1.8V_PRIM on IN2: 268.4,35.47 277.26,35.47 277.83,36.04 277.83,39.93 277.68,40.08 275.26,40.08 274.01,38.84 272.56,38.84 271.41,37.68 268.54,37.68 268.09,37.24 268.09,35.78
+1.8V_PRIM on IN2: 302.47,5.83 302.08,6.22 295.04,6.22 294.29,6.97 283.98,6.97 283.64,6.63 276.84,6.63 276.34,7.14 276.34,7.95 276.58,8.19 283.45,8.19 284.23,8.98 294.48,8.98 294.78,8.69 297.57,8.69 298.51,7.75 298.51,7.73 305.94,7.73 306.12,7.56 306.12,7.14 306.24,7.01 306.24,5.99 306.08,5.83
+1.8V_PRIM on IN2: 146.64,7.25 146.63,7.24 146.55,7.24 146.08,7.71 146.08,9.98 146.33,10.23 158.11,10.23 159.35,11.47 163.93,11.47 164.1,11.3 164.1,10.11 163.9,9.91 162.22,9.91 159.56,7.25
+1.8V_PRIM on IN2: 238.54,38.3 243.96,38.3 244.42,37.85 248.7,37.85 249.04,37.5 249.04,35.48 248.9,35.34 243.79,35.34 242.13,36.99 238.98,36.99 238.38,37.6 238.38,38.14
+1.8V_PRIM on IN3: 304.53,27.81 305.46,27.81 305.87,28.23 305.87,33.92 305.36,34.43 303.77,34.43 303.7,34.5 303.7,35.68 304.61,36.59 304.61,46.04 304.34,46.3 302.27,46.3 302.01,46.05 302.01,42.66 301.6,42.24 301.6,34.53 301.61,34.52 301.61,31.93 304.04,29.49 304.04,28.3
+1.8V_PRIM_PCH on TOP: 208.65,35.9 208.44,35.94 208.24,35.86 208.12,35.86 207.03,34.76 207,34.79 206.54,34.75 206.5,34.29 206.52,34.26 206.43,34.16 205.14,34.16 205.08,34.23 205.08,34.69 205.04,34.73 205.35,35.03 206.18,35.03 206.6,35.46 206.63,35.46 206.89,35.56 207,35.83 207,35.85 207.6,36.46 207.64,36.42 208.14,36.43 208.14,36.93 208.11,36.96 210.57,39.43 213.21,39.43 213.47,39.17 213.62,39.17 213.72,39.15 213.82,39.17 216.94,39.17 216.95,39.16 218.04,39.16 218.15,39.05 218.15,37.46 218.02,37.33 214.45,37.33 214.27,37.51 214.05,37.51 214.04,37.52 213.6,37.52 211.99,35.91 210.92,35.91 210.91,35.91 210.76,35.95 210.61,35.91 210.6,35.91 210.16,35.91 210.15,35.91 210,35.95 209.85,35.91 209.83,35.91 209.4,35.91 209.39,35.91 209.24,35.95 209.08,35.91 209.07,35.91 208.74,35.91 208.73,35.92 208.69,35.88
+1.8V_RUN on TOP (solid shape): 335.17,48.08 336.39,48.08 336.6,47.88 336.6,47.13 336.85,46.88 337.78,46.88 337.99,46.67 337.99,46.56 338,46.55 338,45.97 337.71,45.68 334.78,45.68 334.44,45.34 334.44,44.7 334.34,44.6 333.83,44.6 333.7,44.73 333.7,45.54 333.77,45.61 333.77,47.32 334.63,48.18 335.07,48.18
+1.8V_RUN_CARD on TOP (solid shape): 6.9,81.3 6.9,80.29 5.61,78.99 3.37,78.99 3.09,79.27 3.09,80.8 3.22,80.92 4.75,80.92 5,81.18 5.31,81.18 5.35,81.21 5.67,81.21 5.89,81.43 6.78,81.43
+1.8V_RUN_CARD on TOP (solid shape): 18.14,66.26 18.14,65.12 18.39,64.86 18.39,62.9 18.33,62.83 18.01,62.83 17.88,62.96 17.88,66.26 17.95,66.32 18.07,66.32
+1.8V_RUN_CARD on BOTTOM (solid shape): 6.78,81.18 6.78,79.53 6.52,79.27 5.97,79.27 5.51,79.73 5.51,81.1 5.69,81.28 6.68,81.28
+1.8V_RUN_CARD on IN2 (solid shape): 4.87,80.59 4.87,78.61 4.52,78.26 3.73,78.26 3.09,78.89 3.09,80.7 3.25,80.85 4.62,80.85
+1.8V_RUN_CARD on IN2 (solid shape): 18.58,63.72 18.58,62.45 18.01,61.88 17.06,61.88 16.8,62.13 16.8,62.71 16.99,62.9 17.37,62.9 17.69,63.21 17.69,63.72 17.88,63.91 18.39,63.91
+1.8V_RUN_UZ8 on TOP (solid shape): 333.08,47.42 333.08,45.78 332.53,45.24 331.39,45.24 331.14,45.49 331.14,47.01 331.77,47.01 332.38,47.62 332.88,47.62
+1.8VALWP on BOTTOM (solid shape): 126.34,9.04 126.34,8.73 125.78,8.73 125.78,8.29 126.34,8.29 126.34,7.88 126.36,7.88 126.36,6.3 126.21,6.15 123.59,6.15 123.39,6.35 123.39,7.04 122.86,7.57 122.53,7.57 122.47,7.62 122.47,8.41 122.6,8.53 124.08,8.53 124.41,8.86 124.81,8.86 124.84,8.89 124.89,8.89 125.09,9.09 125.35,9.09 125.43,9.1 125.5,9.12 126.26,9.12
+1.24V_LDOSRAM on TOP: 207.16,32.16 207.16,32.93 207.42,33.19 208,33.19 208.08,33.11 208.07,33.07 208.17,32.62 208.63,32.66 208.89,32.66 209.07,32.56 209.27,32.58 210.39,32.58 210.65,32.32 210.65,31.99 210.45,31.8 207.52,31.8
+1VALWP_B+ on TOP (solid shape): 166.13,4.68 167.14,4.68 167.27,4.56 167.27,1.41 167.14,1.28 165.35,1.28 165.1,1.54 165.1,5.12 165.18,5.2 165.61,5.2
+1VALWP_B+ on BOTTOM: 164.64,5.96 165.64,5.96 166.01,5.59 166.01,4.85 166.22,4.64 166.55,4.64 167.29,5.38 168.75,5.38 168.8,5.33 168.8,4.29 168.63,4.11 167.55,4.11 167.25,3.81 167.25,1.76 167.21,1.73 164.84,1.73 164.59,1.99 164.59,5.9
+1VS_VCCIOP on BOTTOM (solid shape): 143.08,66.25 143.78,66.25 143.78,66.8 144.22,66.8 144.28,66.74 144.28,66.25 145.98,66.25 146.43,66.7 147.49,66.7 147.77,66.42 147.77,61.33 147.37,60.92 142.35,60.92 142.16,61.11 142.16,63.55 141.3,64.41 141.3,65.89 141.66,66.25 142.58,66.25 142.58,66.8 143.08,66.8
+2.5V_MEM on TOP (solid shape): 178.3,20.98 178.99,20.98 179.24,20.73 179.24,19.96 182.04,17.17 182.04,15.19 182.04,12.95 179.85,10.77 178.9,10.77 178.56,11.11 178.56,11.56 180.51,13.51 180.51,17.04 178.1,19.46 178.1,19.84 177.92,20.01 175.26,20.01 175.08,20.19 175.08,21.18 175.21,21.31 177.97,21.31
+2.5V_MEM on TOP (solid shape): 99.3,23.65 99.41,23.65 101.06,22 101.06,19.94 103.55,17.45 103.55,14.55 104.72,13.39 104.72,12.72 104.67,12.68 104.65,12.67 104.34,12.32 104.65,11.97 104.67,11.96 104.72,11.91 104.72,11.2 104.71,11.19 104.71,4.23 103.49,3.01 101.46,3.01 101.14,3.33 101.14,4.53 101.27,4.66 101.9,4.66 102.2,4.96 102.2,5.25 102.21,5.26 102.21,10.69 103.02,11.51 103.02,12.12 103.03,12.14 103.07,12.47 102.83,12.69 102.81,12.69 101.77,13.73 101.77,16.53 98.57,19.74 98.57,22.25 97.56,23.27 96.57,23.27 94.53,25.3 90.98,25.3 90.85,25.17 90.85,24.92 91.23,24.54 94.08,24.54 96.14,22.48 96.14,21.08 96.12,21.07 96.12,20.46 96.01,20.34 95.73,20.34 94.18,21.89 94.18,22.72 93.38,23.52 90.85,23.52 89.89,24.48 89.89,25.99 90.22,26.31 96.63,26.31
+2.5V_MEM on BOTTOM (solid shape): 77.65,9.87 78.21,9.87 78.34,9.74 78.34,8.72 78.18,8.56 76.96,8.56 76.84,8.69 76.84,9.22 76.28,9.22 76.28,9.4 76.84,9.4 76.84,9.88 77.64,9.88
+2.5V_MEM on IN2 (solid shape): 78.55,9.61 78.55,3.27 79.15,2.67 99.4,2.67 101.43,4.7 103.26,4.7 103.49,4.47 103.49,3.01 101.8,1.32 77.67,1.32 76.31,2.68 76.31,9.88 76.47,10.03 78.13,10.03
+2.5V_VIN on BOTTOM (solid shape): 70.63,10.03 70.63,8.84 71.09,8.38 71.52,8.38 71.67,8.23 71.67,7.62 71.55,7.49 69.52,7.49 68.45,8.55 68.45,9.04 67.9,9.04 67.9,9.27 68.45,9.27 68.45,10.01 68.63,10.18 70.48,10.18
+2.8V_FHV0 on TOP: 203.86,23.99 203.86,28.69 204.09,28.92 204.09,28.97 204.19,29.07 204.19,29.2 204.34,29.35 204.7,29.35 204.77,29.28 204.77,28.97 204.32,28.52 204.32,20.16 204.19,20.03 203.54,20.03 203.39,20.19 203.39,20.81 203.13,21.07 203.13,23.27 203.13,23.27
+2.8V_FHV1 on TOP: 204.44,20.1 204.44,28.31 204.95,28.82 204.95,29.23 205.08,29.35 205.48,29.35 205.56,29.28 205.56,28.54 205.1,28.09 205.09,28.08 204.86,27.83 204.95,27.5 204.95,24.18 204.85,23.94 204.95,23.69 204.95,21.9 204.85,21.65 204.95,21.4 205.32,21.03 205.32,20.16 205.2,20.03 204.51,20.03
+3.3V_1.8V_AZIO on TOP: 223.19,38.83 222.53,38.83 222.4,38.7 222.34,38.7 222.33,38.71 222.18,38.74 222.04,38.71 222.03,38.7 221.96,38.7 221.83,38.83 221.83,39.47 221.96,39.59 222.2,39.59 222.21,39.59 222.38,39.76 222.49,39.76 222.53,39.8 222.82,39.8 223.25,39.37 225.73,39.37 225.83,39.27 225.83,38.73 225.75,38.66 223.36,38.66
+3.3V_1.8V_AZIO_R on IN1: 212.75,37.18 213.39,36.54 219.29,36.54 219.86,37.12 221.15,37.12 222.18,38.14 222.28,38.14 222.39,38.25 222.39,38.6 222.35,38.64 219.8,38.64 219.42,38.26 217.01,38.26 216.75,38.01 216.24,38.01 216.05,38.2 212.91,38.2 212.91,38.19 212.75,38.03
+3.3V_1.8V_GPPA on TOP: 213.42,28.26 213.72,28.11 214.01,28.26 215.13,28.26 215.23,28.16 215.23,27.75 215.84,27.15 215.84,26.34 215.98,26.19 216.44,26.19 216.57,26.06 216.57,25.62 216.53,25.58 214.75,25.58 214.51,25.81 213.18,25.81 213.16,25.83 213.04,25.93 212.89,25.97 212.88,25.97 212.53,26.16 212.52,26.18 212.36,26.32 212.14,26.35 212.12,26.34 211.87,26.45 211.87,26.47 211.67,26.67 211.39,26.67 211.37,26.66 211.1,26.78 211.09,26.79 210.94,26.91 210.75,26.94 210.73,26.93 210.33,27.1 210.33,27.11 210.12,27.22 209.89,27.17 209.88,27.17 209.1,27.15 208.94,27.2 208.77,27.15 208.09,27.15 208.04,27.19 207.98,27.21 207.77,27.51 207.64,27.51 207.54,27.61 207.54,28.05 207.78,28.3 207.81,28.3 207.82,28.4 208.06,28.93 208.17,28.93 208.19,28.92 208.39,28.87 208.58,28.94 208.6,28.95 208.96,28.93 208.97,28.92 209.13,28.87 209.29,28.9 209.3,28.9 211.24,28.79 211.26,28.77 211.46,28.68 211.68,28.73 211.7,28.74 211.93,28.67 211.94,28.65 212.14,28.5 212.39,28.52 212.4,28.53 212.69,28.44 212.7,28.43 212.88,28.31 213.09,28.31 213.1,28.32 213.3,28.26
+3.3V_1.8V_GPPD on TOP: 218.28,33.94 218.28,33.62 218.12,33.46 217.1,33.46 217.01,33.56 217.01,34.83 217.07,34.89 217.83,34.89 217.9,34.96 218.59,34.96 218.66,34.89 218.66,34.32
+3.3V_1.8V_SPI on TOP: 206.91,18.81 207.11,19.07 207.02,19.38 207.23,19.59 207.67,19.59 207.73,19.64 207.73,21.5 207.73,21.51 207.76,21.66 207.72,21.81 207.7,21.85 207.67,21.89 207.67,22.67 208.21,23.22 208.38,23.22 208.77,22.82 209.02,22.82 209.17,22.67 209.17,22.38 208.91,22.12 208.91,20.71 208.91,20.4 208.91,20.38 208.87,20.23 208.91,20.07 208.91,20.05 208.91,19.73 208.9,19.66 208.91,19.6 208.91,19.48 208.9,19.4 208.91,19.32 208.91,19.18 208.98,19.11 208.97,19.08 209,18.86 209.2,18.67 209.2,17.62 209.01,17.43 206.97,17.43 206.91,17.49
+3.3V_ALW on TOP (solid shape): 155.49,129.82 155.49,128.17 155.11,127.79 153.97,127.79 153.72,128.04 153.72,129.95 153.91,130.14 155.18,130.14
+3.3V_ALW on TOP (solid shape): 317.33,72.19 317.33,71.85 317.18,71.7 316.99,71.7 316.48,71.19 314.83,71.19 314.83,71.43 315.42,71.43 315.42,71.59 314.83,71.59 314.83,72.32 315.18,72.67 316.85,72.67
+3.3V_ALW on TOP (solid shape): 312.82,14.03 312.82,13.73 312.8,13.71 312.26,13.71 312.26,13.27 312.82,13.27 312.82,12.86 312.84,12.86 312.84,12.52 312.72,12.4 312.05,12.4 311.29,11.64 310.35,11.64 310.15,11.84 310.15,14.06 310.37,14.28 312.57,14.28
+3.3V_ALW on TOP (solid shape): 290.11,6.32 290.11,5.65 290.11,5.65 289.98,5.52 289.98,5.05 289.88,4.95 289.52,4.95 289.23,4.66 289.23,4.47 289,4.24 287.52,4.24 287.38,4.39 287.38,5.05 287.37,5.05 287.37,5.84 287.42,5.89 288.6,5.89 289.11,6.4 290.04,6.4
+3.3V_ALW on TOP (solid shape): 310.05,25.55 310.05,25.54 310.21,25.39 310.21,24.52 309.91,24.23 309.88,24.23 309.85,24.21 309.27,24.21 309.24,24.18 309.24,23.98 309.27,23.95 309.8,23.95 309.88,23.88 309.88,23.72 309.83,23.67 309.29,23.67 309.24,23.62 309.24,23.49 309.27,23.47 309.8,23.47 309.85,23.42 309.85,23.22 309.83,23.19 309.27,23.19 309.22,23.14 309.22,23.01 309.27,22.96 309.8,22.96 309.85,22.91 309.85,22.76 309.78,22.69 308.99,22.69 308.71,22.97 308.71,23.95 308.72,23.96 308.72,25.49 309.04,25.81 309.8,25.81
+3.3V_ALW on TOP (solid shape): 316.44,69.85 316.47,69.83 316.49,69.8 316.49,69.66 316.8,69.66 316.83,69.65 316.85,69.61 316.85,69.56 316.98,69.43 317.04,69.39 317.11,69.37 317.28,69.37 317.31,69.36 317.33,69.32 317.33,67.78 317.14,67.59 315.07,67.59 314.83,67.83 314.83,69.39 314.85,69.42 314.88,69.44 315.42,69.44 315.42,69.58 314.88,69.58 314.85,69.6 314.83,69.63 314.83,69.8 314.85,69.83 314.88,69.85
+3.3V_ALW on TOP (solid shape): 122.09,123.14 122.12,123.08 122.17,123.03 122.22,122.94 122.19,122.84 122.16,122.47 122.44,122.25 122.51,122.24 122.51,120.72 121.96,120.17 121.07,120.17 120.8,120.43 120.8,122.17 120.86,122.18 121.12,122.44 121.02,122.78 120.98,122.89 121.02,123 121.2,123.18 122.07,123.18
+3.3V_ALW on TOP (solid shape): 200.88,3.89 200.88,1.8 200.4,1.32 198.4,1.32 198.37,1.29 193.06,1.29 192.21,2.15 192.21,3.75 192.69,4.23 194.32,4.23 194.33,4.22 194.33,3.36 194.2,2.96 194.54,2.72 194.56,2.72 194.66,2.62 196.03,2.62 196.19,2.77 196.19,3.1 196.13,3.15 196.13,3.16 196.05,3.28 195.93,3.36 195.92,3.36 195.7,3.58 195.7,4.19 195.77,4.25 199.32,4.25 199.71,3.92 200.03,4.31 200.03,4.32 200.45,4.32
+3.3V_ALW on TOP (solid shape): outline of 106 points within 152.85,28.84 180.65,53.36
+3.3V_ALW on TOP (solid shape): outline of 169 points within 70.15,106.53 85.39,115.41
+3.3V_ALW on BOTTOM (solid shape): 145.11,107.21 145.11,106.17 145.36,105.92 149.2,105.92 151.3,103.81 151.3,103.15 150.79,102.63 143.69,102.63 142.34,103.99 142.34,107.21 142.77,107.64 144.67,107.64
+3.3V_ALW on BOTTOM (solid shape): 117.85,9.35 117.85,8.51 118.03,8.33 118.51,8.33 118.74,8.1 118.74,7.29 118.69,7.24 116.95,7.24 116.37,7.82 115.68,7.82 115.51,7.99 115.51,9.21 115.73,9.44 117.76,9.44
+3.3V_ALW on IN1 (solid shape): 163.11,64.41 163.11,52.22 161.59,50.7 155.88,50.7 154.48,52.09 154.48,52.98 154.99,53.49 155.24,53.49 157.78,56.03 157.78,62.89 155.49,65.18 152.45,65.18 151.68,65.94 151.68,68.22 152.45,68.99 158.54,68.99
+3.3V_ALW on IN2 (solid shape): 142.54,126.14 142.54,124.48 142.29,124.23 141.27,124.23 140.64,124.87 140.64,126.14 141.02,126.52 142.16,126.52
+3.3V_ALW on IN2 (solid shape): 123.51,125.84 123.51,125.54 122.25,124.28 122.25,121.74 122.2,121.7 121.1,121.7 120.94,121.87 120.94,122.21 120.97,122.23 121.13,122.53 120.97,122.83 120.94,122.85 120.94,125.65 121.22,125.93 123.42,125.93
+3.3V_ALW on IN3 (solid shape): 153.84,116.23 153.84,114.2 153.46,113.82 152.83,113.82 140.51,126.14 140.51,127.72 141.14,128.36 141.72,128.36
+3.3V_ALW on IN3 (solid shape): 34.59,52.22 34.59,51.71 34.16,51.28 32.28,51.28 30.01,49.01 29.17,49.01 28.94,49.23 28.94,52.97 29.23,53.26 33.55,53.26
+3.3V_ALW on IN3 (solid shape): 48.18,5.61 48.18,5.08 48.46,4.8 49.07,4.8 49.42,4.44 49.42,3.83 49.78,3.48 49.78,2.95 49.7,2.87 48.41,2.87 47.16,4.11 47.16,5.03 46.99,5.21 46.99,5.61 47.16,5.79 48,5.79
+3.3V_ALW on IN3 (solid shape): 108.94,9.83 110.36,9.83 110.64,9.55 110.64,8.84 103.93,2.13 67.31,2.13 66.7,2.74 66.7,7.16 66.15,7.71 66.15,9.3 66.48,9.63 68.27,9.63 69.13,8.76 69.13,4.97 69.03,4.73 69.12,4.49 69.13,4.47 70.25,3.35 92.25,3.35 92.86,3.96 103.35,3.96 106.65,7.26 106.65,9.75 107.44,10.54 108.23,10.54
+3.3V_ALW on IN3 (solid shape): outline of 119 points within 312.85,58.83 318.44,72.67
+3.3V_ALW on TOP: 154.22,65.73 153.67,65.18 150.16,65.18 149.95,65.38 149.96,65.41 149.9,65.65 149.69,65.8 149.65,65.81 149.65,76.56 147.44,78.76 147.44,101.24 145.72,102.97 145.72,111.66 149.46,115.4 152.99,115.4 153.56,114.83 153.56,113.87 153.34,113.64 153.34,100.46 154.22,99.57
+3.3V_ALW on TOP: 305.35,36.48 304.39,37.44 304.39,37.97 304.77,38.35 304.77,38.35 305.43,39.01 306.27,39.01 306.47,39.22 307.13,39.22 307.62,39.7 309.12,39.7 309.27,39.85 309.94,39.85 310.09,39.69 310.09,39.11 309.97,38.99 309.97,38.73 309.89,38.66 309.59,38.66 309.55,38.7 308.74,38.7 308.74,38.64 308.43,38.33 308.43,37.39 307.92,36.88 307.61,36.88 307.61,37.44 307.17,37.44 307.17,36.88 306.76,36.88 306.76,36.88 306.29,36.88 305.89,36.48
+3.3V_ALW on TOP: 327.25,40.95 327.51,40.41 327.33,40.23 326.59,40.23 326.56,40.26 326.56,41.95 327.1,42.48 327.1,44.3 327.17,44.37 328.34,44.37 328.42,44.3 328.42,41.35 328.25,41.18 328.01,41.15 327.85,40.97
+3.3V_ALW on TOP: 254.44,33.57 252.41,33.57 252.18,33.33 251.27,33.33 251.13,33.19 251.13,32.71 250.6,32.19 250.6,31.78 250.84,31.54 251.27,31.54 252.54,32.81 254.34,32.81 254.52,32.98 254.52,33.49
+3.3V_ALW on BOTTOM: 66.95,1.19 66.48,1.66 66.48,4.38 65.59,5.27 65.6,5.28 65.6,9.36 66,9.75 68.3,9.75 68.33,9.72 68.33,9.39 67.77,9.39 67.77,8.91 68.33,8.91 68.33,8.51 68.32,8.5 68.32,8.46 67.95,8.09 67.95,8.08 67.26,7.38 67.26,5.16 69.69,2.73 92.64,2.73 93.06,2.31 98.23,2.31 99.67,3.75 103.49,3.75 103.49,3.82 103.7,4.04 104.85,4.04 105.69,4.88 105.69,6 105.89,6.2 105.89,7.11 106.57,7.8 106.9,7.8 106.9,10.98 107.12,11.2 110.03,11.2 110.64,10.59 110.64,8.61 109.76,7.73 109.75,7.73 109.31,7.58 108.88,7.4 108.87,7.39 107.9,6.43 107.9,6.43 106.98,5.51 106.98,3.83 104.34,1.19
+3.3V_ALW on BOTTOM: 169.06,7.56 169.17,7.56 169.23,7.61 169.85,7.61 170.62,8.38 171.6,8.38 171.64,8.42 171.64,9.25 171.6,9.28 170.52,9.28 169.68,8.44 169.07,8.44 168.98,8.36 168.98,7.63
+3.3V_ALW on BOTTOM: 201.98,11.05 200.24,11.05 200,10.81 200,8.67 200.39,8.28 200.39,7.25 200.21,7.07 199.67,7.07 199.48,6.88 199.48,5.73 199.68,5.52 200.17,5.52 200.43,5.27 200.43,4.05 200.22,3.85 196.55,3.85 196.2,3.49 196.2,2.9 196.54,2.55 200.99,2.55 202.19,3.76 202.19,6.32 201.44,7.07 201.44,8.8 201.11,9.13 201.11,10.08 201.28,10.25 201.98,10.25 202.05,10.32 202.05,10.97
+3.3V_ALW on BOTTOM: 326.29,15.96 325.32,15.96 324.96,16.32 324.96,17.93 325.17,18.14 326.06,18.14 326.38,17.82 326.38,16.05
+3.3V_ALW on BOTTOM: 305.33,11.45 305.35,11.47 305.34,11.49 305.34,11.58 305.35,11.6 305.43,11.84 305.34,12.09 305.34,12.9 305.53,13.09 306.59,13.09 306.68,13.01 306.68,10.74 306.52,10.59 306.52,9.59 305.98,9.04 305.98,7.8 305.85,7.67 304.77,7.67 304.67,7.77 304.67,9.09 305.33,9.75 305.33,11 305.33,11.01 305.36,11.14 305.33,11.27 305.33,11.28
+3.3V_ALW on VCC: outline of 138 points within 103.17,1.17 369.23,83.84
+3.3V_ALW_PCH on TOP (solid shape): 218.02,23.53 218.02,22.89 217.39,22.26 216.75,22.26 216.63,22.38 216.63,24.04 216.69,24.1 217.45,24.1
+3.3V_ALW_PCH on TOP (solid shape): 241.33,35.34 241.33,33.63 241.21,33.5 240.7,33.5 240.52,33.68 240.52,35.33 240.65,35.46 241.22,35.46
+3.3V_ALW_PCH on BOTTOM (solid shape): 200.5,14.76 200.5,14.03 200.76,13.77 200.76,13.77 200.9,13.63 203.04,13.63 203.16,13.51 203.16,12.38 203.09,12.31 200.42,12.31 199.61,13.12 199.61,13.81 199.04,14.38 198.15,14.38 198.08,14.45 198.08,15.21 198.27,15.4 199.86,15.4
+3.3V_ALW_PCH on IN1 (solid shape): 222.02,32.84 221.99,32.82 222.12,32.16 222.43,32.76 222.41,32.87 222.5,32.93 224.89,32.93 224.98,32.89 224.99,32.79 225.32,32.31 225.65,32.79 225.66,32.89 225.75,32.93 226.42,32.93 226.49,32.9 226.52,32.82 226.87,32.41 227.22,32.82 227.25,32.9 227.32,32.93 227.59,32.93 228.37,32.16 228.37,31.69 228.15,31.47 225.33,31.47 225.19,31.61 222.12,31.61 221.22,30.71 221.22,28.66 220.78,28.22 220.52,27.95 220.16,27.95 219.89,28.23 219.89,30.98 221.07,32.16 221.11,32.19 221.13,32.22 221.84,32.93 222,32.93
+3.3V_ALW_PCH on TOP: 223.58,36.02 223.58,35.24 223.77,35.05 224.65,35.05 224.9,35.31 224.9,36.08 224.79,36.19 223.76,36.19
+3.3V_ALW_PCH on TOP: 198.54,14.02 204,14.02 204.16,13.86 204.16,12 202.4,10.24 200.36,10.24 199.72,9.59 193.98,9.59 193.02,8.64 190.25,8.64 190.24,8.65 190.24,9.92 192.74,12.42 196.94,12.42
+3.3V_ALW_PCH on BOTTOM: 226.6,32.59 226.23,32.22 226.23,31.84 226.47,31.61 226.74,31.61 226.84,31.51 226.84,30.03 226.97,29.91 227.5,29.91 227.75,30.15 227.75,30.73 228.74,31.72 228.74,35 228.49,35.24 226.81,35.24 226.6,35.04
+3.3V_ALW_PCH_UZ3 on TOP: 194.4,5.67 194.4,5.63 194.27,5.5 191.53,5.5 190.65,6.37 190.65,8.38 190.77,8.51 191.22,8.51 191.22,7.95 191.65,7.95 191.65,8.51 192.06,8.51 192.4,8.51 192.43,8.53 192.67,8.53 193.5,7.7 194.05,7.7 194.13,7.62 194.13,6.81 194.41,6.53 194.41,6.28 194.4,6.23
+3.3V_ALW_PCHRES on TOP (solid shape): 216.75,34.77 216.75,33.56 216.69,33.5 215.42,33.5 215.23,33.69 215.23,34.7 215.42,34.89 216.63,34.89
+3.3V_ALW_PCHRES on TOP (solid shape): 216.5,29.05 217.2,29.05 217.54,28.71 217.54,28.3 217.44,28.09 217.54,27.88 217.54,27.35 217.35,27.16 216.19,27.16 215.56,27.79 215.56,29.07 215.74,29.24 216.31,29.24
+3.3V_ALW_PCHRES on TOP: 203.56,17.24 203.35,17.02 201.96,17.02 201.72,16.79 201.72,14.93 201.95,14.71 205.05,14.71 205.76,15.42 210.37,15.42 210.6,15.65 210.6,17.13 210.49,17.24
+3.3V_ALW_PCHRES on TOP: 221.07,42.45 225.23,42.45 226.08,41.6 226.08,39.66 225.99,39.57 225.19,39.57 225.1,39.66 225.1,41.5 224.98,41.62 220.37,41.62 219.84,41.1 218.7,41.1 218.55,40.95 218.55,40.09 218.25,39.78 217.85,39.78 217.72,39.91 217.72,41.46 218.59,42.32 220.94,42.32
+3.3V_ALW_PCHRES on IN1: 214.54,39.74 215.97,39.74 216.24,39.47 216.24,38.54 215.91,38.21 212.87,38.21 212.58,37.92 212.58,36.4 212.86,36.12 216.24,36.12 216.51,35.85 216.51,34.25 216.26,34.01 209.64,34.01 209.41,34.24 209.41,40.54 209.74,40.87 212.33,40.87 212.91,40.29 213.98,40.29
+3.3V_ALW_PCHRES on IN3: 203.7,16.14 203.45,16.4 203.45,16.6 203.45,16.92 203.72,17.18 204.97,17.18 204.97,17.18 207.13,17.18 209.21,19.26 210.07,19.26 210.3,19.49 210.3,24.92 215.11,29.73 215.11,34.95 215.15,34.99 216.26,34.99 216.51,34.75 216.51,33.72 217.34,32.88 217.34,26.09 215.85,24.59 215.85,22.95 213.22,20.32 213.22,19.27 212.91,18.96 212.38,18.96 211.51,18.1 210.41,18.1 209.32,17 208.39,17 207.53,16.14
+3.3V_ALW_UE1 on TOP (solid shape): 312.72,34.95 313.81,34.95 313.97,34.8 313.97,34.67 313.84,34.54 312.24,34.54 311.7,35.08 311.32,35.08 311.32,35.2 310.75,35.2 310.63,35.33 310.63,35.6 310.74,35.71 311.96,35.71
+3.3V_ALW_UE1 on TOP (solid shape): 309.97,37.5 309.97,36.04 309.81,35.89 307.56,35.89 307.21,36.25 307.01,36.25 306.89,36.37 306.89,36.75 307.3,36.75 307.3,37.31 307.48,37.31 307.48,36.75 307.97,36.75 308,36.78 308.01,36.78 308.01,36.79 308.56,37.34 308.56,37.74 309.72,37.74
+3.3V_ALW_UE1 on IN2: 319,30.18 318.74,29.92 314.37,29.92 311.74,32.56 311.74,33 310.91,33.82 310.91,34 310.68,34.23 310.19,34.23 308.85,35.57 308.85,37.08 309.1,37.34 310.33,37.34 314.56,33.11 314.56,32.75 314.57,32.7 314.58,32.66 314.58,32.04 314.57,32.04 314.62,31.75 314.87,31.6 314.88,31.59 315.36,31.11 315.37,31.1 315.63,30.8 316,30.93 316.02,30.96 316.04,30.99 317.8,30.99 318.27,30.82 318.45,31.28 318.49,31.32 318.49,35.13 318.94,35.58 319.71,35.58 319.87,35.42 319.87,35.4 320.21,35.07 320.21,31.78 320.36,31.63 320.56,31.59 320.58,31.6 320.66,31.57 320.7,31.5 320.7,30.68 320.34,30.33 319.7,30.33 319.69,30.36 319.28,30.6 319,30.21
+3.3V_ALW_UE1 on IN3: 308.33,37.2 309.76,37.2 309.94,37.02 309.94,36.16 309.67,35.89 308.53,35.89 308.09,36.33 308.09,36.96
+3.3V_ALW_UZ12 on TOP: 250.77,34.74 250.56,34.53 248.7,34.53 248.64,34.46 248.64,33.75 248.8,33.59 248.8,33.07 248.78,33.05 248.78,32.44 248.89,32.34 250.25,32.34 250.97,33.06 250.97,33.84 251.14,34.01 252.33,34.01 252.41,34.09 252.41,34.62 252.28,34.74
+3.3V_ALWP on BOTTOM (solid shape): 98.4,10.72 100.15,10.72 100.5,10.34 100.86,10.72 104.85,10.72 105.15,11.02 106.18,11.02 106.2,11 106.2,7.75 105.76,7.31 105.76,6.31 105.57,6.12 104.92,6.12 104.85,6.19 104.85,6.66 104.65,6.86 95.14,6.86 93.21,8.79 93.21,11.4 93.52,11.71 97.41,11.71
+3.3V_CPS on TOP: 19.8,118.2 20.24,118.2 20.37,118.07 20.37,117.44 19.73,116.8 19.73,114.64 19.41,114.32 19.1,114.32 19.03,114.39 19.03,114.96 19.16,115.09 19.16,117.12 19.6,117.56 19.6,118.01
+3.3V_CPS on IN2: 21.38,114.96 21.64,114.71 23.86,114.71 24.37,114.2 24.37,108.74 25,108.1 25,107.72 24.81,107.53 23.99,107.53 22.91,108.61 22.91,112.8 22.59,113.12 20.27,113.12 19.13,114.26 19.13,114.8 19.29,114.96
+3.3V_DSW on BOTTOM (solid shape): 222.84,21.07 222.84,20.65 222.72,20.52 221.69,20.52 221.39,20.23 221.39,17.62 221.01,17.24 220.37,17.24 220.31,17.3 220.31,17.94 220.12,18.13 219.29,18.13 218.95,18.47 218.91,18.47 218.9,18.48 218.86,18.48 218.72,18.51 218.58,18.48 215.57,18.48 214.35,19.7 214.35,20.02 214.34,20.03 214.34,20.07 214.15,20.26 214.12,20.26 214.12,20.38 214.18,20.47 214.2,20.59 214.21,20.59 214.46,20.59 214.57,20.49 214.57,20.3 214.73,20.13 214.74,20.09 214.74,19.86 215.43,19.17 215.46,19.17 215.54,19.09 216.12,19.09 216.2,19.17 218.42,19.17 218.7,18.89 218.8,18.89 218.8,18.85 219.33,18.85 219.36,18.83 220.31,18.83 220.63,19.15 220.63,19.56 220.63,19.56 220.63,20.97 220.81,21.16 222.75,21.16
+3.3V_FUSE on TOP: 209.89,17.37 209.64,17.62 209.64,18.61 209.04,19.21 209.04,22.03 209.84,22.83 210.3,22.83 210.39,22.74 210.39,22.74 210.53,22.6 210.53,22.3 210.37,22.13 210.37,19.45 210.36,19.4 210.37,19.34 210.37,18.71 210.72,18.36 210.72,17.43 210.66,17.37
+3.3V_HDD on TOP (solid shape): 255.93,22.2 256.82,22.2 257.52,21.49 257.53,21.48 257.61,21.36 257.72,21.28 257.73,21.28 257.76,21.26 258.03,21.26 258.06,21.28 258.36,21.28 258.37,21.28 258.49,21.26 258.62,21.28 258.63,21.28 258.99,21.28 259.07,21.26 259.16,21.25 260.7,19.71 260.7,17.25 260.32,16.87 258.36,16.87 257.65,17.58 257.65,18.69 257.4,18.95 256.74,18.95 255.8,18.01 252.98,18.01 252.24,18.74 252.24,21.89 252.58,22.22 255.9,22.22
+3.3V_HDD on BOTTOM (solid shape): 259.53,19.93 259.56,19.92 259.58,19.88 259.58,19.39 260.13,19.39 260.13,19.88 260.14,19.92 260.18,19.93 260.33,19.93 260.36,19.92 260.38,19.88 260.38,19.39 260.93,19.39 260.93,19.88 260.94,19.92 260.98,19.93 261.16,19.93 261.25,19.85 261.25,19.39 261.71,19.39 262.28,18.82 262.28,17.7 262.18,17.47 262.27,17.24 262.28,17.22 262.28,17.14 262.17,17.04 261.67,17.04 261.57,17.14 261.57,18.01 261.44,18.14 260.9,18.14 260.75,17.98 260.75,17.54 260.75,17.53 260.73,17.42 260.75,17.32 260.75,17.31 260.75,15.47 259.97,14.68 259.97,13.06 259.86,12.95 259.28,12.95 259.23,13 259.23,14.07 258.95,14.35 258.95,19.34 258.96,19.37 259,19.39 259.25,19.39 259.25,19.88 259.27,19.92 259.3,19.93
+3.3V_HDD_M2 on BOTTOM (solid shape): 343.58,4.72 344.17,4.72 344.27,4.62 344.27,3.35 343.69,2.77 343.66,2.77 343.45,2.56 343.45,1.35 343.43,1.32 343.21,1.32 343.17,1.34 343.16,1.37 343.16,2.5 342.95,2.5 342.95,1.37 342.94,1.34 342.9,1.32 342.7,1.32 342.67,1.34 342.65,1.37 342.65,2.51 342.45,2.51 342.45,1.37 342.43,1.34 342.4,1.32 342.18,1.32 342.15,1.34 342.13,1.37 342.13,3.5 342.35,4.13 342.16,4.76 342.15,4.78 342.15,4.82 342.18,4.85 343.45,4.85
+3.3V_HDD_M2 on BOTTOM (solid shape): 356.94,7.64 356.98,7.63 356.99,7.6 357.24,7.28 357.63,7.4 357.71,7.44 357.79,7.39 358.09,7.24 358.38,7.39 358.46,7.44 358.54,7.4 358.93,7.28 359.18,7.6 359.19,7.63 359.23,7.64 359.73,7.64 361.15,6.22 361.15,4.98 361.14,4.95 361.11,4.93 360.5,4.15 361.12,3.37 361.15,3.35 361.16,3.32 361.16,1.3 361.14,1.26 361.11,1.25 360.2,1.25 360.16,1.26 360.15,1.3 360.15,2.51 359.95,2.51 359.95,1.3 359.94,1.26 359.9,1.25 359.71,1.25 359.67,1.26 359.66,1.3 359.66,2.93 359.13,3.45 357.98,3.45 357.95,3.41 357.94,3.02 357.95,2.99 357.95,1.29 357.87,1.21 357.71,1.21 357.67,1.23 357.66,1.26 357.66,2.49 357.46,2.49 357.46,1.26 357.44,1.23 357.4,1.21 357.2,1.21 357.17,1.23 357.15,1.26 357.15,2.49 356.95,2.49 356.95,1.26 356.93,1.23 356.9,1.21 356.7,1.21 356.66,1.23 356.65,1.26 356.65,2.5 356.45,2.5 356.45,1.26 356.44,1.23 356.4,1.21 356.21,1.21 356.13,1.29 356.13,6.68 356.17,6.76 356.25,6.78 356.62,7.03 356.46,7.44 356.41,7.52 356.44,7.6 356.49,7.64
+3.3V_HDD_M2 on TOP: 342.57,4.8 343.37,4.8 343.43,4.74 344.43,4.74 344.82,5.13 345.99,5.13 347.11,6.25 350,6.25 350.63,5.61 351.96,5.61 352.5,6.15 359.15,6.15 359.46,6.45 359.46,8.53 359.84,8.91 366,8.91 366.25,8.66 366.25,3.45 364.19,1.4 343.89,1.4 343.87,1.41 339.52,1.41 339.05,1.88 339.05,4.91 339.16,5.03 342.33,5.03
+3.3V_LAN on TOP (solid shape): 318.44,114.88 318.44,112.55 317.6,111.71 316.48,111.71 316.4,111.78 316.4,112.55 317.09,113.23 317.09,114.3 317.8,115.01 318.31,115.01
+3.3V_LAN on TOP (solid shape): 314.96,89.51 314.96,88.63 314.73,88.4 314.07,88.4 313.6,87.93 313.6,86.02 313.52,85.9 313.51,85.76 313.7,85.55 313.98,85.61 315.31,85.61 315.45,85.47 315.45,83.21 314.56,82.32 308.66,82.32 307.13,83.84 307.13,84.61 307.51,84.99 310.07,84.99 312.31,87.24 312.31,88.52 312.61,88.81 313.03,88.81 313.81,89.6 314.87,89.6
+3.3V_LAN on IN1 (solid shape): 313.86,83.34 313.86,76.22 313.1,75.46 310.05,75.46 308.53,76.99 308.53,83.97 309.16,84.61 312.59,84.61
+3.3V_LAN_OUT on TOP (solid shape): 325.73,85.37 327.82,85.37 327.87,85.33 327.87,83.9 327.82,83.85 326.3,83.85 325.74,84.41 325.66,84.61 325.45,84.7 324.97,85.18 323.82,85.18 323.76,85.25 323.76,85.76 323.82,85.82 325.28,85.82
+3.3V_LAN_OUT on BOTTOM (solid shape): outline of 155 points within 314.88,83.59 328.6,92.86
+3.3V_LAN_OUT on TOP: 315.47,89.15 315.49,89.13 315.49,87.05 315.65,86.88 317.52,86.88 317.62,86.78 318.59,86.78 318.65,86.84 318.65,86.94 318.58,87.02 317.83,87.02 317.65,87.2 316.87,87.2 316.69,87.38 316.69,89.32 316.36,89.65 316.36,89.65 315.52,89.65 315.47,89.59
+3.3V_LAN_UZ2 on TOP (solid shape): 312.58,75.3 312.62,75.29 312.63,75.25 312.63,74.75 313.07,74.75 313.07,75.25 313.08,75.29 313.12,75.3 313.4,75.3 313.48,75.22 313.48,71.73 313.33,71.58 312.76,71.58 312.76,71.43 313.29,71.43 313.33,71.42 313.34,71.38 313.34,71.23 313.33,71.19 313.29,71.18 312.17,71.18 311.75,71.59 311.22,71.59 311.18,71.64 311.18,74.97 311.51,75.3
+3.3V_M_TPM on TOP (solid shape): 243.58,35.95 243.58,35.33 243.44,35.19 242.58,35.19 242.25,34.86 242.25,33.55 242.01,33.31 242.01,31.05 241.91,30.95 241.32,30.95 241.26,31.01 241.26,33.13 241.46,33.34 241.46,35.92 241.65,36.11 243.43,36.11
+3.3V_MMI_AUX on TOP (solid shape): 15.72,61.88 15.72,60.99 15.66,60.93 13.88,60.93 13.69,61.12 13.69,61.75 13.88,61.94 15.66,61.94
+3.3V_MMI_AUX on TOP (solid shape): 18.2,75.09 18.2,73.76 18.39,73.58 18.39,72.54 18.41,72.52 18.49,72.44 18.49,71.04 18.51,71.02 18.51,70.84 18.51,69.77 18.41,69.67 18.33,69.75 18.33,70.38 18.2,70.51 18.2,70.62 18.16,70.67 18.16,71.06 17.71,71.51 17.7,71.56 17.67,71.61 17.68,71.71 17.65,71.81 17.65,72.47 17.42,72.69 17.42,73.35 17.27,73.5 14.01,73.5 13.82,73.69 13.82,74.77 14.2,75.15 18.14,75.15
+3.3V_MMI_IN on TOP (solid shape): 17.37,66.26 17.37,65.18 17.12,64.93 17.12,63.34 17.88,62.58 18.26,62.58 18.33,62.51 18.33,60.67 18.64,60.36 18.64,59.5 18.12,59.5 18.12,59 18.64,59 18.64,58.7 18.12,58.7 18.12,58.2 18.64,58.2 18.64,57.87 18.61,57.84 16.68,57.84 16.49,58.03 16.49,63.21 16.68,63.4 16.68,64.8 17.12,65.25 17.12,66.26 17.18,66.32 17.31,66.32
+3.3V_PGPPBC on TOP: 214.47,28.54 214.09,28.92 213.21,28.92 212.99,29.01 212.76,28.93 212.75,28.92 212.59,28.92 212.57,28.96 212.29,29.2 211.95,29.05 211.9,29 211.85,29.05 211.85,29.07 211.73,29.31 211.48,29.39 211.08,29.39 210.76,29.58 210.44,29.39 210.3,29.39 209.98,29.58 209.67,29.39 208.69,29.39 208.5,29.56 208.25,29.56 208.18,29.62 208.18,30.87 208.31,31 209.61,31 209.68,30.93 209.64,30.9 209.7,30.37 210.22,30.49 210.36,30.49 210.67,30.3 210.98,30.49 211.12,30.49 211.43,30.3 211.74,30.49 211.88,30.49 211.99,30.36 212.15,30.31 212.17,30.3 212.37,30.11 213.75,30.11 213.77,30.08 214.11,30.08 214.34,29.85 215.1,29.85 215.29,29.66 215.29,28.67 215.17,28.54
+3.3V_PGPPEF on TOP: 205.83,17.43 205.48,17.78 205.48,21.42 205.56,21.65 205.48,21.87 205.48,22.19 205.48,22.19 205.48,22.66 205.48,22.66 205.48,23.71 205.56,23.93 205.48,24.16 205.48,25.23 205.52,25.62 205.18,25.81 205.14,25.82 205.1,25.85 205,25.95 205,27.18 205.15,27.34 206.15,27.34 206.3,27.18 206.3,27.1 206.29,27.07 206.29,26.94 206.34,26.81 206.36,26.75 206.36,26.43 206.28,26.22 206.36,26 206.36,25.6 206.28,25.38 206.36,25.17 206.36,24.82 206.29,24.54 206.45,24.31 206.45,24.3 206.58,24.17 206.58,24.12 206.57,24.11 206.48,23.86 206.58,23.61 206.58,23.12 206.69,23.02 206.69,22.95 206.63,22.89 206.63,20.4 206.59,20.37 206.59,17.56 206.47,17.43
+3.3V_PGPPG on TOP: 213.14,33.22 212.95,33.27 212.77,33.22 212.38,33.22 212.19,33.27 212.01,33.22 211.61,33.22 211.43,33.27 211.25,33.22 210.85,33.22 210.67,33.27 210.48,33.22 210.09,33.22 209.92,33.27 209.74,33.22 209.71,33.22 209.33,33.22 209.14,33.27 208.96,33.22 208.57,33.22 208.41,33.26 208.25,33.24 208.22,33.23 208.1,33.34 208.1,34.11 208.08,34.13 208.08,34.49 208.23,34.64 208.56,34.64 208.8,34.4 208.79,34.38 209.02,34.01 209.43,34.13 209.7,34.13 209.98,33.99 210.26,34.13 210.48,34.13 210.76,33.99 211.04,34.13 211.5,34.13 211.56,34.18 211.57,34.19 211.75,34.28 211.85,34.46 211.85,34.48 211.88,34.51 211.95,34.51 211.97,34.49 212.25,34.37 212.52,34.51 212.93,34.51 212.98,34.56 213.02,34.56 213.19,34.4 214.84,34.4 214.97,34.26 214.97,33.62 214.85,33.5 214.33,33.5 214.02,33.19 213.94,33.19 213.74,33.27 213.53,33.22
+3.3V_PGPPHK on TOP: 203.2,27.18 203.2,25.95 203.05,25.8 203.03,25.81 202.62,25.59 202.77,25.16 202.77,24.79 201.9,23.92 201.9,19.37 202.47,18.81 202.47,18.28 202.74,18.01 203.15,18.01 203.23,17.93 203.23,17.34 203.16,17.27 201.71,17.27 201.58,17.41 201.58,18 201.39,18.19 201.39,19.08 200.64,19.83 200.64,21.02 201.01,21.4 201.04,21.43 201.09,21.5 201.11,21.65 201.09,21.77 201.09,21.78 201.09,22.04 201.1,22.05 201.1,25.19 201.72,25.82 201.73,25.82 201.98,26.07 201.98,26.96 202.27,27.25 203.13,27.25
+3.3V_PHVLDO on TOP: 211.38,40.01 211.18,40.21 211.18,40.5 211.31,40.63 213.07,40.63 213.46,40.54 213.69,40.87 213.69,40.89 213.75,40.95 213.79,40.92 214.14,40.86 214.37,41.14 214.37,41.16 214.6,41.38 214.72,41.38 214.73,41.38 215.04,41.38 215.24,41.62 215.24,41.64 216.05,42.45 216.05,42.64 216.31,42.89 216.34,42.89 216.5,43.05 217.48,43.05 218.06,43.63 221.92,43.63 222.02,43.53 222.02,42.89 221.83,42.7 221.01,42.7 220.83,42.52 220.32,42.52 220.31,42.53 218.4,42.53 216.9,41.03 216.24,41.03 215.74,40.52 214.64,40.52 214.13,40.01
+3.3V_PRTC on BOTTOM (solid shape): 214.21,20.02 214.21,19.65 215.51,18.35 218.85,18.35 218.98,18.22 218.98,17.94 218.85,17.81 215.04,17.81 213.63,19.22 213.63,19.58 213.53,19.68 213.53,19.74 213.4,19.86 213.4,20.08 213.46,20.14 214.09,20.14
+3.3V_RUN on TOP (solid shape): 25.95,59.59 25.95,58.39 25.37,57.81 18.79,57.81 18.79,59.97 19.05,60.22 25.32,60.22
+3.3V_RUN on TOP (solid shape): 271.75,40.59 271.75,39.24 271.88,39.11 271.88,38.91 271.82,38.85 270.9,38.85 270.72,39.03 270.72,40.55 270.85,40.68 271.65,40.68
+3.3V_RUN on TOP (solid shape): 174.09,27.47 174.09,26.9 173.76,26.57 173.76,25.68 173.77,25.68 173.7,25.62 173.09,25.62 173.04,25.66 173.04,27 172.84,27.2 172.84,27.71 173.03,27.9 173.67,27.9
+3.3V_RUN on TOP (solid shape): 140.71,12.8 140.71,12.49 141.25,11.95 141.25,11.75 141.17,11.67 140.2,11.67 139.87,12 139.87,12.24 140.2,12.57 140.2,12.8 140.35,12.95 140.57,12.95
+3.3V_RUN on TOP (solid shape): 268.85,17.85 268.85,17.6 268.81,17.38 268.91,17.17 268.91,15.26 267.76,15.26 267.64,15.39 267.64,17.96 267.78,18.1 268.6,18.1
+3.3V_RUN on TOP (solid shape): 277.57,6.36 277.57,4.9 276.25,3.58 273.59,3.58 273.24,3.94 272.33,3.94 272.31,3.96 272.31,4.19 272.36,4.24 273.5,4.24 274.53,5.28 275.24,5.28 275.25,5.27 275.93,5.27 276.14,5.49 276.14,7.01 276.3,7.16 276.77,7.16
+3.3V_RUN on TOP (solid shape): 207.11,13.92 207.11,13.41 208.01,12.51 209.25,12.51 210.3,13.56 211.48,13.56 211.7,13.35 212.15,13.35 212.27,13.23 212.27,12.86 212.05,12.64 210.61,12.64 210.43,12.46 210.43,11.92 208.4,9.89 208.4,6.31 207.5,5.41 199.97,5.41 199.78,5.6 199.78,7.17 202.97,7.17 202.97,7.11 202.98,7.06 203,7.01 203.02,6.96 203.05,6.92 203.08,6.88 203.13,6.85 203.17,6.82 203.22,6.8 203.27,6.79 203.33,6.78 203.38,6.79 203.43,6.8 203.48,6.82 203.53,6.85 203.57,6.88 203.61,6.92 203.64,6.96 203.66,7.01 203.67,7.06 203.68,7.11 203.68,7.17 203.67,7.22 203.66,7.27 203.64,7.32 203.61,7.36 203.57,7.4 203.53,7.44 203.48,7.46 203.43,7.48 203.38,7.49 203.33,7.5 203.27,7.49 203.22,7.48 203.17,7.46 203.13,7.44 203.08,7.4 203.05,7.36 203.02,7.32 203,7.27 202.98,7.22 202.97,7.17 199.78,7.17 199.78,9.38 200.57,10.17 202.52,10.17 205.65,13.3 205.65,13.99 205.91,14.25 206.78,14.25
+3.3V_RUN on BOTTOM (solid shape): 17.29,98.44 17.29,96.81 17.23,96.75 16.09,96.75 15.89,96.94 15.89,98.59 16,98.7 17.03,98.7
+3.3V_RUN on BOTTOM (solid shape): 174.17,36.95 174.17,26.46 174.06,26.35 173.12,26.35 172.84,26.63 172.84,36.15 171.53,37.47 171.53,38.07 171.6,38.15 172.98,38.15
+3.3V_RUN on BOTTOM (solid shape): 265.74,23.41 265.74,22.51 262.74,19.51 261.38,19.51 261.38,20.06 260.8,20.06 260.8,19.51 260.5,19.51 260.5,20.06 260,20.06 260,19.51 259.71,19.51 259.71,20.06 259.12,20.06 259.12,19.51 258.43,19.51 257.35,20.6 257.35,21.54 257.72,21.91 262.92,21.91 264.41,23.4 264.45,23.43 264.48,23.47 265.68,23.47
+3.3V_RUN on IN2 (solid shape): 18.24,98.01 18.24,95.97 17.6,95.34 17.17,95.34 16.67,95.84 16.67,97.99 16.85,98.18 18.08,98.18
+3.3V_RUN on IN2 (solid shape): 26.21,59.97 26.21,59.08 25.19,58.06 23.29,58.06 22.91,58.44 22.91,59.71 23.41,60.22 25.95,60.22
+3.3V_RUN on TOP: 222.93,28.22 223.05,28.33 223.05,28.61 223.38,28.94 223.93,28.94 224.14,28.73 224.14,27.49 224.14,27.49 224.14,27.33 224.08,27.27 223.49,27.27 222.86,26.63 222.86,26.59 222.84,26.59 222.84,26.05 222.86,26.05 222.86,25.96 222.84,25.96 222.84,25.59 222.84,25.58 222.84,25.1 222.69,24.95 222.28,24.95 222.03,25.21 222.03,26.54 222.04,26.56 222.01,26.58 222.01,27.15 221.2,27.15 221.08,27.28 221.08,27.91 221.18,28.02 221.9,28.02 222.11,28.22
+3.3V_RUN on TOP: 347.5,14.99 348.67,16.15 355.08,16.15 355.1,16.14 355.27,16.1 355.43,16.14 355.45,16.15 355.75,16.15 355.87,16.13 356,16.15 360.66,16.15 362.75,13.89 365.72,13.09 365.74,13.09 366.38,12.46 366.38,9.49 366,9.11 365.04,9.11 365.04,9.68 363.01,9.68 363.01,9.11 346.31,9.11 344.14,11.28 335.96,11.28 334.94,12.3 334.94,13.98 334.01,14.91 334.01,17.59 333.92,17.68 333.92,17.77 333.89,17.79 333.89,19.07 333.9,19.09 334.13,19.09 334.13,18.48 334.28,18.48 334.28,19.09 334.63,19.09 334.76,19.21 334.76,19.85 335.17,20.27 337.26,20.27 337.56,19.97 337.56,19.46 337.56,19.45 337.56,18.91 337.03,18.91 337.03,18.48 337.52,18.48 337.55,18.46 337.56,18.43 337.56,15.54 338.12,14.99 345.69,14.99 345.76,14.96 345.79,14.88 346.08,14.53 346.48,14.75 346.54,14.8 346.62,14.8 346.89,14.77 347.1,14.95 347.12,14.99
+3.3V_RUN on BOTTOM: 203.22,9.33 203.22,8.53 203.56,8.19 207.18,8.19 207.79,8.8 208,8.8 208.4,9.21 208.4,9.55 207.93,10.02 207.92,10.02 207.79,10.15 207.79,12.95 207.61,13.14 207.61,14.09 207.49,14.21 204.32,14.21 204.21,14.09 204.21,13.6 204.46,13.35 204.46,10.57
+3.3V_RUN on VCC: outline of 122 points within 22.91,8.28 337.61,113.44
+3.3V_RUN on IN2: 221.74,37.2 221.74,35.92 222.11,35.55 222.72,35.55 223.25,36.08 225.81,36.08 225.97,35.93 226.89,35.93 227.08,36.12 227.08,37.46 226.46,38.09 222.63,38.09
+3.3V_RUN on IN2: 217.93,51.35 217.93,48.75 223.8,42.89 225.17,42.89 225.73,43.45 225.73,45.33 219.18,51.87 218.45,51.87
+3.3V_RUN_AUDIO on TOP: 338.33,17.23 337.69,17.87 337.69,19.51 337.69,19.51 337.69,21.26 337.7,21.28 337.7,24.83 337.83,24.95 339.3,24.95 340.14,24.11 340.14,17.59 339.78,17.23
+3.3V_RUN_AUDIO_DVDD on TOP (solid shape): 339.23,33.76 339.88,33.11 339.88,32.28 339.33,31.73 338.79,31.73 338.39,31.33 338.39,31.12 338.34,31.07 337.74,31.07 337.74,31.79 338.28,32.33 338.28,32.77 338.59,33.09 338.59,33.56 339.02,33.98 339.02,34.93 339.03,34.93 339.23,34.93
+3.3V_RUN_AUDIO_IO on TOP (solid shape): 342.42,34.78 342.42,34.09 342.83,33.68 342.83,33.24 342.75,33.16 342.38,33.16 342.23,33.32 342.23,34.78 342.27,34.82 342.38,34.82
+3.3V_RUN_AUDIO_IO on BOTTOM (solid shape): 343.5,33.62 343.5,33.05 343.62,32.93 343.98,32.93 344.04,32.88 344.04,32.2 343.9,32.06 342.11,32.06 342.04,32.13 342.04,32.55 342.12,32.63 342.89,32.63 343.01,32.75 343.01,33.04 342.89,33.16 342.46,33.16 342.25,33.37 342.25,33.7 342.32,33.77 343.35,33.77
+3.3V_RUN_AUDIO_UZ5 on TOP: 333.93,20.56 333.9,20.57 333.88,20.61 333.88,21.67 334.28,22.06 334.32,22.06 334.32,22.1 334.36,22.15 334.36,22.6 334.41,22.65 335.03,22.65 335.18,22.49 337.37,22.49 337.57,22.29 337.57,21.33 336.8,20.56 334.33,20.56 334.29,20.57 334.28,20.61 334.28,21.09 334.14,21.09 334.14,20.61 334.13,20.57 334.09,20.56
+3.3V_RUN_CARD on TOP (solid shape): 23.35,62.51 23.35,61.81 23.22,61.68 21.45,61.68 21.26,61.87 21.26,62.51 21.45,62.7 23.16,62.7
+3.3V_RUN_CARD on TOP (solid shape): 31.85,64.48 31.85,63.85 31.66,63.66 28.42,63.66 28.23,63.85 28.23,64.55 28.42,64.74 31.6,64.74
+3.3V_RUN_CARD on TOP (solid shape): 17.76,66.26 17.76,64.17 17.63,64.04 17.44,64.04 17.25,64.23 17.25,64.86 17.5,65.12 17.5,66.26 17.57,66.32 17.69,66.32
+3.3V_RUN_CARD on BOTTOM (solid shape): 31.54,64.55 33.5,64.55 33.69,64.36 33.69,63.85 33.5,63.66 30.14,63.66 29.89,63.91 29.89,64.67 30.02,64.79 31.29,64.79
+3.3V_RUN_CARD on IN1 (solid shape): 22.45,64.17 22.45,62.13 22.22,61.9 21.61,61.9 21.2,62.31 21.2,63.83 20.8,64.23 17.88,64.23 17.63,63.98 17.37,63.98 17.18,64.17 17.18,64.93 17.5,65.25 21.38,65.25
+3.3V_RUN_UT9 on BOTTOM (solid shape): 18.73,108.09 18.86,108.09 19.2,107.75 19.2,107.53 18.94,107.28 18.53,107.28 17.89,106.64 17.89,105.75 18.08,105.56 18.08,104.96 18.03,104.91 17.14,104.91 17.14,104.9 16.05,104.9 15.88,105.06 15.88,105.55 16.99,106.66 16.99,107.83 17.39,108.23 18.59,108.23
+3.3V_RUN_UT9 on IN2: 17.83,105.81 17.43,106.21 17.43,111.49 16.68,112.24 16.68,118.13 17.19,118.64 18.33,118.64 18.33,118.63 18.68,118.29 18.68,112.41 19.81,111.28 19.81,110.4 19.6,110.2 19.1,110.2 18.84,109.94 18.84,108.04 19.99,106.9 21.64,106.9 21.95,106.58 22.08,106.58 23.16,105.5 23.16,104.74 22.91,104.48 22.4,104.99 21.95,104.99 21.76,105.18 21.76,105.5 21.46,105.81
+3.3V_RUN_UZ3 on TOP (solid shape): outline of 117 points within 195.68,4.8 199.64,9.02
+3.3V_SPI on BOTTOM: 227.39,14.91 228.13,14.91 228.55,14.49 228.55,14.13 228.47,14.06 227.61,14.06 227.35,14.31 227.35,14.87
+3.3V_TBTA_FLASH on BOTTOM (solid shape): 29.82,88.76 30.56,88.76 30.63,88.7 30.63,88.63 30.65,88.58 30.65,88.5 30.6,88.41 30.5,88.41 30.34,88.44 30.19,88.35 29.04,88.35 29,88.31 28.98,88.31 28.57,87.9 27.36,87.9 27.35,87.91 27.35,88.8 27.48,88.92 29.66,88.92
+3.3V_TP on TOP (solid shape): 140.15,10.97 141.38,10.97 141.47,10.87 141.47,9.6 141.05,9.18 141.05,8.36 141.03,8.33 140.47,8.33 140.39,8.4 139.76,8.4 139.58,8.58 139.58,10.94 139.71,11.06 140.06,11.06
+3.3V_VDD_DCI on TOP: 19.45,113.21 19.48,113.18 19.48,112.86 19.41,112.8 19.1,112.8 18.59,113.31 18.27,113.31 18.21,113.37 18.21,114.77 18.33,114.9 18.78,114.9 18.84,114.83 18.84,114.2 19.45,113.59
+3.3V_VDD_DCIN on BOTTOM (solid shape): 74.34,111.53 74.34,111.02 73.35,110.03 71.17,110.03 70.71,110.49 70.71,110.9 70.81,111 72.13,111 72.89,111.76 74.11,111.76
+3.3V_VDD_PIC on TOP (solid shape): 22.9,97.66 23.75,97.66 25.7,95.71 25.7,95 25.65,94.94 25.02,94.94 23.19,96.77 22.51,96.77 18.95,100.33 18.95,100.69 19.27,101.01 19.55,101.01
+3.3V_VDD_PIC on TOP (solid shape): 25.47,87.25 25.47,85.58 25.46,85.54 25.42,85.53 25.3,85.53 25.3,85.09 25.42,85.09 25.46,85.08 25.47,85.04 25.47,84.56 25.68,84.35 25.68,83.74 25.42,83.49 25.4,83.49 23.95,82.04 19.5,82.04 19.12,82.42 19.12,82.81 19.11,82.82 19.11,85.22 19.22,85.32 19.5,85.32 19.59,85.23 19.59,83.85 19.59,83.84 19.55,83.69 19.59,83.55 19.59,83.54 19.59,82.84 19.6,82.83 19.6,82.73 19.83,82.5 22.45,82.5 24.13,84.18 24.13,87.52 24.51,87.9 24.82,87.9
+3.3V_VDD_PIC on BOTTOM (solid shape): 19.93,100.72 19.93,99.99 19.7,99.77 18.21,99.77 18.13,99.85 18.13,100.82 18.13,100.82 19.82,100.82
+3.3V_VDD_PIC on BOTTOM (solid shape): 18.09,104.19 18.09,103.18 17.86,102.91 17.97,102.58 17.61,102.22 17.13,102.22 16.74,102.61 16.74,102.83 17.03,103.12 17.03,104.13 17.03,104.18 17.1,104.25 18.03,104.25
