# Allegro board LA-F711P R05-0112.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CSN_1PH_R: length 6.5
  TOP w0.203: PU1700.48 62.18,83.19 62.29,83.08 v2(62.92,83.08) 63.21,83.37 PC1704.1 63.72,83.05 PC1705.1 PC1701.1 64.76,82.37 PR1703.2
CSON_ISL88738: length 5
  TOP w0.203: v2(7.27,30.21) 7.27,30.7 7.49,30.92 7.95,30.92 8.41,31.38 PU901.1
  BOTTOM w0.203: PR938.1 6.87,28.69 PC945.2 6.87,29.81 v2(7.27,30.21) PC946.1
CSOP_ISL88738: length 6
  TOP w0.203: v2(7.97,30.45) 7.97,30.46 8.68,31.18 8.68,31.18 8.81,31.31 PU901.2
  BOTTOM w0.102: PR937.1 8.82,28.57 v1(9.41,27.99)
  BOTTOM w0.203: PC942.1 8.16,30.64 v2(7.97,30.45) 7.8,30.28 7.8,29.51 PC945.1 7.78,28.76 PR937.1
CSP1_2PH: length 8.5
  TOP w0.203: PR1763.1 51.9,73.01 v1(51.9,74.03) 51.9,75.58 PR1776.2 52.43,76.11 PC1734.2 53.25,77.81 54.16,77.81 54.95,78.6 55.17,78.6 55.33,78.76 PU1700.28
CSP1_4PH: length 11.2
  TOP w0.203: PU1700.11 55.73,86.11 54.71,87.13 54.28,87.13 54.12,87.29 v2(54.12,87.71) PC1733.2
  BOTTOM w0.152: PR1757.2 54.87,91.34 54.12,90.59 v1(54.12,88.7) v2(54.12,87.71) 54.17,87.71 PR1772.2
CSP2_4PH: length 13
  TOP w0.203: PC1735.2 v2(53.23,87.7) 53.23,87.34 v1(53.92,86.66) 54.71,86.66 55.33,86.03 PU1700.12
  BOTTOM w0.152: PR1773.2 53.89,87.04 v2(53.23,87.7) 53.23,90.84 54.75,92.35 PR1764.2
CSP3_4PH: length 14.4
  TOP w0.203: PC1736.2 52.47,88.21 v2(52.47,87.69) 52.47,87.21 v1(52.59,87.1) 53.56,86.12 54.69,86.12 54.93,85.88 PU1700.13
  BOTTOM w0.152: PR1765.2 55.29,93.37 52.35,90.43 52.35,87.81 v2(52.47,87.69) 52.88,87.28 PR1774.2
CSP4_4PH: length 26.3
  TOP w0.152: PC1737.2 53.04,90.21 v1(52.14,90.21) 51.35,89.42 v2(51.35,87.65)
  TOP w0.203: v2(53.5,79.33) 53.5,79.58 53.91,79.99 PU1700.26
  IN1 w0.203: v2(53.5,79.33) 53.64,79.47 53.64,85.62 51.61,87.65 v2(51.35,87.65)
  BOTTOM w0.102: v2(51.35,87.65) 50.97,87.27 PR2007.2 50.99,86.97 PR1775.2
  BOTTOM w0.152: v2(51.35,87.65) 51.86,88.16 51.86,90.48 55.77,94.39 PR1766.2
CSP_1PH: length 11.3
  TOP w0.102: v2(64.68,81.46) 65.87,81.46 v1(66.14,81.19)
  TOP w0.203: PC1705.2 62.66,81.46 62.43,81.68 62.43,82.47 62.11,82.79 PU1700.47 ; PC1705.2 63.04,81.45 PR1701.2 ; PC1705.2 PC1701.2 v2(64.68,81.46)
  BOTTOM w0.203: v2(64.68,81.46) 65.96,82.74 65.96,83.77 65.95,83.78 PR1702.1
CSREF_2PH: length 16.4
  TOP w0.102: v2(53.65,75.45) 53.25,75.05 v1(52.85,75.05)
  TOP w0.203: PU1700.29 55.73,78.32 v2(55.67,78.26) 55.5,78.1 54.91,78.1 54.3,77.48 53.84,77.48 PC1734.1 53.35,76.11 PR1776.1 53.34,75.77 v2(53.65,75.45)
  BOTTOM w0.203: v2(55.67,78.26) 56.59,79.18 PC1727.1 ; v2(53.65,75.45) 54.47,75.45 55.02,74.9 55.02,69.17 PR2002.2
CSREF_4PH: length 62.8
  TOP w0.152: PC1733.1 54.62,88.75 54.62,87.79 v1(55,87.42) 55.19,87.42 v2(56.04,86.57) ; PC1733.1 54.12,90.03 PC1737.1 ; PC1733.1 PC1735.1 PC1736.1
  TOP w0.203: PU1700.10 56.13,86.48 v2(56.04,86.57)
  TOP w0.254: PR1806.2 86.85,92.47 86.85,92.19 v2(87.08,91.96) ; PR1906.2 v2(97.72,90.69) ; PR1902.2 v2(91.91,90.67) ; PR1802.2 76.88,90.17 v2(77.36,90.65)
  IN3 w0.152: v2(97.72,90.69) 97.28,90.69 96.86,91.11 92.34,91.11 v2(91.91,90.67) 91.88,90.7 88.34,90.7 v2(87.08,91.96) 85.91,91.96 84.65,90.7 77.42,90.7 v2(77.36,90.65) 77.15,90.44 75.55,90.44 75.23,90.75 72.08,90.75 69.07,87.74 66.54,87.74 64.5,85.7 56.9,85.7 v2(56.04,86.57)
  BOTTOM w0.152: PR1775.1 PR1774.1 PR1773.1 PR1772.1 55.11,86.05 55.72,85.45 PC1723.2 56.31,86.3 v2(56.04,86.57)
CSSUM_2PH: length 9.5
  TOP w0.102: v1(54.48,72.92) 54.17,73.23 PR1749.1
  TOP w0.203: PU1700.30 56.13,77.99 55.9,77.76 55.04,77.76 PC1728.2 54.25,76.09 PC1726.2 54.24,75.68 54.28,75.64 PR1748.2 54.03,74.95 53.11,74.03 PR1749.1
CSSUM_4PH: length 15.6
  TOP w0.102: PR1752.2 v1(57.01,97.14)
  TOP w0.203: PC1725.1 55.11,88.19 56.53,86.78 PU1700.9 ; PR1747.2 56.58,91.55 PR1746.2 56.06,91.87 55.82,92.11 54.72,92.11 54.57,91.96 54.57,89.73 55.03,89.26 PC1724.2
  TOP w0.254: PR1752.2 PR1751.2 PR1750.2 PR1747.2 ; PC1725.1 55.1,88.4 PC1724.2
CV2_ON: length 43.2
  TOP w0.102: RE539.2 329.75,37.95 v1(329.59,37.79) 329.14,37.35 329.14,36.84 329.37,36.61 v2(329.54,36.61)
  IN3 w0.102: v2(318.55,23.66) 318.99,24.1 319.99,24.1 320.52,24.64 321.65,24.64 323.74,26.73 323.74,27.3 325.29,28.85 325.29,30.55 327.43,32.68 328.09,32.68 329.03,33.62 329.03,34.58 329.43,34.99 329.43,36.5 329.54,36.61 v2(329.54,36.61)
  BOTTOM w0.102: JUSH1.3 311.33,7.77 311.95,7.15 313.14,7.15 314.39,8.39 314.51,8.39 314.75,8.63 314.75,11.34 318.18,14.77 318.18,22.99 318.55,23.35 v2(318.55,23.66)
CV2_ON_R: length 22.5
  TOP w0.102: RPE10.4 326.26,45.29 326.44,45.11 327.43,45.11 327.53,45.21 328.47,45.21 328.57,45.11 328.57,41.49 v1(328.97,41.09) 329.75,40.31 RE539.1 329.29,39.26 329.29,38.08 328.69,37.48 328.02,37.48 328,37.51 326.83,37.51 326.68,37.36 325.5,37.36 324.99,36.85 324.99,36.76 323.69,35.45 323.68,35.45 323.43,35.2 320.12,35.2 319.66,34.75 UE1.H8
DAT_DDC2_CRT: length 59.6
  TOP w0.107: v2(329.36,68.6) 329.1,68.35 328.85,68.35 328.73,68.47 UV6.16
  IN1 w0.099: v2(360.2,103.39) 359.91,103.1 359.91,100.49 358.5,99.08 353.15,99.08 341.46,87.4 341.46,86.04 340.88,85.45 339.46,85.45 333.62,79.61 333.62,72.6 332.2,71.18 332.14,71.18 332.14,71.17 329.99,71.17 329.36,70.54 v2(329.36,68.6)
  BOTTOM w0.107: RV119.1 359.66,102.81 360.2,103.35 v2(360.2,103.39) 360.25,103.39 v1(360.81,102.83) JCRT1.12
DAT_TP_SIO_I2C_CLK: length 223.5
  TOP w0.107: UE1.C12 v2(322.92,39.15)
  IN1 w0.099: v2(320.53,19.85) 320.53,20.22 322.04,21.74 322.5,21.74 324.32,23.56 324.32,25.68 323.77,26.23 323.77,27.12 324.16,27.51 324.16,34.42 324.47,34.73 324.47,37.52 322.92,39.06 v2(322.92,39.15)
  BOTTOM w0.107: v2(320.53,19.85) 320.3,19.85 319.68,19.23 319.68,14.86 315.65,10.83 315.65,8.49 314.84,7.68 314.68,7.68 313.13,6.13 312.61,6.13 309.15,2.67 293.23,2.67 291.78,4.12 288.22,4.12 285.88,1.78 278.76,1.78 275.97,4.57 275.97,5.7 273.83,7.84 271.34,7.84 268.56,5.07 267.48,5.07 264.14,1.73 192.52,1.73 191.69,2.56 191.69,6.32 189.11,8.89 189.11,12.93 187.97,14.08 184.12,14.08 183.55,14.64 177.9,14.64 177.2,13.95 177.2,12.66 176.74,12.19 175.12,12.19 174.53,12.78 174.13,12.78 171.54,12.78 170.92,12.16 160.59,12.16 156.58,8.15 156.36,8.15 155.27,9.25 CZ80.1 153.49,9.25 RZ347.2 RZ22.2
DAT_TP_SIO_R: length 15.7
  BOTTOM w0.107: RZ22.1 152.33,8.11 151.02,8.11 RZ18.2 150.45,7.98 149.62,7.98 CZ88.1 148.84,7.9 147.55,7.9 146.73,8.72 146.73,10.11 145.62,11.23 v1(143.32,11.23) 141.12,11.23 140.52,10.62 JKBTP1.8
DCI_CLK: length 7.9
  TOP w0.102: RT307.2 16.18,118.69 16.18,118.33 16.87,117.63 16.87,116.8 18.18,115.5 v2(18.18,115.31)
  BOTTOM w0.102: v2(18.18,115.31) 18.4,115.09 18.4,114.6 19.41,113.59 19.41,113.56 19.63,113.35 UT9.50
DCI_DATA: length 7.5
  TOP w0.102: v2(18.78,115.34) 18.46,115.66 18.4,115.66 17.26,116.8 v1(17.26,117.56) 17.26,117.63 16.43,118.45 16.43,118.69 RT306.2
  BOTTOM w0.102: v2(18.78,115.34) 18.65,115.21 18.65,114.71 19.66,113.7 UT9.51
DCIN1_EN: length 348.1
  TOP w0.104: UE1.K4 v2(315.72,32.75)
  TOP w0.254: v2(69.21,107.35) 69.21,107.42 68.7,107.92 PR1221.1
  IN2 w0.102: v2(324.41,50.55) 323.95,50.09 321.53,50.09 318.9,52.72 308.69,52.72 308.04,53.36 304.53,53.36 300.59,49.42 287.45,49.42 281.3,43.27 275.57,43.27 273.79,41.49 272.95,41.49 271.31,41.07 270.25,40.02 267.82,40.02 267.28,39.47 265.96,39.47 265,38.51 253.26,38.51 253.12,38.65 250.85,38.65 249.65,39.84 245.23,39.84 243.67,41.4 240.14,41.4 235.4,46.14 234.93,46.14 222.53,58.55 217.34,58.55 211.76,64.14 211.76,85.88 179.75,117.88 126.31,117.88 121.92,113.49 88.42,113.49 87.31,114.6 86.58,114.6 86.48,114.5 86.48,112.18 87.56,111.11 87.56,109.91 85.77,108.13 78.79,108.13 76.65,105.99 72.77,105.99 72.14,105.36 68.18,105.36 67.22,106.32 67.22,107.3 67.72,107.8 68.84,107.8 69.21,107.43 v2(69.21,107.35)
  IN3 w0.102: v2(315.72,32.75) 316.14,33.17 317.48,33.17 317.72,33.42 317.72,34.49 318.05,34.82 318.05,35.06 319.14,36.14 319.14,39.28 320.59,40.74 320.59,42.08 322.96,44.44 322.96,47.52 324.41,48.97 v2(324.41,50.55)
DCIN2_EN: length 341.9
  TOP w0.102: v2(326.08,50.75) 326.08,50.4 v1(327.55,48.94) 329.28,47.2 329.28,45.81 328.8,45.33 328.8,41.76 330.27,40.29 330.27,37.86 v2(329.61,37.19)
  TOP w0.104: UE1.L12 v2(322.12,31.95)
  TOP w0.254: v2(82.6,118.64) 81.17,118.64 80.15,117.61 PR26.1
  IN2 w0.102: v2(322.12,31.95) 322.55,31.95 323.21,32.61 323.21,33.75 324.42,34.96 327.27,34.96 327.44,35.12 330.59,35.12 330.83,35.37 330.83,36.91 330.59,37.15 329.65,37.15 v2(329.61,37.19) ; v2(326.08,50.75) 326,50.75 325.41,51.35 321.64,51.35 318.31,54.67 316.43,54.67 315.9,55.21 315.9,56.87 316.43,57.4 319.13,57.4 v2(320.19,58.46)
  BOTTOM w0.102: v2(320.19,58.46) 319.92,58.19 311.07,58.19 310.24,57.37 299.79,57.37 296.55,54.13 289.58,54.13 279.4,43.94 278.46,43.94 264.94,38.33 250.26,38.33 249.15,39.45 244.61,39.45 241.61,42.45 240.43,42.45 238.46,44.41 236.44,44.41 222.25,58.6 217.28,58.6 212.57,63.31 212.57,76.98 196.13,93.42 175.93,93.42 147.14,122.21 126.34,122.21 124.1,119.96 100.55,119.96 98.51,117.92 83.32,117.92 v2(82.6,118.64)
DCIN3_EN: length 1.1
  TOP w0.102: UE1.J6 v2(317.32,33.55)
  BOTTOM w0.102: v2(317.32,33.55) 316.93,33.93 T262.1
DCIN_ISL88738: length 2.8
  BOTTOM w0.102: v1(14.26,38.42) 13.99,38.68 v2(13.25,38.68)
  BOTTOM w0.508: PR916.1 12.61,38.04 v2(13.25,38.68)
DDR4_DRAMRST#_PCH: length 196
  TOP w0.089: 213.56,13.88 213.54,13.9 213.54,13.99 212.56,14.98 212.56,15.37 212.35,15.58 212.35,18.5 v2(213.14,19.28)
  TOP w0.107: v2(214.82,6.51) 215.14,6.84 215.14,10.33 213.41,12.06 213.41,13.23 213.56,13.39 213.56,13.88 ; v2(51.35,12.55) 51.25,12.65 51.25,13.94 51.88,14.57 RD11.2 RD12.2
  IN3 w0.102: v2(214.82,6.51) 214.7,6.4 204.72,6.4 201.49,9.64 198.45,9.64 195.97,12.12 195.28,12.12 188.72,18.67 182.01,18.67 179.37,16.03 177.14,16.03 174.98,13.87 169.87,13.87 169.64,13.64 153.92,13.64 153.36,13.08 153.36,12.6 152.73,11.96 138.71,11.96 138.12,12.55 137.23,12.55 136.17,11.48 110.5,11.48 109.36,12.62 106.58,12.62 105.61,13.59 105.43,13.77 99.79,13.77 99.26,14.3 94.61,14.3 94.08,13.77 88.25,13.77 87.66,13.18 84.29,13.18 82.49,11.37 65.69,11.37 65.27,11.79 62.41,11.79 62.11,12.08 51.72,12.08 51.35,12.45 v2(51.35,12.55)
  BOTTOM w0.089: UH1.BB46 213.21,20.67 213.12,20.58 213.12,20.31 213.04,20.23 213.04,19.38 v2(213.14,19.28)
DDR_A_ACT#: length 67.4
  IN3 w0.076: v2(93.01,51.33) 93.06,51.28 93.06,47.95 92.44,47.33
  IN3 w0.152: v2(54.46,17.1) 54.46,17.38 55.02,17.94 55.02,19.27 54.31,19.98 54.31,23.7 65.93,35.32 81.72,35.32 92.3,45.9 92.3,47.19 92.44,47.33
  BOTTOM w0.076: UC1.AU3 93.33,54.15 93.33,53.01 93.44,52.89 93.44,51.76 v2(93.01,51.33)
  BOTTOM w0.168: v2(54.46,17.1) 55.64,15.92 55.64,15.73 56.47,14.9 JDIMM1.114
DDR_A_ALERT#: length 78.5
  IN1 w0.076: 84.45,60.55 84.58,60.43 86.41,60.43 86.51,60.32 91.43,60.32 92.27,59.48 v2(92.27,56.79)
  IN1 w0.152: v2(56.21,16.43) 56.52,16.75 56.52,37.42 66.77,47.68 66.77,53.76 68.79,55.78 72.06,55.78 75.57,59.28 76.16,59.28 78.15,61.27 81.55,61.27 81.64,61.18 82.17,61.18 82.21,61.23 83.78,61.23 84.45,60.55
  BOTTOM w0.076: UC1.AU5 93.14,56.29 93.14,56.49 92.84,56.79 v2(92.27,56.79)
  BOTTOM w0.168: JDIMM1.116 56.97,16 56.54,16.43 v2(56.21,16.43)
DDR_A_BA0: length 73.6
  IN3 w0.076: 102.4,44.41 102.4,44.62 101.49,45.52 101.49,51.27 100.78,51.98 v2(100.31,51.98)
  IN3 w0.152: 102.4,44.41 102.4,40.77 94.59,32.96 94.59,32.53 94.73,32.39 94.73,32.17 94.51,31.95 94.3,31.95 94.09,32.16 93.88,32.16 93.66,31.94 93.66,31.73 93.86,31.52 93.86,31.31 93.65,31.09 93.43,31.09 93.23,31.3 93.01,31.3 92.8,31.08 92.8,30.86 93,30.66 93,30.44 92.79,30.23 92.57,30.23 92.37,30.43 92.15,30.43 91.94,30.22 91.94,30 92.14,29.8 92.14,29.58 91.92,29.37 91.71,29.37 91.5,29.57 91.29,29.57 91.07,29.35 91.07,29.14 91.28,28.93 91.28,28.72 91.06,28.5 90.85,28.5 90.7,28.65 90.49,28.65 90.27,28.43 90.27,28.22 90.41,28.07 90.41,27.86 90.2,27.64 89.98,27.64 89.92,27.71 89.7,27.71 89.49,27.49 89.49,27.27 89.55,27.21 89.55,26.99 88.62,26.07 70.42,26.07 68.6,24.25 68.6,22.7 67.38,21.48 67.38,16.67 67.49,16.55 v2(67.84,16.55)
  BOTTOM w0.076: v2(100.31,51.98) 100.7,52.38 100.7,55.28 UC1.AH5
  BOTTOM w0.168: v2(67.84,16.55) 67.31,16.02 67.31,15.26 67.47,15.1 JDIMM1.150
DDR_A_BA1: length 68.3
  IN3 w0.076: 101.48,44.07 101.48,44.34 101.02,44.79 101.02,49.33 v2(100.29,50.06)
  IN3 w0.152: 101.48,44.07 101.48,42.02 101.06,41.6 101.06,41.39 101.26,41.18 101.26,40.97 101.05,40.75 100.83,40.75 100.63,40.96 100.41,40.96 100.2,40.74 100.2,40.52 100.4,40.32 100.4,40.11 100.19,39.89 99.97,39.89 99.77,40.09 99.55,40.09 99.34,39.88 99.34,39.66 99.54,39.46 99.54,39.24 99.32,39.03 99.11,39.03 98.9,39.23 98.69,39.23 98.47,39.01 98.47,38.8 98.68,38.6 98.68,38.38 98.46,38.16 98.25,38.16 98.04,38.37 97.83,38.37 97.61,38.15 97.61,37.94 97.81,37.73 97.81,37.52 97.6,37.3 97.38,37.3 97.18,37.51 96.96,37.51 96.75,37.29 96.75,37.07 96.95,36.87 96.95,36.65 96.74,36.44 96.52,36.44 96.32,36.64 96.1,36.64 95.88,36.43 95.88,36.21 96.09,36.01 96.09,35.79 95.87,35.58 95.66,35.58 95.45,35.78 95.24,35.78 95.02,35.56 95.02,35.35 95.23,35.15 95.23,34.93 95.01,34.71 94.79,34.71 94.59,34.92 94.38,34.92 94.16,34.7 94.16,34.49 94.36,34.28 94.36,34.07 94.15,33.85 93.93,33.85 93.73,34.06 93.51,34.06 93.3,33.84 93.3,33.62 93.5,33.42 93.5,33.2 93.29,32.99 93.07,32.99 92.87,33.19 92.65,33.19 92.38,32.92 92.38,32.7 92.53,32.55 92.53,32.34 92.31,32.12 92.1,32.12 91.95,32.27 91.73,32.27 91.52,32.06 91.52,31.84 91.67,31.69 91.67,31.47 91.45,31.26 91.24,31.26 91.08,31.41 90.87,31.41 86.44,26.98 70.04,26.98 67.2,24.14 67.2,22.6 66.25,21.64 v2(66.25,20.97)
  BOTTOM w0.076: UC1.AH1 101.2,52.04 100.93,51.77 100.93,50.71 v2(100.29,50.06)
  BOTTOM w0.168: v2(66.25,20.97) 66.22,21 JDIMM1.145
DDR_A_BG0: length 68.4
  IN3 w0.076: v2(92.17,51.76) 92.63,51.31 92.63,50.93 92.83,50.72 92.83,48.37 91.84,47.38 91.84,47.33
  IN3 w0.152: 91.84,47.33 91.84,46.09 81.53,35.78 65.74,35.78 53.85,23.89 53.85,18.81 54.4,18.26 v2(54.51,18.26)
  BOTTOM w0.076: UC1.AU1 93.66,51.42 93.13,50.89 92.89,50.89 92.58,51.21 92.58,51.36 v2(92.17,51.76)
  BOTTOM w0.168: v2(54.51,18.26) 54.53,18.26 55.39,19.13 55.39,19.96 56.72,21.29 JDIMM1.115
DDR_A_BG1: length 69.1
  IN3 w0.076: 91.38,47.33 91.38,47.39 92.58,48.59 92.58,50.34 92.38,50.55 v2(92.17,50.55)
  IN3 w0.152: 91.38,47.33 91.38,46.28 81.34,36.24 65.55,36.24 53.39,24.08 53.39,23.7 53.39,18.86 v2(52.66,18.12)
  BOTTOM w0.076: UC1.AU2 93.94,53.54 93.94,51.37 92.96,50.39 92.33,50.39 v2(92.17,50.55)
  BOTTOM w0.168: JDIMM1.113 56.22,21.48 55.8,21.06 55.63,21.06 52.73,18.15 52.68,18.15 v2(52.66,18.12)
DDR_A_CKE0: length 78.1
  IN3 w0.152: v2(52.71,19.65) 52.61,19.65 52.33,19.93 52.33,21.2 52.61,21.48 52.61,21.78 52.45,21.94 51.25,21.94 51.1,22.09 51.1,22.38 51.26,22.55 52.45,22.55 52.61,22.7 52.61,23.05 52.45,23.2 52,23.2 51.84,23.37 51.84,23.65 52.03,23.84 52.42,23.84 52.57,23.99 52.57,24.38 65.21,37.02 65.78,37.02 65.93,37.18 65.93,37.4 66.08,37.55 66.43,37.55 66.58,37.39 66.58,37.18 66.73,37.02 67.04,37.02 67.19,37.18 67.19,37.39 67.34,37.55 67.65,37.55 67.8,37.39 67.8,37.18 67.95,37.02 68.25,37.02 68.41,37.18 68.41,37.39 68.56,37.55 68.86,37.55 69.02,37.39 69.02,37.18 69.17,37.02 69.47,37.02 69.63,37.18 69.63,37.39 69.78,37.55 70.08,37.55 70.24,37.39 70.24,37.18 70.39,37.02 70.69,37.02 70.85,37.18 70.85,37.39 71,37.55 71.3,37.55 71.46,37.39 71.46,37.18 71.61,37.02 71.91,37.02 72.06,37.18 72.06,37.39 72.22,37.55 72.5,37.55 72.65,37.39 72.65,37.18 72.8,37.02 73.11,37.02 73.26,37.18 73.26,37.39 73.41,37.55 73.72,37.55 73.87,37.39 73.87,37.18 74.02,37.02 74.33,37.02 74.48,37.18 74.48,37.39 74.63,37.55 74.92,37.55 75.08,37.39 75.08,37.18 75.23,37.02 75.53,37.02 75.69,37.18 75.69,37.39 75.84,37.55 76.14,37.55 76.3,37.39 76.3,37.18 76.45,37.02 76.75,37.02 76.91,37.18 76.91,37.39 77.06,37.55 77.36,37.55 77.52,37.39 77.52,37.18 77.67,37.02 77.97,37.02 78.13,37.18 78.13,37.39 78.28,37.55 78.58,37.55 78.73,37.39 78.73,37.18 78.89,37.02 79.19,37.02 79.34,37.18 79.34,37.39 79.5,37.55 81.54,37.55 89.92,45.93 89.92,46.34 90.07,46.49 90.46,46.49 90.6,46.63 90.6,46.92 90.46,47.05 90.34,47.05 90.19,47.21 90.19,47.56 90.36,47.73 90.7,47.73 91.13,48.16 91.13,48.84 91.28,48.99 91.8,48.99 v2(92.07,48.72)
  BOTTOM w0.076: UC1.AT1 94.46,53.11 94.46,50.75 92.43,48.72 v2(92.07,48.72)
  BOTTOM w0.168: JDIMM1.109 55.22,21.26 53.61,19.65 v2(52.71,19.65)
DDR_A_CKE1: length 77
  IN3 w0.152: v2(92.2,49.96) 90.69,49.96 90.54,49.81 90.54,48.56 89.46,47.48 89.46,46.12 81.35,38 65.55,38 50.64,23.1 50.64,21.51 50.93,21.22 51.72,21.22 51.87,21.07 51.87,20.77 51.72,20.61 50.93,20.61 50.78,20.46 50.78,20.16 50.93,20 51.72,20 51.87,19.85 51.87,19.55 51.72,19.4 50.93,19.4 50.78,19.24 50.78,18.94 50.93,18.79 51.72,18.79 51.87,18.63 51.87,18.33 51.72,18.18 51.09,18.18 50.91,18 50.91,17.69 51.06,17.54 v2(52.66,17.54)
  BOTTOM w0.076: UC1.AT2 94.1,53.53 94.1,51.3 92.73,49.94 92.22,49.94 v2(92.2,49.96)
  BOTTOM w0.168: JDIMM1.110 55.47,15.09 55.11,15.44 54.4,15.44 52.66,17.18 v2(52.66,17.54)
DDR_A_CLK0: length 83.6
  IN3 w0.076: 99.81,46.35 99.81,46.37 99.8,46.39 99.8,46.48 99.96,46.64 99.96,46.88 99.6,47.24 99.25,47.24 v2(99.09,47.39)
  IN3 w0.089: 99.81,46.35 99.81,42.87 98.41,41.47 98.12,41.47 97.79,41.8 97.66,41.8 97.47,41.61 97.47,41.48 97.8,41.15 97.8,40.86 97.5,40.56 97.21,40.56 96.88,40.89 96.75,40.89 96.56,40.7 96.56,40.58 96.9,40.24 96.9,39.96 96.6,39.66 96.31,39.66 95.98,39.99 95.85,39.99 95.66,39.8 95.66,39.67 95.99,39.34 95.99,39.05 95.65,38.71 95.37,38.71 95.03,39.05 94.91,39.05 94.72,38.86 94.72,38.73 95.05,38.4 95.05,38.11 94.75,37.81 94.46,37.81 94.13,38.14 94,38.14 93.81,37.95 93.81,37.83 94.15,37.49 94.15,37.2 93.84,36.9 93.55,36.9 93.22,37.23 93.1,37.23 92.91,37.04 92.91,36.92 93.24,36.59 93.24,36.3 92.94,35.99 92.65,35.99 92.31,36.33 92.19,36.33 92,36.14 92,36.01 92.33,35.68 92.33,35.39 92.03,35.09 91.74,35.09 91.41,35.42 91.28,35.42 91.09,35.23 91.09,35.11 91.43,34.77 91.43,34.49 91.12,34.18 90.84,34.18 90.5,34.52 90.38,34.52 90.19,34.33 90.19,34.2 90.52,33.87 90.52,33.58 90.22,33.28 89.93,33.28 89.6,33.61 89.47,33.61 89.28,33.42 89.28,33.3 89.62,32.96 89.62,32.67 89.31,32.37 89.02,32.37 88.69,32.7 88.57,32.7 88.38,32.51 88.38,32.39 88.71,32.06 88.71,31.77 88.41,31.46 88.12,31.46 87.78,31.8 87.66,31.8 87.47,31.61 87.47,31.48 87.8,31.15 87.8,30.86 87.5,30.56 87.21,30.56 86.88,30.89 86.75,30.89 86.56,30.7 86.56,30.58 86.9,30.24 86.9,29.96 86.59,29.65 86.31,29.65 85.97,29.99 85.85,29.99 85.66,29.8 85.66,29.67 85.99,29.34 85.99,29.05 85.65,28.71 85.36,28.71 85.08,28.99 84.95,28.99 84.61,28.65 69.35,28.65 64.85,24.15 64.85,22.6 64.29,22.04 64.29,19.79 63.96,19.46 63.61,19.46 v2(63.41,19.27)
  BOTTOM w0.076: UC1.AG1 101.94,53.43 102.05,53.54 102.23,53.54 102.32,53.45 102.32,53.03 101.84,52.54 101.84,49.93 101.43,49.52 101.43,48.71 100.97,48.25 100.97,48 100.96,47.99 100.96,47.97
  BOTTOM w0.089: JDIMM1.137 62.22,21.31 62.35,21.18 62.35,19.76 62.61,19.51 63.18,19.51 v2(63.41,19.27) ; v2(99.09,47.39) 99.34,47.14 100.13,47.14 100.16,47.12 100.48,47.12 100.96,47.6 100.96,47.97
DDR_A_CLK1: length 81.9
  IN3 w0.089: v2(63.57,17.02) 63.57,16.77 63.42,16.62 63.22,16.62 63.01,16.42 63.01,15.66 62.91,15.56 62.78,15.56 62.7,15.65 62.7,17.25 62.81,17.36 62.81,17.77 62.44,18.14 62.1,18.14 62.01,18.23 62.01,18.49 62.1,18.59 62.55,18.59 62.75,18.79 62.75,20.81 63.6,21.66 63.6,22.33 64.16,22.89 64.16,24.43 69.06,29.34 84.22,29.34 97.64,42.76 97.77,42.76 98.09,42.44 98.38,42.44 98.68,42.74 98.68,43.03 98.34,43.37 98.34,43.52 98.4,43.58 98.92,43.58 99.12,43.78 99.12,44.18 98.92,44.39 98.43,44.39 98.34,44.47 98.34,44.76 98.43,44.84 98.89,44.84 99.12,45.08 99.12,45.51 98.92,45.71 98.5,45.71 98.34,45.86 98.34,48.52 98.43,48.6 99.66,48.6 99.93,48.88 99.93,49.69 99.74,49.89 99.38,49.89 99.15,49.65 98.46,49.65 98.34,49.78 98.34,51.07 98.43,51.16 98.55,51.16 98.72,51 98.9,51 99.04,50.86 v2(99.04,50.75)
  BOTTOM w0.076: UC1.AK2 99.42,53.78 98.97,53.32 98.97,52.83 98.89,52.76 98.42,52.76 98.24,52.58 98.24,52.21 98.17,52.15 97.65,52.15 97.48,51.97 97.48,50.74 97.65,50.57 98.11,50.57 98.28,50.74 98.28,51.05 98.36,51.13 98.47,51.13 98.71,50.89 98.91,50.89 v2(99.04,50.75)
  BOTTOM w0.089: v2(63.57,17.02) 63.37,16.82 63.24,16.82 62.91,17.15 62.63,17.15 62.42,16.94 62.42,16.2 62.33,16.12 62.07,16.12 61.87,15.92 61.87,15.36 62.07,15.16 62.53,15.16 62.58,15.11 62.58,15.01 62.47,14.9 JDIMM1.138
DDR_A_CLK#0: length 83.6
  IN3 w0.076: v2(99.09,46.76) 99.09,46.89 99.27,47.07 99.53,47.07 99.79,46.82 99.79,46.71 99.63,46.55 99.63,46.39 99.61,46.37 99.61,46.35
  IN3 w0.089: 99.61,46.35 99.61,42.95 98.33,41.66 98.2,41.66 97.87,41.99 97.58,41.99 97.27,41.69 97.27,41.4 97.61,41.07 97.61,40.94 97.42,40.76 97.29,40.76 96.96,41.09 96.67,41.09 96.37,40.78 96.37,40.5 96.7,40.16 96.7,40.04 96.52,39.85 96.39,39.85 96.06,40.19 95.77,40.19 95.47,39.88 95.47,39.59 95.8,39.26 95.8,39.14 95.57,38.91 95.45,38.91 95.11,39.24 94.83,39.24 94.52,38.94 94.52,38.65 94.86,38.32 94.86,38.19 94.67,38 94.54,38 94.21,38.34 93.92,38.34 93.62,38.03 93.62,37.74 93.95,37.41 93.95,37.29 93.76,37.1 93.64,37.1 93.3,37.43 93.01,37.43 92.71,37.13 92.71,36.84 93.04,36.5 93.04,36.38 92.85,36.19 92.73,36.19 92.4,36.52 92.11,36.52 91.8,36.22 91.8,35.93 92.14,35.6 92.14,35.47 91.95,35.28 91.82,35.28 91.49,35.62 91.2,35.62 90.9,35.31 90.9,35.03 91.23,34.69 91.23,34.57 91.04,34.38 90.92,34.38 90.58,34.71 90.3,34.71 89.99,34.41 89.99,34.12 90.33,33.79 90.33,33.66 90.14,33.47 90.01,33.47 89.68,33.81 89.39,33.81 89.09,33.5 89.09,33.21 89.42,32.88 89.42,32.76 89.23,32.57 89.1,32.57 88.77,32.9 88.48,32.9 88.18,32.6 88.18,32.31 88.51,31.97 88.51,31.85 88.32,31.66 88.2,31.66 87.87,31.99 87.58,31.99 87.27,31.69 87.27,31.4 87.61,31.07 87.61,30.94 87.42,30.75 87.29,30.75 86.96,31.09 86.67,31.09 86.37,30.78 86.37,30.5 86.7,30.16 86.7,30.04 86.51,29.85 86.39,29.85 86.05,30.18 85.77,30.18 85.46,29.88 85.46,29.59 85.8,29.26 85.8,29.13 85.57,28.9 85.44,28.9 85.16,29.19 84.87,29.19 84.53,28.85 69.27,28.85 64.65,24.23 64.65,22.68 64.09,22.13 64.09,19.87 63.88,19.66 63.62,19.66 63.4,19.87 v2(63.4,20.11)
  BOTTOM w0.076: 101.14,47.97 101.14,47.99 101.13,48 101.13,48.18 101.6,48.64 101.6,49.45 102,49.86 102,52.48 102.49,52.96 102.49,53.52 102.3,53.71 102.05,53.71 UC1.AG2
  BOTTOM w0.089: 101.14,47.97 101.14,47.53 100.55,46.94 100.09,46.94 100.06,46.96 99.29,46.96 v2(99.09,46.76) ; v2(63.4,20.11) 63.4,19.79 63.3,19.69 62.68,19.69 62.53,19.84 62.53,21.11 62.72,21.3 JDIMM1.139
DDR_A_CLK#1: length 81.8
  IN3 w0.089: v2(63.59,16.26) 63.42,16.43 63.3,16.43 63.21,16.34 63.21,15.58 62.99,15.37 62.7,15.37 62.5,15.57 62.5,17.33 62.61,17.44 62.61,17.69 62.36,17.95 62.02,17.95 61.81,18.15 61.81,18.57 62.02,18.78 62.47,18.78 62.56,18.87 62.56,20.89 63.4,21.74 63.4,22.41 63.96,22.97 63.96,24.51 68.98,29.54 84.14,29.54 97.56,42.95 97.85,42.95 98.17,42.63 98.3,42.63 98.49,42.82 98.49,42.95 98.15,43.28 98.15,43.6 98.32,43.77 98.84,43.77 98.92,43.86 98.92,44.1 98.84,44.19 98.35,44.19 98.15,44.39 98.15,44.84 98.35,45.04 98.81,45.04 98.92,45.16 98.92,45.43 98.83,45.52 98.42,45.52 98.15,45.78 98.15,48.6 98.35,48.8 99.61,48.8 99.76,48.95 99.76,49.62 99.67,49.71 99.45,49.71 99.2,49.46 98.38,49.46 98.15,49.69 98.15,51.15 98.35,51.36 98.63,51.36 98.8,51.19 98.85,51.19 v2(99.04,51.39)
  BOTTOM w0.076: UC1.AK1 99.42,53.26 99.34,53.34 99.22,53.34 99.13,53.26 99.13,52.76 98.96,52.59 98.48,52.59 98.41,52.51 98.41,52.15 98.24,51.98 97.72,51.98 97.65,51.9 97.65,50.81 97.72,50.74 98.04,50.74 98.12,50.81 98.12,51.12 98.29,51.29 98.53,51.29 98.77,51.05 98.85,51.05 99.04,51.25 v2(99.04,51.39)
  BOTTOM w0.089: JDIMM1.140 62.97,14.84 62.76,15.05 62.76,15.19 62.6,15.34 62.14,15.34 62.05,15.43 62.05,15.85 62.14,15.94 62.41,15.94 62.6,16.13 62.6,16.86 62.71,16.97 62.83,16.97 63.17,16.64 63.42,16.64 63.59,16.46 v2(63.59,16.26)
DDR_A_CS#0: length 78.2
  IN3 w0.076: v2(104.08,55.43) 104.54,54.97 104.54,53.59 102.11,51.16 102.11,46.37 104.1,44.38
  IN3 w0.152: 104.1,44.38 104.1,39.03 92.56,27.49 92.56,27.27 93.53,26.3 93.53,26.09 93.32,25.87 93.09,25.87 92.13,26.84 91.91,26.84 91.69,26.63 91.69,26.41 92.67,25.44 92.67,25.22 92.45,25.01 92.23,25.01 91.26,25.98 91.05,25.98 90.83,25.76 90.83,25.55 91.47,24.91 91.47,24.69 91.25,24.48 91.04,24.48 90.4,25.12 90.18,25.12 89.43,24.36 86.1,24.36 85.94,24.21 85.94,24 85.79,23.85 85.49,23.85 85.34,24 85.34,24.21 85.18,24.36 83.53,24.36 83.38,24.21 83.38,24 83.23,23.85 82.92,23.85 82.77,24 82.77,24.21 82.62,24.36 81.47,24.36 81.32,24.21 81.32,24 81.17,23.85 80.86,23.85 80.71,24 80.71,24.21 80.56,24.36 80.26,24.36 80.1,24.21 80.1,24 79.95,23.85 79.65,23.85 79.49,24 79.49,24.21 79.34,24.36 77.75,24.36 77.6,24.21 77.6,24 77.45,23.85 77.14,23.85 76.99,24 76.99,24.21 76.84,24.36 76.53,24.36 76.38,24.21 76.38,24 76.23,23.85 75.92,23.85 75.77,24 75.77,24.21 75.62,24.36 75.31,24.36 75.16,24.21 75.16,24 75.01,23.85 74.7,23.85 74.55,24 74.55,24.21 74.4,24.36 74.09,24.36 73.94,24.21 73.94,24 73.79,23.85 73.48,23.85 73.33,24 73.33,24.21 73.18,24.36 72.87,24.36 72.72,24.21 72.72,24 72.57,23.85 72.26,23.85 72.11,24 72.11,24.07 71.96,24.22 71.63,24.22 v2(71.5,24.35)
  BOTTOM w0.076: UC1.AD5 104.43,55.78 v2(104.08,55.43)
  BOTTOM w0.168: JDIMM1.149 67.22,23.23 67.46,23.47 67.46,24.51 67.66,24.71 71.14,24.71 v2(71.5,24.35)
DDR_A_CS#1: length 80.6
  IN3 w0.076: 105.03,44.41 105.03,44.58 102.89,46.71 102.71,46.71 102.46,46.96 102.46,47.97 v2(102.83,48.34)
  IN3 w0.152: v2(69.73,20.13) 69.73,19.91 69.88,19.76 70.53,19.76 70.68,19.91 70.68,21.03 72.46,22.81 72.84,22.81 72.84,22.81 91.55,22.81 96.99,28.25 96.99,28.83 97.41,29.25 97.41,29.39 96.69,30.11 96.69,30.33 96.94,30.58 97.16,30.58 98.13,29.61 98.35,29.61 98.56,29.83 98.56,30.04 97.59,31.01 97.59,31.23 97.81,31.44 98.02,31.44 98.99,30.47 99.21,30.47 99.42,30.69 99.42,30.9 98.45,31.88 98.45,32.09 98.67,32.31 98.88,32.31 99.86,31.34 100.07,31.34 100.29,31.55 100.29,31.77 99.32,32.74 99.32,32.95 99.53,33.17 99.75,33.17 100.72,32.2 100.93,32.2 101.15,32.41 101.15,32.63 100.18,33.6 100.18,33.82 100.38,34.01 100.59,34.01 101.56,33.04 101.78,33.04 101.99,33.26 101.99,33.47 101.02,34.45 101.02,34.66 105.03,38.66 105.03,44.41
  BOTTOM w0.076: UC1.AE2 103.41,53.52 103.41,52.49 102.42,51.49 102.42,48.75 v2(102.83,48.34)
  BOTTOM w0.168: JDIMM1.157 69.22,20.64 v2(69.73,20.13)
DDR_A_D0: length 81.3
  IN3 w0.097: v2(28.3,17.06) 28.6,17.36 28.6,21.13 28.9,21.44 28.9,23.26 45.08,39.44 45.21,39.44 45.5,39.15 45.69,39.15 45.8,39.26 45.8,39.39 45.49,39.71 45.49,39.85 45.62,39.98 45.76,39.98 46.07,39.67 46.21,39.67 46.33,39.78 46.33,39.96 45.92,40.37 45.92,40.51 46.71,41.3 46.84,41.3 47.27,40.87 47.41,40.87 48.2,41.66 49.2,41.66 59.2,51.66 60.09,51.66 66.31,57.88 72.76,57.88 75.41,55.23 v2(78.29,55.23)
  BOTTOM w0.076: v2(78.29,55.23) 78.29,55.82 78.96,56.49 79.61,56.49 79.69,56.41 80.04,56.41 80.09,56.47 80.92,56.47 UC1.BR6
  BOTTOM w0.107: v2(28.3,17.06) 29.97,15.39 JDIMM1.8
DDR_A_D1: length 81.1
  IN3 w0.097: v2(79.84,56.77) 79.41,57.2 79.27,57.2 78.05,55.98 75.51,55.98 72.97,58.52 66.04,58.52 59.79,52.26 58.96,52.26 49.02,42.33 46.16,42.33 36.2,32.36 36.2,32.23 36.49,31.93 36.49,31.8 36.35,31.66 36.22,31.66 35.92,31.95 35.79,31.95 35.65,31.82 35.65,31.68 35.94,31.39 35.94,31.25 35.81,31.11 35.67,31.11 35.38,31.41 35.24,31.41 35.1,31.27 35.1,31.13 35.4,30.84 35.4,30.7 35.26,30.57 35.13,30.57 34.83,30.86 34.69,30.86 34.56,30.73 34.56,30.59 34.85,30.29 34.85,30.16 34.72,30.02 34.58,30.02 34.3,30.3 34.14,30.3 34.02,30.17 34.02,30.04 34.31,29.75 34.31,29.61 27.76,23.06 27.76,19.78 v2(28.15,19.39)
  BOTTOM w0.076: UC1.BT6 v2(79.84,56.77)
  BOTTOM w0.107: v2(28.15,19.39) 29.13,20.37 29.13,20.62 29.72,21.21 JDIMM1.7
DDR_A_D2: length 80.3
  IN3 w0.076: v2(79.37,53.79) 79.37,53.79 78.77,53.79 78.44,53.46 77.94,53.46 77.67,53.19
  IN3 w0.097: v2(31.2,20.44) 31.2,20.81 31.67,21.29 31.67,23.92 36.42,28.67 37.25,28.67 37.39,28.81 37.39,28.94 37.11,29.22 37.11,29.36 37.29,29.54 37.42,29.54 37.7,29.26 37.84,29.26 37.98,29.39 37.98,29.53 37.7,29.81 37.7,29.95 37.83,30.08 37.97,30.08 38.25,29.8 38.39,29.8 38.52,29.94 38.52,30.08 38.24,30.36 38.24,30.49 38.38,30.63 38.52,30.63 38.8,30.35 38.93,30.35 39.07,30.49 39.07,30.62 38.79,30.9 38.79,31.04 38.93,31.18 39.06,31.18 39.34,30.9 39.48,30.9 39.61,31.03 39.61,31.17 39.34,31.45 39.34,31.58 39.47,31.72 39.61,31.72 39.89,31.44 40.02,31.44 40.16,31.58 40.16,31.72 39.88,31.99 39.88,32.13 40.02,32.27 40.16,32.27 40.43,31.99 40.57,31.99 40.71,32.13 40.71,32.26 40.43,32.54 40.43,32.68 40.57,32.81 40.7,32.81 40.98,32.53 41.12,32.53 41.25,32.67 41.25,32.81 40.97,33.09 40.97,33.22 41.11,33.36 41.25,33.36 41.53,33.08 41.66,33.08 41.8,33.22 41.8,33.35 41.52,33.63 41.52,33.77 45.27,37.52 46.17,37.52 48.82,40.17 49.82,40.17 59.82,50.17 60.85,50.17 67.07,56.39 72.08,56.39 75.36,53.11 77.59,53.11 77.67,53.19
  BOTTOM w0.076: v2(79.37,53.79) 79.37,54.38 79.66,54.67 80.06,54.67 80.24,54.86 80.85,54.86 80.87,54.88 81.43,54.88 UC1.BP3
  BOTTOM w0.107: JDIMM1.17 32.22,21.28 31.38,20.44 v2(31.2,20.44)
DDR_A_D3: length 79.4
  IN3 w0.076: v2(78.88,53.27) 78.33,53.27 78,52.93
  IN3 w0.097: v2(31.2,18.86) 31.72,19.39 31.72,20.78 31.99,21.04 31.99,23.81 32.41,24.23 33.3,24.23 42.85,33.79 42.85,33.93 42.55,34.23 42.55,34.37 42.68,34.51 42.82,34.51 43.13,34.2 43.26,34.2 43.4,34.34 43.4,34.47 43.09,34.78 43.09,34.92 43.23,35.05 43.37,35.05 43.67,34.75 43.81,34.75 43.95,34.88 43.95,35.02 43.64,35.33 43.64,35.46 43.78,35.6 43.91,35.6 44.22,35.29 44.36,35.29 44.49,35.43 44.49,35.57 44.19,35.87 44.19,36.01 44.32,36.15 44.46,36.15 44.77,35.84 44.9,35.84 45.04,35.97 45.04,36.11 44.73,36.42 44.73,36.56 45.39,37.21 46.29,37.21 48.95,39.87 49.94,39.87 59.95,49.87 60.97,49.87 67.19,56.09 71.92,56.09 75.79,52.22 76.58,52.22 77.16,52.81 77.87,52.81 78,52.93
  BOTTOM w0.076: v2(78.88,53.27) 79.4,53.27 80.22,54.09 80.53,54.09 UC1.BR3
  BOTTOM w0.107: JDIMM1.21 33.22,21.08 31.2,19.06 v2(31.2,18.86)
DDR_A_D4: length 81.7
  IN3 w0.097: v2(28.34,15.51) 28.35,15.52 29.26,15.52 29.36,15.62 29.36,15.85 29.26,15.95 28.96,15.95 28.9,16.01 28.9,20.98 29.2,21.28 29.2,23.14 44.88,38.81 45.78,38.81 48.33,41.36 49.33,41.36 59.33,51.36 60.35,51.36 66.32,57.33 66.57,57.58 72.63,57.58 75.88,54.33 v2(77.39,54.33)
  BOTTOM w0.076: UC1.BN5 81.99,56.59 81.83,56.76 80.28,57.12 79.69,57.12 78.81,56.66 77.4,55.25 77.4,54.33 v2(77.39,54.33)
  BOTTOM w0.107: JDIMM1.4 28.97,15.07 28.53,15.51 v2(28.34,15.51)
DDR_A_D5: length 81.4
  IN3 w0.097: v2(28.18,20.91) 28.18,22.97 37.04,31.82 37.04,31.96 36.92,32.08 36.92,32.22 37.05,32.35 37.19,32.35 37.31,32.23 37.45,32.23 37.64,32.43 37.64,32.57 37.32,32.89 37.32,33.03 37.45,33.16 37.59,33.16 37.92,32.84 38.05,32.84 38.19,32.97 38.19,33.11 37.86,33.44 37.86,33.57 38,33.71 38.14,33.71 38.46,33.38 38.6,33.38 38.74,33.52 38.74,33.66 38.41,33.98 38.41,34.12 38.55,34.26 38.68,34.26 39.01,33.93 39.15,33.93 39.28,34.07 39.28,34.2 38.96,34.53 38.96,34.67 39.09,34.8 39.23,34.8 39.56,34.48 39.69,34.48 39.83,34.61 39.83,34.75 39.5,35.08 39.5,35.21 39.64,35.35 39.77,35.35 40.09,35.03 40.24,35.03 40.4,35.19 40.4,35.33 40.06,35.67 40.06,35.8 40.62,36.37 40.76,36.37 41.1,36.03 41.24,36.03 41.38,36.16 41.38,36.3 41.03,36.64 41.03,36.78 46.22,41.96 49.08,41.96 59.08,51.96 59.91,51.96 66.13,58.18 72.88,58.18 75.39,55.68 78.72,55.68 v2(78.73,55.67)
  BOTTOM w0.076: UC1.BP6 81.7,56.47 81.31,56.08 80.86,56.08 80.63,56.3 80.22,56.3 80.16,56.25 79.62,56.25 79.54,56.33 79.24,56.33 78.73,55.81 v2(78.73,55.67)
  BOTTOM w0.107: v2(28.18,20.91) 28.72,21.45 JDIMM1.3
DDR_A_D6: length 80.4
  IN3 w0.097: v2(31.04,15.58) 32.09,15.58 32.36,15.85 32.36,20.27 32.84,20.76 32.84,22.92 49.2,39.27 50.19,39.27 60.2,49.27 74.34,49.27 74.55,49.48 74.55,49.62 74.28,49.89 74.28,50.03 74.47,50.22 74.62,50.22 75.53,49.31 75.67,49.31 75.81,49.44 75.81,49.58 75.07,50.32 75.07,50.46 75.2,50.59 75.34,50.59 76.08,49.85 76.21,49.85 76.35,49.99 76.35,50.13 76.01,50.47 76.01,50.61 76.14,50.74 76.28,50.74 76.62,50.4 76.76,50.4 76.9,50.54 76.9,50.67 76.55,51.01 76.55,51.16 76.68,51.29 76.83,51.29 77.17,50.95 77.31,50.95 77.44,51.08 77.44,51.22 77.24,51.42 77.24,51.56 77.55,51.88 v2(78.23,51.88)
  BOTTOM w0.076: UC1.BP2 81.98,53.73 81.98,53.04 80.4,51.46 78.65,51.46 v2(78.23,51.88)
  BOTTOM w0.107: v2(31.04,15.58) 31.56,15.58 31.97,15.17 JDIMM1.16
DDR_A_D7: length 80
  IN3 w0.097: v2(81.87,55.09) 81.27,55.09 78.52,52.34 77.18,52.34 76.63,51.79 75.76,51.79 71.76,55.79 67.32,55.79 61.27,49.75 61.09,49.57 60.07,49.57 50.07,39.57 49.07,39.57 32.54,23.04 32.54,22.79 32.54,20.88 32.06,20.39 32.06,16.05 31.95,15.95 31.62,15.95 31.52,16.05 31.52,17.14 31.4,17.26 v2(31.08,17.26)
  BOTTOM w0.102: UC1.BN3 82.28,54.68 v2(81.87,55.09)
  BOTTOM w0.107: v2(31.08,17.26) 32.79,15.55 32.79,15.24 32.97,15.06 JDIMM1.20
DDR_A_D8: length 75.1
  IN3 w0.097: v2(83.97,54.8) 83.16,54 81.81,54 76.27,48.47 60.53,48.47 50.44,38.37 49.45,38.37 34.82,23.75 34.82,23.29 34.29,22.76 34.29,19.48 34.09,19.28 34.09,18.16 33.84,17.91 33.58,17.91 33.37,18.12 33.11,18.12 32.99,18.24 32.99,18.5 33.09,18.59 33.34,18.59 v2(33.43,18.51)
  BOTTOM w0.076: v2(83.97,54.8) 83.64,55.13 UC1.BL4
  BOTTOM w0.107: v2(33.43,18.51) 33.56,18.51 35.22,20.16 JDIMM1.29
DDR_A_D9: length 75.5
  IN3 w0.097: v2(83.97,55.45) 83.86,55.45 83.54,55.78 82.91,55.78 82.57,55.43 82.57,54.95 82.1,54.48 81.84,54.48 76.12,48.77 60.4,48.77 50.31,38.67 49.33,38.67 34.52,23.87 34.52,23.62 34.52,23.41 33.99,22.88 33.99,22.21 33.9,22.11 33.44,22.11 33.35,22.01 33.35,21.82 33.44,21.72 33.9,21.72 33.99,21.63 33.99,21.43 33.9,21.34 33.45,21.34 33.35,21.23 33.35,21.05 33.45,20.95 33.9,20.95 33.99,20.85 33.99,20.66 33.9,20.56 33.45,20.56 33.35,20.46 33.35,20.28 33.45,20.18 33.9,20.18 33.99,20.08 33.99,19.84 33.89,19.74 33.04,19.74 v2(32.8,19.98)
  BOTTOM w0.076: UC1.BL5 83.64,55.78 v2(83.97,55.45)
  BOTTOM w0.107: JDIMM1.25 34.22,21.07 33.13,19.98 v2(32.8,19.98)
DDR_A_D10: length 74.7
  IN3 w0.076: 80.29,49.43 80.29,49.62 81.53,50.86 v2(81.53,51.43)
  IN3 w0.097: v2(36.76,18.96) 37.2,19.41 37.2,22.07 37.55,22.41 37.55,23.46 42.66,28.57 42.8,28.57 43.16,28.21 43.29,28.21 43.43,28.35 43.43,28.48 43.07,28.84 43.07,28.98 43.21,29.11 43.34,29.11 43.7,28.76 43.84,28.76 43.98,28.89 43.98,29.03 43.62,29.39 43.62,29.52 43.75,29.66 43.89,29.66 44.25,29.3 44.39,29.3 44.52,29.44 44.52,29.57 44.16,29.93 44.16,30.07 44.3,30.21 44.44,30.21 44.79,29.85 44.93,29.85 45.07,29.98 45.07,30.12 44.71,30.48 44.71,30.62 44.85,30.75 44.98,30.75 45.34,30.39 45.48,30.39 45.61,30.53 45.61,30.67 45.26,31.03 45.26,31.16 45.39,31.3 45.53,31.3 45.89,30.94 46.02,30.94 61.44,46.35 77.8,46.35 78.28,46.83 78.3,46.83 80.29,48.83 80.29,49.43
  BOTTOM w0.076: v2(81.53,51.43) 81.53,52.01 82.37,52.85 82.5,52.85 82.72,53.07 82.72,53.21 83.34,53.83 UC1.BL2
  BOTTOM w0.107: v2(36.76,18.96) 38.22,20.43 JDIMM1.41
DDR_A_D11: length 73.5
  IN3 w0.076: 80.6,49.43 80.6,49.58 81.97,50.95 v2(81.97,51.83)
  IN3 w0.097: 80.6,49.43 80.6,48.71 78.42,46.53 78.4,46.53 77.92,46.05 61.59,46.05 42.63,27.09 42.49,27.09 42.12,27.46 41.98,27.46 41.84,27.32 41.84,27.19 42.22,26.81 42.22,26.68 42.08,26.54 41.94,26.54 41.57,26.91 41.43,26.91 41.3,26.78 41.3,26.64 41.67,26.27 41.67,26.13 41.53,25.99 41.4,25.99 41.02,26.37 40.89,26.37 40.75,26.23 40.75,26.1 41.13,25.72 41.13,25.58 40.99,25.45 40.85,25.45 40.48,25.82 40.34,25.82 38.58,24.06 38.58,23.88 38.77,23.69 38.77,23.21 37.52,21.96 37.52,18.15 v2(36.75,17.39)
  BOTTOM w0.076: v2(81.97,51.83) 81.97,52.21 82.36,52.59 82.5,52.59 83.09,53.18 UC1.BM1
  BOTTOM w0.107: JDIMM1.42 38.47,15.7 36.79,17.39 v2(36.75,17.39)
DDR_A_D12: length 75.5
  IN3 w0.097: v2(33.93,15.34) 33.85,15.42 33.85,16.07 33.96,16.18 34.77,16.18 34.88,16.3 34.88,16.47 34.79,16.56 33.79,16.56 33.69,16.66 33.69,16.84 33.81,16.97 34.6,16.97 34.69,17.06 34.69,19.01 34.88,19.19 35.08,19.4 35.08,22.06 36.06,23.03 36.06,24.11 49.56,37.61 50.52,37.61 60.78,47.87 76.52,47.87 76.7,48.04 81.92,53.27 83.43,53.27 84.78,54.62 v2(84.78,54.8)
  BOTTOM w0.076: UC1.BK4 84.45,55.13 v2(84.78,54.8)
  BOTTOM w0.107: JDIMM1.24 33.97,15.3 v2(33.93,15.34)
DDR_A_D13: length 76
  IN3 w0.097: v2(84.79,55.4) 84.47,55.4 84.37,55.3 84.37,54.63 84.32,54.59 83.31,53.57 81.8,53.57 76.4,48.17 60.65,48.17 50.47,37.99 49.49,37.99 35.12,23.62 35.12,23.16 34.59,22.63 34.59,19.36 34.39,19.16 34.39,17.36 34.3,17.27 32.97,17.27 32.86,17.16 32.86,16.99 32.99,16.86 v2(33.21,16.86)
  BOTTOM w0.076: UC1.BK5 84.41,55.78 v2(84.79,55.4)
  BOTTOM w0.107: v2(33.21,16.86) 34.97,15.1 JDIMM1.28
DDR_A_D14: length 73.9
  IN3 w0.076: 80.9,49.43 80.9,49.57 82.99,51.66 v2(82.99,52.57)
  IN3 w0.097: 80.9,49.43 80.9,48.59 78.55,46.23 78.53,46.23 78.05,45.75 61.78,45.75 40.89,24.86 40.75,24.86 40.47,25.14 40.32,25.14 40.19,25.01 40.19,24.87 40.48,24.58 40.48,24.45 40.34,24.31 40.2,24.31 39.83,24.68 39.69,24.68 39.56,24.55 39.56,24.41 39.93,24.04 39.93,23.9 39.79,23.76 39.66,23.76 39.28,24.14 39.15,24.14 39.01,24 39.01,23.87 39.38,23.49 39.38,23.35 37.93,21.9 37.93,17.55 37.84,17.45 37.31,17.45 37.21,17.35 37.21,17.17 37.31,17.07 37.75,17.07 37.84,16.97 37.84,16.78 37.75,16.68 37.46,16.68 37.36,16.58 37.36,16.4 37.46,16.3 37.66,16.3 37.75,16.2 37.75,15.96 37.66,15.86 v2(37.04,15.86)
  BOTTOM w0.076: v2(82.99,52.57) 83.34,52.57 UC1.BK1
  BOTTOM w0.107: v2(37.04,15.86) 37.47,15.43 JDIMM1.38
DDR_A_D15: length 74.9
  IN3 w0.097: v2(36.72,20.56) 36.72,22.01 37.25,22.54 37.25,23.58 45.47,31.8 45.6,31.8 45.95,31.46 46.08,31.46 46.22,31.59 46.22,31.73 45.88,32.07 45.88,32.21 46.01,32.34 46.15,32.34 46.49,32 46.63,32 46.77,32.14 46.77,32.28 46.42,32.62 46.42,32.75 46.56,32.89 46.7,32.89 47.04,32.55 47.17,32.55 47.31,32.68 47.31,32.82 46.97,33.16 46.97,33.3 47.11,33.44 47.24,33.44 47.58,33.09 47.72,33.09 47.86,33.23 47.86,33.37 47.52,33.71 47.52,33.85 47.65,33.98 47.79,33.98 48.13,33.64 48.27,33.64 48.4,33.78 48.4,33.91 48.06,34.26 48.06,34.39 48.2,34.53 48.33,34.53 48.68,34.19 48.81,34.19 48.95,34.32 48.95,34.46 48.61,34.8 48.61,34.94 48.74,35.07 48.88,35.07 49.22,34.73 49.36,34.73 49.5,34.87 49.5,35.01 49.15,35.35 49.15,35.48 49.29,35.62 49.43,35.62 49.77,35.28 49.91,35.28 50.04,35.42 50.04,35.55 49.79,35.81 49.79,35.95 49.92,36.08 50.06,36.08 50.32,35.82 50.45,35.82 61.28,46.65 62.57,46.65 62.57,46.65 77.52,46.65 v2(79.82,48.96)
  BOTTOM w0.076: v2(79.82,48.96) 80.91,48.96 84.65,52.7 84.65,53.56 UC1.BK2
  BOTTOM w0.107: JDIMM1.37 37.22,21.07 v2(36.72,20.56)
DDR_A_D16: length 53
  IN1 w0.097: v2(73.41,17.31) 72.78,17.31 72.63,17.46 72.63,47.93 72.73,48.03 73.43,48.03 73.53,48.13 73.53,48.33 73.43,48.43 72.73,48.43 72.63,48.53 72.63,48.74 72.73,48.84 73.1,48.84 73.65,49.4 73.65,55.13 78.06,59.54 v2(78.45,59.54)
  BOTTOM w0.102: v2(78.45,59.54) 78.52,59.47 80.2,59.47 UC1.BT11
  BOTTOM w0.107: v2(73.41,17.31) 72.47,16.37 JDIMM1.170
DDR_A_D17: length 54.1
  IN1 w0.097: v2(73.36,19.06) 73.36,18.64 73.26,18.54 73.03,18.54 72.93,18.64 72.93,45.93 73.05,46.05 73.79,46.05 73.88,46.15 73.88,46.35 73.79,46.45 73.05,46.45 72.95,46.55 72.95,46.74 73.05,46.84 73.79,46.84 73.88,46.94 73.88,47.14 73.79,47.24 73.05,47.24 72.95,47.34 72.95,47.57 73.05,47.68 73.85,47.68 73.96,47.78 73.96,54.96 77.39,58.4 v2(77.72,58.4)
  BOTTOM w0.102: UC1.BR11 80.64,59.26 79.12,59.26 78.26,58.4 v2(77.72,58.4)
  BOTTOM w0.107: JDIMM1.169 72.22,20.2 v2(73.36,19.06)
DDR_A_D18: length 51.3
  IN1 w0.097: v2(76.81,15.66) 76.15,16.33 76.15,20.27 74.8,21.61 74.8,40.46 74.9,40.56 75.36,40.56 75.45,40.66 75.45,40.86 75.36,40.96 74.9,40.96 74.8,41.06 74.8,41.26 74.9,41.36 75.36,41.36 75.45,41.45 75.45,41.65 75.36,41.75 74.9,41.75 74.8,41.85 74.8,42.05 74.9,42.15 75.36,42.15 75.45,42.25 75.45,53.83 78.05,56.42 v2(78.05,56.91)
  BOTTOM w0.076: UC1.BT9 80.29,58.9 79.14,58.9 77.95,57.71 77.95,57.01 v2(78.05,56.91)
  BOTTOM w0.107: JDIMM1.186 76.47,15.32 v2(76.81,15.66)
DDR_A_D19: length 52
  IN1 w0.097: v2(78.45,57.37) 78.56,57.26 78.56,56.51 75.76,53.71 75.76,37.7 75.66,37.6 75.28,37.6 75.18,37.5 75.18,37.3 75.28,37.21 75.66,37.21 75.76,37.11 75.76,36.91 75.66,36.81 75.28,36.81 75.18,36.71 75.18,36.51 75.28,36.41 75.66,36.41 75.76,36.31 75.76,36.12 75.66,36.02 75.28,36.02 75.18,35.92 75.18,35.72 75.28,35.62 75.66,35.62 75.76,35.52 75.76,35.32 75.66,35.22 75.28,35.22 75.18,35.13 75.18,34.93 75.28,34.83 75.66,34.83 75.76,34.73 75.76,34.53 75.66,34.43 75.28,34.43 75.18,34.33 75.18,34.13 75.28,34.04 75.66,34.04 75.76,33.94 75.76,33.74 75.66,33.64 75.28,33.64 75.18,33.54 75.18,33.34 75.28,33.24 75.66,33.24 75.76,33.14 75.76,32.95 75.66,32.85 75.28,32.85 75.18,32.75 75.18,32.55 75.28,32.45 75.66,32.45 75.76,32.35 75.76,32.15 75.66,32.05 75.28,32.05 75.18,31.96 75.18,31.76 75.28,31.66 75.66,31.66 75.76,31.56 75.76,31.36 75.66,31.26 75.28,31.26 75.18,31.16 75.18,30.96 75.28,30.87 75.66,30.87 75.76,30.77 75.76,30.57 75.66,30.47 75.28,30.47 75.18,30.37 75.18,22.26 v2(76.8,20.64)
  BOTTOM w0.076: v2(78.45,57.37) 79.01,57.37 79.42,57.78 79.88,57.78 80.25,58.16 80.9,58.16 UC1.BR8
  BOTTOM w0.107: JDIMM1.187 76.72,20.72 v2(76.8,20.64)
DDR_A_D20: length 53.9
  IN1 w0.097: v2(73.47,15.6) 72.61,15.6 72.31,15.9 72.31,48.89 73.35,49.93 73.35,55.99 74.3,56.94 74.89,56.94 78.32,60.36 78.45,60.36 v2(78.73,60.09)
  BOTTOM w0.102: v2(78.73,60.09) 79.14,59.67 79.75,59.67 80.01,59.93 81.35,59.93 UC1.BP11
  BOTTOM w0.107: JDIMM1.174 v2(73.47,15.6)
DDR_A_D21: length 54.3
  IN1 w0.076: v2(79.32,60.06) 79.62,60.36 79.73,60.36 79.87,60.22 79.87,60.09 79.26,59.48 78.91,59.48 78.46,59.03 78.46,58.6 77.86,58 77.43,58
  IN1 w0.097: 77.43,58 74.26,54.83 74.26,45.85 74.16,45.74 73.35,45.74 73.25,45.64 73.25,45.42 73.35,45.32 74.14,45.32 74.24,45.22 74.24,45.02 74.14,44.93 73.35,44.93 73.25,44.83 73.25,44.63 73.35,44.53 74.14,44.53 74.24,44.43 74.24,44.23 74.14,44.13 73.35,44.13 73.25,44.03 73.25,43.84 73.35,43.74 74.14,43.74 74.24,43.64 74.24,43.44 74.14,43.34 73.35,43.34 73.25,43.24 73.25,20.8 v2(73.41,20.64)
  BOTTOM w0.076: UC1.BN11 82.07,59.63 81.57,60.12 79.38,60.12 v2(79.32,60.06)
  BOTTOM w0.107: JDIMM1.173 73.22,20.83 v2(73.41,20.64)
DDR_A_D22: length 52.9
  IN1 w0.097: v2(79.38,58.17) 79.38,57.61 79.02,57.24 79.02,56.54 76.06,53.58 76.06,28.57 75.96,28.47 75.58,28.47 75.48,28.37 75.48,28.17 75.58,28.07 75.96,28.07 76.06,27.97 76.06,27.77 75.96,27.68 75.58,27.68 75.48,27.58 75.48,27.38 75.58,27.28 75.96,27.28 76.06,27.18 76.06,26.98 75.96,26.88 75.58,26.88 75.48,26.78 75.48,26.59 75.58,26.49 75.96,26.49 76.06,26.39 76.06,26.19 75.96,26.09 75.58,26.09 75.48,25.99 75.48,25.79 75.58,25.69 75.96,25.69 76.06,25.59 76.06,25.4 75.96,25.3 75.58,25.3 75.48,25.2 75.48,25 75.58,24.9 75.96,24.9 76.06,24.8 76.06,24.6 75.96,24.51 75.58,24.51 75.48,24.41 75.48,22.53 77.23,20.79 77.23,19.33 v2(76.81,18.91)
  BOTTOM w0.076: v2(79.38,58.17) 80.03,58.17 80.23,58.37 81.08,58.37 81.4,58.05 UC1.BP8
  BOTTOM w0.107: JDIMM1.183 75.72,20.01 v2(76.81,18.91)
DDR_A_D23: length 53.1
  IN1 w0.097: v2(79.91,58.55) 79.91,57.71 79.43,57.23 79.43,56.45 79.77,56.11 79.77,55.78 79.36,55.37 79.13,55.37 76.47,52.71 76.47,26.42 77.53,25.36 77.53,25.16 77.43,25.06 76.78,25.06 76.68,24.96 76.68,24.76 76.78,24.66 77.43,24.66 77.53,24.56 77.53,24.37 77.43,24.27 76.78,24.27 76.68,24.17 76.68,23.97 76.78,23.87 77.43,23.87 77.53,23.77 77.53,17.96 v2(76.8,17.24)
  BOTTOM w0.076: UC1.BN8 82.21,58.05 81.93,58.33 81.35,58.33 81.14,58.55 v2(79.91,58.55)
  BOTTOM w0.107: v2(76.8,17.24) 75.47,15.91 JDIMM1.182
DDR_A_D24: length 52.9
  IN1 w0.097: v2(83.25,60.05) 82.88,60.05 82.48,59.64 82.48,59.03 82.06,58.62 81.56,58.62 80.27,57.34 80.27,54.9 79.98,54.61 79.61,54.61 79.23,54.23 79.23,54.22 76.97,51.96 76.97,26.85 78.03,25.79 78.03,17.01 77.93,16.92 77.72,16.92 77.61,16.81 77.61,16.62 77.7,16.52 78.2,16.52 78.31,16.41 78.31,16.24 78.22,16.15 77.66,16.15 77.54,16.02 77.54,15.88 77.64,15.79 78.67,15.79 v2(78.69,15.76)
  BOTTOM w0.076: v2(83.25,60.05) 83.25,60.05 83.25,60.05 UC1.BL12
  BOTTOM w0.107: v2(78.69,15.76) 78.47,15.54 JDIMM1.194
DDR_A_D25: length 53.6
  IN1 w0.097: v2(78.78,19.02) 78.43,19.02 78.33,19.11 78.33,23.35 78.44,23.46 79.48,23.46 79.57,23.56 79.57,24.46 79.48,24.56 78.43,24.56 78.33,24.66 78.33,24.86 78.43,24.96 79.51,24.96 79.6,25.05 79.6,25.73 77.28,28.06 77.28,51.55 78.15,52.43 78.61,52.43 80.57,54.39 80.57,56.37 82.9,58.7 82.9,59.43 83.11,59.64 83.7,59.64 v2(84.08,60.01)
  BOTTOM w0.076: UC1.BL11 83.69,59.63 v2(84.08,60.01)
  BOTTOM w0.107: v2(78.78,19.02) 77.72,20.08 JDIMM1.191
DDR_A_D26: length 50.9
  IN1 w0.097: v2(78.85,20.56) 79.81,20.56 79.9,20.66 79.9,21.08 79.81,21.18 78.78,21.18 78.69,21.28 78.69,21.47 78.78,21.57 79.81,21.57 79.9,21.67 79.9,21.87 79.81,21.97 78.78,21.97 78.69,22.07 78.69,22.27 78.78,22.37 79.81,22.37 79.9,22.47 79.9,22.66 79.81,22.76 78.99,22.76 78.89,22.86 78.89,23.06 78.99,23.16 79.81,23.16 79.9,23.26 79.9,25.86 77.58,28.18 77.58,50.2 77.75,50.38 80.88,53.5 80.88,56.25 83.08,58.45 v2(83.28,58.45)
  BOTTOM w0.076: UC1.BL8 83.61,58.12 v2(83.28,58.45)
  BOTTOM w0.107: v2(78.85,20.56) 78.72,20.69 JDIMM1.195
DDR_A_D27: length 52.1
  IN1 w0.076: 81.85,49.38 81.85,50.11 83.22,51.49 83.33,51.49 84.18,52.34 84.18,53.2 85.49,54.51 85.49,57.98 85.41,58.06 v2(84.95,58.06)
  IN1 w0.097: v2(82.44,15.65) 83.92,15.65 84.03,15.75 84.03,15.99 83.92,16.09 83.04,16.09 82.94,16.2 82.94,16.39 83.04,16.49 83.93,16.49 84.03,16.59 84.03,16.79 83.93,16.89 83.33,16.89 83.23,16.99 83.23,20.83 83.07,20.99 83.07,46.21 82.83,46.45 81.94,46.45 81.85,46.55 81.85,49.38
  BOTTOM w0.076: v2(84.95,58.06) 84.62,57.74 UC1.BJ8
  BOTTOM w0.107: v2(82.44,15.65) 81.97,15.19 JDIMM1.208
DDR_A_D28: length 53.2
  IN1 w0.076: v2(84.95,59.36) 84.53,58.95 84.53,58.59 84.22,58.28 84.22,56.51 83.56,55.85 83.56,55.24
  IN1 w0.097: 83.56,55.24 83.56,54.97 83.25,54.66 83.25,53.74 79.4,49.89 79.4,48.81 80.24,47.97 80.24,43.58 80.68,43.14 82.07,43.14 82.17,43.04 82.17,42.84 82.07,42.74 81.59,42.74 81.49,42.64 81.49,42.44 81.59,42.34 82.07,42.34 82.17,42.25 82.17,42.05 82.07,41.95 81.59,41.95 81.49,41.85 81.49,41.65 81.59,41.55 82.07,41.55 82.17,41.45 82.17,41.26 82.07,41.16 81.59,41.16 81.49,41.06 81.49,19 81.59,18.9 v2(82.53,18.9)
  BOTTOM w0.076: UC1.BJ11 84.62,59.69 v2(84.95,59.36)
  BOTTOM w0.107: v2(82.53,18.9) 80.72,20.71 JDIMM1.203
DDR_A_D29: length 53
  IN1 w0.076: v2(84.95,58.71) 84.57,58.33 84.57,56.5 84.37,56.31 84.37,55.24
  IN1 w0.097: 84.37,55.24 84.37,54.58 83.55,53.76 83.55,52.56 83.08,52.09 82.97,52.09 80.54,49.66 80.54,49.15 80.64,49.05 81.02,49.05 81.12,48.95 81.12,48.75 81.02,48.65 80.64,48.65 80.54,48.55 80.54,48.36 80.64,48.26 81.02,48.26 81.12,48.16 81.12,47.96 81.02,47.86 80.64,47.86 80.54,47.76 80.54,47.56 80.64,47.47 81.02,47.47 81.12,47.37 81.12,47.17 81.02,47.07 80.64,47.07 80.54,46.97 80.54,46.77 80.64,46.67 81.02,46.67 81.12,46.57 81.12,46.38 81.02,46.28 80.64,46.28 80.54,46.18 80.54,45.98 80.64,45.88 81.02,45.88 81.12,45.78 81.12,45.58 81.02,45.48 80.64,45.48 80.54,45.38 80.54,45.19 80.64,45.09 81.38,45.09 81.48,44.99 81.48,44.79 81.38,44.69 80.64,44.69 80.54,44.59 80.54,44.35 80.64,44.25 82.36,44.25 82.46,44.14 82.46,43.93 82.36,43.83 81.43,43.83 81.3,43.71 81.3,43.53 81.4,43.44 82.36,43.44 82.47,43.33 82.47,20.74 82.5,20.71 v2(82.5,20.53)
  BOTTOM w0.076: v2(84.95,58.71) 84.62,59.04 UC1.BJ10
  BOTTOM w0.107: JDIMM1.207 81.72,21.31 v2(82.5,20.53)
DDR_A_D30: length 50.9
  IN1 w0.097: v2(78.76,17.44) 79.75,17.44 79.85,17.54 79.85,17.79 79.75,17.89 79.39,17.89 79.29,17.99 79.29,18.19 79.39,18.29 79.73,18.29 79.83,18.39 79.83,18.58 79.73,18.68 79.57,18.68 79.47,18.78 79.47,18.98 79.57,19.08 79.83,19.08 80.3,19.55 80.3,25.89 77.88,28.31 77.88,50.07 81.18,53.37 81.18,56.1 82.7,57.63 v2(83.32,57.63)
  BOTTOM w0.076: v2(83.32,57.63) 83.6,57.35 UC1.BL7
  BOTTOM w0.107: JDIMM1.190 77.47,16.15 v2(78.76,17.44)
DDR_A_D31: length 51.5
  IN1 w0.097: v2(82.47,17.28) 82.83,17.28 82.93,17.38 82.93,20.71 82.77,20.87 82.77,44.44 82.66,44.55 82.06,44.55 81.96,44.65 81.96,44.85 82.06,44.95 82.66,44.95 82.76,45.05 82.76,45.24 82.66,45.34 81.6,45.34 81.5,45.44 81.5,45.64 81.6,45.74 82.66,45.74 82.76,45.84 82.76,46.05 82.66,46.15 81.61,46.15 81.5,46.25 81.5,50.19 83.1,51.79 83.21,51.79 83.88,52.46 83.88,53.33 85.19,54.63 85.19,57.17 v2(84.95,57.41)
  BOTTOM w0.076: v2(84.95,57.41) 84.62,57.09 UC1.BJ7
  BOTTOM w0.107: v2(82.47,17.28) 81.07,15.88 81.07,15.32 80.97,15.21 JDIMM1.204
DDR_A_D32: length 72.5
  IN3 w0.076: v2(84.75,51.97) 84.25,52.48 84.14,52.48 81.4,49.74 81.4,49.43
  IN3 w0.097: 81.4,49.43 81.4,48.38 78.28,45.25 61.99,45.25 38.44,21.7 38.44,15.63 38.53,15.54 v2(38.93,15.54)
  BOTTOM w0.076: v2(84.75,51.97) 85.27,51.97 85.54,52.24 85.54,52.73 85.44,52.83 85.44,53.47 85.5,53.53 85.5,54.52 UC1.BG4
  BOTTOM w0.107: JDIMM1.46 39.47,15.14 39.07,15.54 v2(38.93,15.54)
DDR_A_D33: length 72.8
  IN3 w0.076: v2(84.3,51.52) 84.41,51.63 84.41,51.86 84.16,52.12 84.05,52.12 83.55,51.62 83.55,51.32 83.37,51.14 83.07,51.14 81.7,49.77 81.7,49.43
  IN3 w0.097: 81.7,49.43 81.7,48.27 81.7,48.25 78.4,44.95 62.12,44.95 40.47,23.31 40.47,23.17 40.74,22.9 40.74,22.76 40.61,22.63 40.47,22.63 40.2,22.9 40.06,22.9 39.9,22.73 39.9,22.63 40.39,22.14 40.39,22.01 40.22,21.85 40.09,21.85 39.63,22.3 39.49,22.3 39.36,22.17 39.36,22.03 39.81,21.57 39.81,21.44 39.68,21.3 39.54,21.3 39.1,21.74 38.96,21.74 38.83,21.61 38.83,21.47 39.27,21.03 39.27,20.89 39.04,20.67 v2(38.85,20.67)
  BOTTOM w0.076: v2(84.3,51.52) 85.15,51.52 85.71,52.08 85.71,52.85 85.6,52.95 85.6,53.39 85.66,53.44 85.67,53.44 85.67,54.44 86.07,54.84 86.24,54.84 86.45,55.04 86.45,55.44 UC1.BG5
  BOTTOM w0.107: v2(38.85,20.67) 39.22,21.04 JDIMM1.45
DDR_A_D34: length 72
  IN3 w0.097: v2(41.97,20.87) 42.26,20.87 42.39,20.74 42.39,19.18 42.49,19.07 42.73,19.07 42.84,19.18 42.84,21.12 42.62,21.34 42.62,21.63 44.04,23.05 44.04,23.24 43.68,23.6 43.68,23.97 44.05,24.34 44.18,24.34 44.52,24.01 44.66,24.01 44.79,24.15 44.79,24.28 44.46,24.62 44.46,24.75 44.65,24.94 44.79,24.94 45.01,24.72 45.14,24.72 45.28,24.86 45.28,25 45.06,25.22 45.06,25.35 62.86,43.16 79.21,43.16 84.12,48.06 84.12,48.88 84.71,49.46 84.71,51.26 85.48,52.03 85.48,54.71 85.62,54.85 v2(87.28,54.85)
  BOTTOM w0.076: v2(87.28,54.85) 87.01,55.13 UC1.BF4
  BOTTOM w0.107: JDIMM1.59 42.72,21.41 42.18,20.87 v2(41.97,20.87)
DDR_A_D35: length 72.9
  IN3 w0.076: v2(87.29,55.45) 87.68,55.07 87.68,54.71 87.43,54.46 87.1,54.46 86.18,53.54 86.18,52.03 84.9,50.75 84.9,49.23 84.66,48.99
  IN3 w0.097: v2(41.96,19.35) 41.96,19.17 42.44,18.69 42.44,17.72 42.54,17.62 42.98,17.62 43.14,17.77 43.14,21.73 45.09,23.68 45.09,24.2 45.77,24.88 45.77,25.65 62.99,42.86 79.34,42.86 84.42,47.94 84.42,48.75 84.66,48.99
  BOTTOM w0.076: UC1.BF5 86.97,55.78 v2(87.29,55.45)
  BOTTOM w0.107: JDIMM1.63 43.72,21.1 v2(41.96,19.35)
