# Allegro board LA-F711P R05-0112.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SATA_PTX_RD_DRX_P2: length 8.6
  BOTTOM w0.097: UN7.15 251.28,15.84 251.44,16 251.44,16.06 251.53,16.15 251.85,16.15 252.24,15.77 v4(253.4,15.77) 254.18,15.77 254.84,16.43 254.84,16.9 254.88,16.94 254.88,17.53 254.84,17.57 254.84,18.01 254.99,18.16 255.96,18.16 256.08,18.03 256.08,17.79 255.81,17.52 CN4.2
SATAGP0: length 14.7
  TOP w0.089: RH377.2 207.29,19.05 v2(206.76,18.52)
  TOP w0.102: v2(206.94,23.01) 206.94,22.95 206.78,22.79 v1(206.78,22.11) 206.78,20.47 RH377.2
  BOTTOM w0.089: UH1.AH41 206.28,23.78 206.94,23.12 v2(206.94,23.01) ; 207.87,13.88 207.87,15.11 207.29,15.7 207.29,17.32 206.76,17.84 v2(206.76,18.52)
  BOTTOM w0.102: 207.87,13.88 207.87,11.33 208.45,10.74 RH316.2
SATAGP3: length 9.7
  BOTTOM w0.089: 212.03,13.88 v1(212.03,14.25) 212.03,15.31 210.68,16.66 210.43,16.66 208.58,18.51 208.58,20.94 208.64,21.01 UH1.AN47
  BOTTOM w0.102: 212.03,13.88 212.03,13.28 RH323.2
SATAGP5: length 2.5
  TOP w0.102: RH325.2 209.91,23.64 v1(209.33,23.07) 208.93,23.07 v2(208.85,23.15)
  BOTTOM w0.089: UH1.AM43 v2(208.85,23.15)
SATAGP6: length 9.3
  BOTTOM w0.089: 210.34,16.48 208.38,18.43 208.38,20.62 208.18,20.82 UH1.AM47
  BOTTOM w0.102: 210.34,16.48 210.61,16.48 211.16,15.92 v1(211.16,15.43) 211.16,13.3 RH326.2
SATAGP7: length 8.3
  BOTTOM w0.089: UH1.AM48 208.15,20.29 208.19,20.25 208.19,18.35 208.27,18.26 208.27,18.26 209.91,16.62
  BOTTOM w0.102: RH322.2 210.28,13.3 v1(210.28,14.36) 210.28,16.25 209.91,16.62
SATALED#: length 269.9
  TOP w0.102: v2(279.85,12.86) 279.85,14.31 284.79,19.26 284.79,27.14 288.64,30.99 288.64,35.94 289.62,36.91 290.95,36.91 294.58,40.54 294.58,46.48 294.84,46.74 294.84,53.39 v1(295.47,54.03) 296.21,54.76 v2(296.39,54.76)
  IN2 w0.102: v2(360.78,13.64) 360.78,13.08 354.2,6.5 350.68,6.5 348.72,8.46 340.54,8.46 338.18,10.82 337.58,10.82 336.53,11.87 329.94,11.87 328.71,10.64 320.97,10.64 318.33,13.28 280.26,13.28 v2(279.85,12.86) 278.91,13.8 258.18,13.8 255.21,10.84 251.06,10.84 248.58,13.32 232.97,13.32 231.35,14.93 222.11,14.93 221.69,15.35 216.85,15.35 216.68,15.52 208.1,15.52 205.38,18.24 204.1,18.24 203.73,18.6 203.73,19.11 204.16,19.54 206.28,19.54 v2(206.28,19.54)
  BOTTOM w0.089: RH380.2 206.36,15.14 206.21,15.3 206.21,19.41 206.28,19.48 v2(206.28,19.54) 206.34,19.6 206.34,20.09 206.81,20.56 UH1.AK48
  BOTTOM w0.102: RN101.2 328.14,64.24 328.37,64.01 328.37,59.67 327.05,58.36 325.78,58.36 324.86,57.44 322.9,57.44 321.47,58.87 319.94,58.87 319.51,58.44 308.69,58.44 QZ2.4 308.08,58.09 305.54,58.09 305.04,57.59 299.69,57.59 296.86,54.76 v2(296.39,54.76) ; RN100.2 361.11,13.31 v2(360.78,13.64)
SBIOS_TX: length 135.9
  TOP w0.102: v2(236.52,31.15) v1(237.05,30.62) 237.26,30.41 237.26,25.16 236.77,24.67 236.77,21.5 235.36,20.09 235.36,17.05 235.15,16.84 235.15,15.6 v2(234.36,14.81)
  IN2 w0.102: v2(212.95,32.91) 212.95,32.63 213.41,32.17 218.06,32.17 218.35,32.46 219.07,32.46 219.9,31.63 220.49,31.63 221.68,30.45 223.49,30.45 224.52,29.43 226.69,29.43 227.01,29.74 233.98,29.74 235.39,31.15 v2(236.52,31.15) ; v2(234.36,14.81) 234.37,14.79 252.68,14.79 253.39,14.08 322.08,14.08 v2(324.01,12.15)
  BOTTOM w0.089: UH1.BB24 v2(212.95,32.91)
  BOTTOM w0.102: RE306.1 v2(324.01,12.15)
SD_1_CD#: length 23
  TOP w0.089: v2(16.35,71.8) 16.35,71.26 17.23,70.38 UR1.30
  IN3 w0.102: v2(30.93,68.4) 30.93,68.7 30.07,69.57 30.07,72.18 28.62,73.63 22.03,73.63 20.5,72.1 18.02,72.1 17.72,71.8 v2(16.35,71.8)
  BOTTOM w0.102: JSD1.18 v2(30.93,68.4)
SD_1_CLK: length 2.3
  TOP w0.089: RR5.1 v1(20.94,65.94) 20.82,65.94 20.23,66.54 UR1.17
SD_1_CLK_R: length 42.3
  TOP w0.089: v2(24.43,65.99) CR21.1 22.89,65.99 RR5.2
  IN3 w0.089: v2(30.53,66.19) 29.3,66.19 29.14,66.34 29.14,67.8 29.05,67.89 28.84,67.89 28.75,67.8 28.75,64.18 28.63,64.06 28.47,64.06 28.37,64.16 28.37,68.53 28.28,68.62 28.08,68.62 27.99,68.53 27.99,64.21 27.82,64.04 27.68,64.04 27.58,64.14 27.58,67.51 27.49,67.6 27.24,67.6 27.12,67.48 27.12,63.99 27,63.87 26.84,63.87 26.72,63.99 26.72,67.08 26.59,67.21 26.4,67.21 26.27,67.08 26.27,63.92 26.15,63.8 25.99,63.8 25.87,63.92 25.87,67.23 25.74,67.36 25.56,67.36 25.43,67.23 25.43,66.18 25.24,65.99 v2(24.43,65.99)
  BOTTOM w0.089: JSD1.5 31.5,67 31.34,67 v2(30.53,66.19)
SD_1_CMD: length 3.3
  TOP w0.089: UR1.19 v1(21.05,67.34) 21.45,67.34 22.21,68.1 RR6.1
SD_1_CMD_R: length 41.9
  TOP w0.089: v2(25,68.1) RR6.2
  IN3 w0.089: v2(30.4,61.3) 31.31,61.3 31.8,61.78 31.8,66 28.55,69.25 28.55,71.57 28.45,71.67 28.27,71.67 28.17,71.57 28.17,70.45 28.05,70.33 27.88,70.33 27.76,70.45 27.76,71.65 27.64,71.77 27.47,71.77 27.35,71.65 27.35,68.49 27.24,68.37 27.07,68.37 26.95,68.49 26.95,72.24 26.86,72.33 26.63,72.33 26.54,72.24 26.54,68.07 26.42,67.95 26.25,67.95 26.14,68.07 26.14,72.23 26.05,72.32 25.82,72.32 25.73,72.23 25.73,68.2 25.63,68.1 v2(25,68.1)
  BOTTOM w0.089: JSD1.2 v2(30.4,61.3)
SD_1_DAT0: length 4.1
  TOP w0.089: RR10.1 22.08,64.84 22.08,64.62 22.02,64.56 20.99,64.56 20.53,65.01 19.64,65.01 19.23,65.43 UR1.16
SD_1_DAT0_R: length 42.5
  TOP w0.089: v2(24.45,63.93) 24.17,64.22 24.17,64.44 23.94,64.67 23.17,64.67 RR10.2
  IN1 w0.089: v2(24.45,63.93) 24.45,64.42 25.73,65.7 25.73,66.4 26.22,66.89 27.56,66.89 27.85,67.18 27.85,67.9 27.56,68.18 26,68.18 25.91,68.27 25.91,68.86 26,68.95 29.12,68.95 29.46,69.3 29.46,69.89 29.06,70.29 25.93,70.29 25.84,70.38 25.84,70.95 25.93,71.04 27.82,71.04 28.17,71.4 28.17,72.01 27.82,72.36 21.92,72.36 21.83,72.45 21.83,73.13 21.92,73.21 28.65,73.21 28.8,73.06 28.8,72.16 29.19,71.77 30.3,71.77 30.49,71.57 v2(30.49,71.41)
  BOTTOM w0.089: JSD1.7 32.09,71.2 31.61,71.68 30.76,71.68 v2(30.49,71.41)
SD_1_DAT1: length 4.1
  TOP w0.089: UR1.15 18.83,65.45 19.53,64.74 v4(20.02,64.74) 20.42,64.74 20.88,64.29 21.74,64.29 RR9.1
SD_1_DAT1_R: length 42.5
  TOP w0.089: v2(23.86,63.93) 23.9,63.97 23.9,64.33 23.83,64.4 23.15,64.4 RR9.2
  IN1 w0.089: v2(23.86,63.93) 24.12,64.19 24.12,64.56 25.39,65.83 25.39,66.54 26.08,67.23 27.43,67.23 27.51,67.31 27.51,67.76 27.43,67.85 25.86,67.85 25.58,68.13 25.58,69 25.86,69.28 28.98,69.28 29.13,69.44 29.13,69.75 28.93,69.96 25.79,69.96 25.51,70.24 25.51,71.09 25.79,71.38 27.68,71.38 27.84,71.53 27.84,71.87 27.68,72.03 21.78,72.03 21.49,72.32 21.49,73.26 21.78,73.55 28.79,73.55 29.13,73.2 29.13,72.3 29.33,72.1 30.36,72.1 v2(30.5,72.24)
  BOTTOM w0.089: JSD1.8 32.09,72.6 31.69,72.2 31.69,72.1 31.57,71.97 30.77,71.97 v2(30.5,72.24)
SD_1_DAT2: length 4.3
  TOP w0.089: UR1.21 20.94,68.14 21.75,68.95 21.75,69.86 v1(21.9,70.01) RR8.1
SD_1_DAT2_R: length 41.4
  TOP w0.089: v2(24.42,70.01) RR8.2
  IN3 w0.089: v2(30.39,59.41) 28.94,59.41 27.01,61.34 22.04,61.34 21.19,62.19 21.19,63.84 21.92,64.57 23.05,64.57 23.15,64.68 23.15,64.86 23.03,64.97 21.93,64.97 21.83,65.07 21.83,65.29 21.93,65.39 23.05,65.39 23.15,65.49 23.15,65.67 23.03,65.79 21.92,65.79 21.81,65.89 21.81,66.08 21.92,66.18 23.04,66.18 23.14,66.29 23.14,66.49 23.03,66.61 21.92,66.61 21.81,66.71 21.81,66.91 21.92,67.01 23.05,67.01 23.15,67.11 23.15,67.29 23.03,67.41 21.92,67.41 21.81,67.52 21.81,67.71 21.92,67.81 23.04,67.81 23.15,67.92 23.15,68.1 23.03,68.21 21.93,68.21 21.81,68.33 21.81,68.51 21.92,68.62 23.03,68.62 23.15,68.74 23.15,68.91 23.03,69.02 21.94,69.02 21.81,69.14 21.81,69.3 21.92,69.4 23.04,69.4 23.17,69.54 23.17,69.71 23,69.88 21.92,69.88 21.81,69.98 21.81,70.15 21.93,70.27 24.16,70.27 v2(24.42,70.01)
  BOTTOM w0.089: JSD1.9 31.3,58.5 v2(30.39,59.41)
SD_1_DAT3: length 3.5
  TOP w0.089: UR1.20 21.02,67.74 22.34,69.06 RR7.1
SD_1_DAT3_R: length 42.6
  TOP w0.089: RR7.2 24.63,69.06 v2(24.88,69.3)
  IN3 w0.089: v2(24.88,69.3) 24.99,69.42 24.99,70.65 24.77,70.87 21.56,70.87 21.45,70.98 21.45,71.13 21.56,71.24 24.2,71.24 24.32,71.36 24.32,71.53 24.2,71.65 21.58,71.65 21.46,71.77 21.46,71.94 21.58,72.06 24.02,72.06 24.14,72.18 24.14,72.34 24.02,72.46 22.26,72.46 22.16,72.56 22.16,72.81 22.28,72.94 28.19,72.94 29.36,71.77 29.36,69.29 32.43,66.22 32.43,60.57 32.13,60.27 v2(30.43,60.27)
  BOTTOM w0.089: JSD1.1 30.8,59.9 v2(30.43,60.27)
SD_1_N0: length 46.7
  TOP w0.089: v2(19.66,71.14) 19.66,71.14 19.23,70.71 UR1.25
  IN1 w0.089: v2(8.51,48.74) 8.53,48.71 9.49,48.71 9.85,49.07 9.85,54.86 13.51,58.52 13.51,59.13 13.23,59.41 11.62,59.41 11.53,59.5 11.53,59.94 11.62,60.03 14.18,60.03 14.53,60.38 14.53,60.97 14.18,61.32 11.62,61.32 11.53,61.41 11.53,61.83 11.65,61.94 13.35,61.94 13.64,62.23 13.64,62.95 13.35,63.23 11.65,63.23 11.53,63.35 11.53,63.76 11.62,63.85 13.23,63.85 13.51,64.14 13.51,67.84 15.73,70.07 19.16,70.07 19.6,70.51 19.6,71.09 v2(19.66,71.14)
  BOTTOM w0.089: v2(8.51,48.74) 8.49,48.75 7.6,48.75 7.35,49 JSD1.12
SD_1_N1: length 46.7
  TOP w0.089: UR1.23 20.47,68.94 v2(21.01,69.47)
  IN3 w0.089: v2(21.01,69.47) 20.27,69.47 19.7,68.9 19.7,66.16 19.11,65.56 14.49,65.56 13.68,64.76 11.94,64.76 10.36,66.34 10.36,73.63 17.14,80.42 17.14,82 16.44,82.7 v2(15.92,82.7)
  BOTTOM w0.089: JSD1.15 7.35,80.77 7.68,81.1 7.68,81.6 8.03,81.95 14.38,81.95 15.13,82.7 v2(15.92,82.7)
SD_1_P0: length 46.6
  TOP w0.089: v2(18.89,71.14) 18.83,71.08 UR1.26
  IN1 w0.089: v2(8.48,49.32) 8.61,49.32 8.89,49.05 9.35,49.05 9.52,49.21 9.52,55 13.18,58.66 13.18,58.99 13.09,59.08 11.48,59.08 11.2,59.36 11.2,60.08 11.48,60.36 14.04,60.36 14.19,60.52 14.19,60.83 14.04,60.99 11.48,60.99 11.2,61.27 11.2,61.96 11.51,62.27 13.21,62.27 13.3,62.36 13.3,62.81 13.21,62.9 11.52,62.9 11.2,63.21 11.2,63.9 11.48,64.18 13.09,64.18 13.18,64.27 13.18,67.98 15.6,70.4 19.03,70.4 19.27,70.65 19.27,70.97 19.1,71.14 v2(18.89,71.14)
  BOTTOM w0.089: v2(8.48,49.32) 8.18,49.02 7.71,49.02 7.62,49.11 7.62,49.72 7.84,49.94 8.2,49.94 8.45,50.18 JSD1.11
SD_1_P1: length 46.6
  TOP w0.089: v2(20.96,68.86) 20.64,68.54 UR1.22
  IN3 w0.089: v2(15.92,82.07) 15.92,82.12 16.18,82.38 16.31,82.38 16.82,81.87 16.82,80.55 10.04,73.77 10.04,66.21 11.81,64.44 13.82,64.44 14.62,65.24 19.24,65.24 20.02,66.03 20.02,68.77 20.4,69.15 20.67,69.15 v2(20.96,68.86)
  BOTTOM w0.089: JSD1.16 8.45,80.79 7.95,81.3 7.95,81.49 8.14,81.68 14.49,81.68 15.25,82.43 15.61,82.43 15.92,82.12 v2(15.92,82.07)
SD_GPIO: length 3.5
  TOP w0.102: UR1.28 18.03,70.55 17.96,70.61 17.96,70.9 17.4,71.47 v1(17.4,71.68) 17.4,72.45 RR3.2
SD_RCOMP_1P8: length 6.4
  TOP w0.254: RH611.2 216.26,45.82 215.99,45.55 215.99,45.19 v1(215.72,44.92) 214.74,43.94 214.74,43.58 214.55,43.38 214.55,42.21 214.02,41.68 214.02,41.65 v2(213.82,41.45)
  BOTTOM w0.089: UH1.BE5 214.12,41.57 214,41.45 v2(213.82,41.45)
SD_RCOMP_3P3: length 4.8
  TOP w0.254: RH610.2 216.31,44.93 215.08,43.7 v1(215.08,43.36) 214.89,43.16 v2(214.89,41.7)
  BOTTOM w0.089: v2(214.89,41.7) 214.57,42.02 UH1.BE4
SDWP: length 25.2
  TOP w0.102: v2(16.94,72.21) 16.94,71.32 17.63,70.63 UR1.29
  IN2 w0.102: v2(33.83,72.71) 32.43,72.71 31.05,74.09 21.92,74.09 20.37,72.54 17.27,72.54 v2(16.94,72.21)
  BOTTOM w0.102: v2(33.83,72.71) 34.55,72.71 34.72,72.54 34.72,71.91 35.16,71.47 QR1.1
SDWP_Q: length 4.2
  BOTTOM w0.102: JSD1.19 33.63,74 34.4,74 v1(34.89,73.51) 35.54,72.86 QR1.3
SIM_DET: length 14.7
  BOTTOM w0.102: JNGFF2.66 340.9,59.21 342.98,57.12 v1(350.01,57.12) 350.48,57.12 351.9,55.7 JSIM1.9
SIO_EXT_SMI#: length 8.7
  BOTTOM w0.089: 208.33,13.88 208.33,15.4 207.61,16.11 v1(207.61,16.24) 207.61,17.25 207.22,17.64 207.22,19.61 207.21,19.62 207.21,20.32 207.22,20.33 207.22,20.43 207.23,20.44 207.23,20.45 207.23,20.46 207.23,20.75 207.47,20.98 UH1.AL47
  BOTTOM w0.102: 208.33,13.88 RH310.2
SIO_EXT_WAKE#: length 175.3
  TOP w0.102: v2(229.46,4.85) 229.23,5.08 229.23,7.76 228.34,8.65 228.34,12.31 231.04,15.01 231.04,17.69 232.25,18.9 232.25,21.38 232.97,22.1 232.97,25.49 233.31,25.83 233.31,29.35 v1(232.85,29.81) 232.45,30.21 232.45,31.34 232.12,31.67 232.12,32.85 v2(232.53,33.25) ; v2(210.67,32.91) 211.67,31.91 RH309.2
  TOP w0.104: RE703.1 322.57,21.15 319,21.15 317.9,20.05 317.9,9.21 v2(319.63,7.48)
  IN1 w0.099: v2(319.63,7.48) 319.07,8.04 317.2,8.04 316.61,7.44 311.6,7.44 310.02,5.86 307.22,5.86 305.37,7.7 292.83,7.7 292.26,8.27 279.02,8.27 277.71,9.58 268.1,9.58 265.52,7.01 257.05,7.01 255.7,5.66 233.56,5.66 233.15,5.24 229.85,5.24 v2(229.46,4.85)
  IN2 w0.102: v2(210.67,32.91) 210.67,32.98 211.29,33.6 215.46,33.6 215.98,33.08 220.37,33.08 220.41,33.04 222.63,33.04 224.19,31.48 226.86,31.48 227.26,31.07 230.35,31.07 v2(232.53,33.25)
  BOTTOM w0.089: UH1.AU24 v2(210.67,32.91)
SIO_EXT_WAKE#_EC: length 9.1
  TOP w0.104: UE1.M12 322.52,31.22 322.94,30.8 322.94,26.94 323.8,26.08 323.8,24.31 323.82,24.28 323.82,23.57 323.58,23.33 RE703.2
SIO_PWRBTN#: length 395.3
  TOP w0.102: v2(193.67,65.71) 193.67,65.43 195.98,63.13 v1(196.68,63.13) 208.58,63.13 218.47,53.23 218.47,51.28 218.88,50.88 219.76,50.88 222.55,53.67 224.27,53.67 234.39,43.56 234.39,40.9 236.11,39.17 236.11,36.28 235.4,35.56 235.4,30.69 235.73,30.35 235.73,24.63 235.39,24.29 235.39,21.78 234.19,20.57 234.19,18.1 v2(233.32,17.23) ; v2(52.5,53.62) 52.12,53.24 52.12,51 RC241.2 52.12,49.73 52.12,48.28 52.45,47.95 CC269.1 52.75,47.7 52.04,47.7 50.51,46.17 48.81,46.17 47.99,45.35 47.99,44.33 47.49,43.83 47.49,43.81 47.3,43.63 43.52,43.63 42.49,42.59 42.49,40.56 42.67,40.39 JXDP1.41
  TOP w0.104: UE1.K11 v2(322.12,32.75)
  IN1 w0.099: v2(318.75,25.17) 317.08,23.49 317.08,19.05 316.44,18.41 v2(314.2,18.41)
  IN3 w0.102: v2(214.95,21.67) 214.96,21.67 216.07,20.57 220.08,20.57 220.08,20.57 221.88,20.57 224.66,17.79 229.01,17.79 229.57,17.23 v2(233.32,17.23) 233.5,17.23 235.34,15.39 237.26,15.39 237.74,15.87 242.74,15.87 243.22,15.39 253.35,15.39 253.96,14.78 267.45,14.78 267.97,15.3 277.67,15.3 278.77,16.4 279.7,16.4 280.42,17.12 282.25,17.12 282.46,16.91 295.19,16.91 295.71,17.43 298.47,17.43 299.13,18.09 300.28,18.09 300.68,18.49 311.62,18.49 311.94,18.17 313.95,18.17 v2(314.2,18.41) ; v2(318.75,25.17) 319.26,24.67 319.7,24.67 320.53,25.5 320.53,30.47 320.05,30.95 320.05,31.37 320.23,31.55 321.56,31.55 321.74,31.72 321.74,32.44 322.05,32.75 v2(322.12,32.75)
  BOTTOM w0.089: UH1.BE46 214.67,21.39 v2(214.95,21.67)
  BOTTOM w0.102: v2(193.67,65.71) 191.57,67.81 172.8,67.81 172.3,67.3 172.3,64.41 162.97,55.09 162.97,53.5 151.2,41.73 60.15,41.73 52.5,49.38 v2(52.5,53.62)
SIO_RCIN#: length 3.6
  BOTTOM w0.089: UH1.BE39 214.39,25.02 214.45,25.09 214.91,25.09 214.91,25.09 216.09,25.09 216.31,24.87 T286.1
SIO_SLP_A#: length 203.6
  TOP w0.102: v2(175.33,42.24) 175.33,42.62 175.38,42.66 175.38,43.35 175.32,43.41 JAPS1.6 ; v2(222.52,23.14) 222.52,23.32 RH628.1 221.83,23.67 CH343.1
  TOP w0.104: v2(317.09,16.05) 317.09,16.46 317.46,16.82 v1(317.46,17.87) 317.46,19.94 318.91,21.39 320.75,21.39 320.98,21.61 321.66,21.61 323.03,22.99 323.03,23.65 322.98,23.7 322.98,24.15 323.13,24.31 323.13,26.17 322.56,26.74 322.56,30.13 322.21,30.48 322.21,31.06 UE1.M11
  IN1 w0.089: 223.61,22.73 222.93,22.73 v2(222.52,23.14)
  IN1 w0.099: 223.61,22.73 226.89,22.73 227.38,22.23 229.01,22.23 230.12,21.12 237.02,21.12 237.2,21.3 239.68,21.3 240.6,20.38 241.49,20.38 242.68,19.19 252.17,19.19 253.3,20.32 290.07,20.32 290.26,20.52 294.69,20.52 295.48,21.31 296.37,21.31 298.12,23.06 307.35,23.06 307.63,22.79 310.24,22.79 311.07,21.95 311.07,18.99 313.63,16.43 316.71,16.43 v2(317.09,16.05)
  IN1 w0.122: v2(222.52,23.14) 222.15,23.51 220.65,23.51 220.08,24.08 214.31,24.08 213.95,24.44 213.53,24.44 213.12,24.04 212.61,24.04 212.57,24.08 212.01,24.08 211.78,23.86 210.72,23.86 209.49,25.09 209.49,26.85 208.76,27.58 207.72,27.58 207.16,28.14 207.16,31.85 206.32,32.69 206.32,33.15 207.95,34.77 207.95,36.06 208.41,36.52 208.41,37.05 207.82,37.63 206.55,37.63 199.63,44.55 197.66,44.55 196.26,45.95 191.53,45.95 190.86,46.61 186.23,46.61 181.31,41.69 177.06,41.69 176.51,42.24 v2(175.33,42.24)
  BOTTOM w0.089: UH1.BE40 214.45,24.5 214.53,24.43 214.84,24.43 214.89,24.47 214.93,24.51 215.86,24.51 216.05,24.32 218.08,24.32 218.37,24.03 220.15,24.03 220.39,23.79
  BOTTOM w0.102: 220.39,23.79 220.63,23.55 222.04,23.55 222.45,23.14 v2(222.52,23.14)
SIO_SLP_LAN#: length 176
  TOP w0.102: UZ2.5 316.44,70.91 317.06,71.53 v1(317.92,71.53) 318.31,71.53 319.07,70.76 319.07,65.35 321.41,63.02 327.45,63.02 327.7,62.77 327.7,62.12 327.53,61.95 v2(327.53,61.92) ; v2(320.54,34.42) 320.21,34.75 UE1.H9
  IN2 w0.102: v2(225.64,23.36) 225.97,23.36 226.03,23.41 228.9,23.41 229.74,24.26 233.26,24.26 234.1,23.41 236.64,23.41 237.71,24.48 256.43,24.48 256.76,24.15 261.73,24.15 264.64,21.25 280.21,21.25 283.64,24.67 283.64,27.04 284.46,27.86 289.87,27.86 291.96,29.95 297.13,29.95 301.08,33.9 307.61,33.9 v2(308.08,33.42)
  IN3 w0.102: v2(327.53,61.92) 327.53,60.81 326.96,60.24 326.96,59 327.55,58.41 327.55,57 328.93,55.62 328.93,48.59 328.57,48.24 328.57,41.21 324.59,37.23 324.59,36.72 323.01,35.14 321.25,35.14 320.54,34.42 320.54,34.42 320.54,34.42 v2(320.54,34.42)
  BOTTOM w0.089: UH1.BF40 214.81,24.66 214.85,24.7 215.94,24.7 216.13,24.51 218.14,24.51 218.45,24.2 220.3,24.2 220.48,24.02 220.55,23.95
  BOTTOM w0.102: 225.65,23.36 225.87,23.14 RH204.1 ; 225.65,23.36 v2(225.64,23.36) ; 225.65,23.36 225.65,23.38 225.3,23.74 RH631.1 223.41,23.82 CH346.1 220.67,23.82 220.55,23.95 ; v2(308.08,33.42) 308.43,33.07 308.43,32.33 310.2,30.56 313.75,30.56 314.56,29.75 316.76,29.75 317.57,30.56 318.36,30.56 319.27,31.48 319.27,32.84 319.6,33.17 319.88,33.17 320.1,33.39 320.1,33.82 320.54,34.26 v2(320.54,34.42)
SIO_SLP_S0#: length 214.5
  TOP w0.102: v2(254.01,23.55) v1(254.01,25.93) 254.01,29.1 RZ112.1 252.7,30.38 RZ362.2 251.81,31.73 252.7,32.61 255.23,32.61 255.42,32.8 255.42,34.38 253.92,35.88 251.37,35.88 251,36.25 247.86,36.25 RZ363.1 ; PR425.1 151.85,55.11 v2(153.02,53.94) ; v2(179.44,42.41) 179.45,42.41 179.82,42.78 JAPS1.15
  IN1 w0.089: 199.78,45.74 200.29,45.22 202.03,45.22 202.74,44.51 202.74,41.83 204.77,39.8 205.91,39.8 206.24,40.13 207.25,40.13 207.34,40.04 207.34,40.03 207.58,39.79 207.58,38.63 208.59,37.62 209.09,37.62 209.34,37.37 209.34,35.96 209.13,35.75 209.13,34.29 209.06,34.23 208.81,34.23 207.98,33.4 207.98,32.21 207.41,31.64 207.41,29.01 207.61,28.82 208.83,28.82 209.63,29.61 217.78,29.61 219.66,27.73 221.02,27.73 221.47,28.18 221.47,29.98 222.06,30.57 222.87,30.57 v2(223.39,31.09) 223.44,31.03 223.46,31.03 223.61,30.88
  IN1 w0.099: 223.61,30.88 224.6,29.9 227.39,29.9 227.54,29.75 230.18,29.75 233.38,26.56 235.76,26.56 237.29,25.02 239.64,25.02 239.84,24.82 240.45,24.82 241.86,23.41 253.87,23.41 v2(254.01,23.55) ; 199.78,45.74 198.7,46.81 191.47,46.81 191.27,47.01 185.94,47.01 181.33,42.41 v2(179.44,42.41) 179.45,42.41 179.45,42.99 177.94,44.5 174.91,44.5 174.42,44.99 170.71,44.99 168.93,46.77 164.14,46.77 162.79,48.12 155.97,48.12 153.02,51.07 v2(153.02,53.94)
  BOTTOM w0.089: UH1.BC28 213.72,30.18 213.76,30.23 214.08,30.23 214.2,30.34 214.97,30.34 215.3,30.67 218.07,30.67 218.23,30.51 222.04,30.51 222.05,30.51 222.81,30.51 v2(223.39,31.09)
  BOTTOM w0.102: v2(153.02,53.94) 153.02,54.19 152.29,54.91 143.45,54.91 140.43,57.94 140.43,59.57 139.09,60.91 139.09,68.4 142.87,72.18 142.87,75.92 143.79,76.83 143.79,80.7 142.9,81.58 RH619.1
SIO_SLP_S3#: length 246.1
  TOP w0.102: RH626.1 187.6,45.86 CH341.1 186.86,45.15 v2(186.85,45.14) 186.85,45.11 v1(186.43,44.69) 184.86,43.12 182.08,43.12 180.32,41.35 174.28,41.35 173.38,42.25 173.38,43.35 173.32,43.41 JAPS1.2 ; QE11.2 322.46,17.73 321.61,17.73 321.08,18.26 v2(320.59,18.26) ; v2(332.51,49.96) 332.88,49.96 333.46,49.37 334.39,49.37 335.24,50.22 335.24,50.44 335.58,50.77 336.04,50.77 336.55,50.26 UE5.1 337.33,50.26 337.98,49.61 339.06,49.61 339.35,49.31 RE280.1 339.91,49.21 340.8,49.21 341.07,49.49 341.07,49.59 341.34,49.86 UE3.2
  TOP w0.104: UE1.K9 v2(320.54,32.73)
  IN1 w0.099: v2(320.54,32.73) 320.54,32.72 320.9,32.36 320.9,30.99 320.31,30.41 320.31,27.3 319.53,26.52 319.53,25.71 319.2,25.37 319.2,24.92 317.65,23.38 317.65,18.47 318.52,17.6 319.91,17.6 320.57,18.26 v2(320.59,18.26)
  IN1 w0.122: v2(218.15,22.5) 218.13,22.5 217.94,22.31 216.38,22.31 215.11,21.05 211.55,21.05 211.34,21.26 208.99,21.26 208.95,21.3 208.38,21.3 207.61,22.07 205.7,22.07 203.32,24.44 201.81,24.44 200.99,25.25 200.99,26.95 199.54,28.4 198.35,28.4 197.85,28.9 197.85,31.92 199.62,33.69 199.62,39.85 200,40.23 200,41.47 199.07,42.4 196.8,42.4 195.31,43.89 188.09,43.89 v2(186.85,45.14)
  IN2 w0.102: v2(308.5,30.99) 307.77,30.26 306.32,30.26 302.66,26.59 295.38,26.59 294.44,25.64 292.43,25.64 285.27,18.48 276.23,18.48 274.9,17.16 v2(274.9,16.81)
  IN3 w0.102: v2(274.9,16.81) 274.49,16.41 247.52,16.41 246.71,17.22 235.45,17.22 234.43,18.25 229.99,18.25 229.43,18.81 227.03,18.81 226.41,19.43 225.29,19.43 223.13,21.59 219.06,21.59 v2(218.15,22.5) ; v2(320.54,32.73) 320.54,32.99 320.94,33.39 320.94,33.71 321.2,33.97 321.48,33.97 321.7,34.19 321.7,34.47 321.96,34.73 323.25,34.73 324.36,35.84 325.05,36.53 325.05,37.04 329.03,41.02 329.03,48.05 329.38,48.4 329.38,48.53 330.88,50.02 332.44,50.02 v2(332.51,49.96)
  BOTTOM w0.089: UH1.BF42 215.12,23.32 215.23,23.21 216.71,23.21 217.42,22.5 218.12,22.5 218.13,22.52 218.13,22.5 v2(218.15,22.5)
  BOTTOM w0.102: v2(308.5,30.99) 309.15,30.34 313.69,30.34 314.47,29.55 316.84,29.55 317.66,30.36 318.67,30.36 320.14,31.83 320.14,32.11 320.54,32.5 v2(320.54,32.73)
SIO_SLP_S4#: length 533.6
  TOP w0.089: 204.13,50.17 205.23,49.07 205.8,49.07 206.12,49.39 206.12,50.17
  TOP w0.102: 206.12,50.17 v2(206.12,50.53) ; JAPS1.5 174.82,43.41 174.88,43.35 174.88,42.95 174.62,42.7 v2(174.32,42.7) ; 204.13,50.17 204.13,50.59 203.21,51.51 203.21,55.37 202.17,56.41 191.59,56.41 190.39,55.22 185.43,55.22 184.95,55.7 184.95,57 183.18,58.76 174.29,58.76 170.19,54.66 170.19,53.58 170.75,53.02 170.75,47.98 v2(170.87,47.85) ; UZ21.4 v1(127.07,91.78) 126.22,91.78 126.06,91.95 v2(126.06,92.48) ; UE1.N12 322.75,30.52 322.75,26.84 323.52,26.07 323.52,24 v2(323.39,23.88)
  IN1 w0.099: v2(324.09,18.78) 323.84,18.78 320.5,15.45 316.8,15.45 316.36,15.89 312.88,15.89 311.56,17.22 309.07,17.22 308.02,18.26 308.02,20.25 307.75,20.52 302.88,20.52 302.42,20.98 298.48,20.98 297.03,19.54 296.73,19.54 296,18.8 295.23,18.8 293.65,17.22 286.61,17.22 285.22,18.6 266.19,18.6 265.57,17.98 263.5,17.98 262.88,18.6 258.44,18.6 257.82,17.98 253.96,17.98 253.01,17.04 250.39,17.04 249.96,17.47 240.89,17.47 240.38,17.98 239.62,17.98 238.2,19.41 228.04,19.41 226.93,20.52 222.8,20.52 222.47,20.84 218.02,20.84 217.09,21.77 217.06,21.77 217.06,21.77 v2(217.08,21.77) ; v2(152.03,50.23) 155.29,46.96 161.64,46.96 164.89,43.71 172.44,43.71 173.45,42.7 v2(174.32,42.7) 174.32,41.9 176.02,40.19 176.67,40.19 182.86,34 182.86,24.71 184.4,23.18 184.4,20.9 v2(187.26,18.05)
  IN2 w0.102: v2(43.71,12.17) 43.71,13.02 44.04,13.35 50.01,13.35 50.2,13.54 64.25,13.54 65.9,11.89 65.9,7.96 66.8,7.06 v2(69.49,7.06)
  IN3 w0.102: v2(69.49,7.06) 73.14,10.71 82.76,10.71 83.53,11.48 89.02,11.48 89.99,12.45 99.01,12.45 99.48,12.92 105.34,12.92 106.31,11.95 108.97,11.95 110.15,10.78 138.2,10.78 138.71,11.28 156.56,11.28 158.49,13.21 170,13.21 170.23,13.44 175.23,13.44 177.39,15.6 179.59,15.6 181.66,17.67 186.88,17.67 v2(187.26,18.05) ; v2(206.12,50.53) 206.08,50.53 205.79,50.24 205.79,48.73 205.44,48.39 205.44,46.51 204.67,45.73 204.67,37.81 205.46,37.02 205.46,35.88 206.41,34.92 210.45,34.92 211.04,35.52 214.52,35.52 214.89,35.15 216.34,35.15 216.81,34.68 216.81,34.15 217.7,33.26 217.7,32.12 218.86,30.96 218.86,26.29 217.09,24.52 217.09,21.79 217.07,21.77 v2(217.08,21.77) ; v2(174.32,42.7) 174.11,42.7 171.47,45.34 171.47,46.65 170.87,47.24 v2(170.87,47.85) 170.89,47.86 170.89,49.34 171.45,49.9 171.45,56.59 143.73,84.31 137.79,84.31 130.93,91.16 126.46,91.16 126.06,91.57 v2(126.06,92.48)
  BOTTOM w0.089: UH1.BE42 214.54,23.29 214.73,23.1 215.06,23.1 215.22,22.95 215.89,22.95 217.07,21.77 v2(217.08,21.77)
  BOTTOM w0.102: UZ34.2 v2(152.03,50.23) ; v2(170.87,47.85) 172.51,49.49 CH342.1 173.33,50.15 RH627.1 ; v2(323.39,23.88) 323.39,22.88 324.43,21.84 324.43,19.12 v2(324.09,18.78)
  BOTTOM w0.254: v2(43.71,12.17) 43.71,11.96 43.15,11.41 PR208.2 ; v2(69.49,7.06) 67.66,7.06 67.36,6.76 67.36,5.91 67.7,5.57 PR513.1
SIO_SLP_S5#: length 189.5
  TOP w0.089: RH632.1 219.82,23.25 219.85,23.25
  TOP w0.102: JAPS1.4 174.32,43.55 173.91,43.14 173.91,42.1 174.43,41.58 180.22,41.58 183.24,44.6 v1(183.52,44.6) 185.64,44.6 v2(186.22,45.17) ; 219.85,23.25 CH347.1 220.52,22.53 v2(220.46,22.47)
  TOP w0.104: UE1.N8 319.32,30.28 v2(319.35,30.25)
  IN1 w0.122: v2(220.46,22.47) 220.38,22.47 219.74,23.11 219.04,23.11 218.7,23.46 214.63,23.46 212.43,21.26 211.64,21.26 211.12,21.78 210.02,21.78 209.76,22.04 208.62,22.04 207.81,22.86 207.81,23.15 207.57,23.39 206.47,23.39 205.64,24.22 205.64,35.68 203.35,37.97 203.35,38.95 198.81,43.48 197.25,43.48 196.14,44.59 189.1,44.59 188.08,45.6 186.65,45.6 v2(186.22,45.17)
  IN2 w0.102: v2(274.23,16.85) 274.27,16.85 276.13,18.71 285.18,18.71 292.33,25.87 294.34,25.87 295.29,26.82 302.56,26.82 306.46,30.72 307.62,30.72 v2(308.48,31.57)
  IN3 w0.102: v2(274.23,16.85) 274.01,16.64 256.64,16.64 255.53,17.74 250.71,17.74 250.41,17.45 235.55,17.45 233.86,19.14 229.67,19.14 229.58,19.04 227.12,19.04 226.5,19.66 225.38,19.66 223.22,21.82 220.85,21.82 220.46,22.21 v2(220.46,22.47)
  BOTTOM w0.089: 219.47,22.87 218.99,22.87 218.92,22.94 218.72,22.94 217.91,23.75 215.81,23.75 215.63,23.93 215.15,23.93 214.97,23.75 214.17,23.75 214.04,23.62 213.76,23.62 213.74,23.59 UH1.BC42
  BOTTOM w0.102: v2(319.35,30.25) 319.17,30.25 318.98,30.05 317.64,30.05 316.93,29.35 314.39,29.35 313.63,30.1 308.81,30.1 308.09,30.82 308.09,31.19 v2(308.48,31.57) ; 219.47,22.87 220.02,22.87 220.42,22.47 v2(220.46,22.47)
SIO_SLP_SUS#: length 221.6
  TOP w0.102: v2(314.34,8.8) 315.22,9.68 315.22,14.53 312.76,16.99 v1(312.76,17.55) 312.85,17.65 312.85,20.92 312.12,21.66 312.12,22.92 313.64,24.44 313.64,26.14 RE349.1
  IN2 w0.102: v2(211.9,27.18) 211.9,27.73 211.1,28.54 199.59,28.54 199.35,28.78 198.84,28.78 197.71,29.91 190.71,29.91 189.48,31.14 188.24,31.14 187.66,31.71 181.7,31.71 v2(181.63,31.77)
  IN3 w0.102: v2(314.34,8.8) 314.34,9.33 313.57,10.1 308.99,10.1 307.98,9.08 299.77,9.08 298.15,10.7 294.8,10.7 293.77,9.68 287.03,9.68 285.42,8.07 270.88,8.07 268.47,5.66 263.88,5.66 262.85,4.63 254.59,4.63 252.08,2.12 223.26,2.12 222.97,1.83 211.96,1.83 211.73,2.06 205.47,2.06 204.69,2.83 204.69,3.47 203.95,4.22 203.31,4.22 201.32,6.2 193.21,6.2 192.86,5.85 v2(192.85,5.85)
  BOTTOM w0.089: UH1.BD39 213.5,25.12 213.11,25.51 213.11,25.95 213.24,26.09 213.24,26.42 213.09,26.57 212.72,26.57 212.31,26.97 212.07,26.97 211.9,27.14 v2(211.9,27.18)
  BOTTOM w0.102: RH441.1 192.79,5.17 192.69,5.27 192.69,5.68 192.85,5.83 v2(192.85,5.85) 192.84,5.85 189.6,9.09 189.6,13.13 188.05,14.68 184.45,14.68 181.01,18.12 181.01,28.78 181.63,29.4 v2(181.63,31.77) 182.06,32.21 CH345.1 182.32,32.18 RH630.1
SIO_SLP_SUS#_R: length 5.1
  TOP w0.102: 316.12,30.17 v1(314.42,28.47) 314.29,28.34 314.29,27.71 RE349.2 313.98,27.39 RE561.1
  TOP w0.104: UE1.N4 316.12,30.17
SIO_SLP_WLAN#: length 215.6
  TOP w0.089: CH344.1 218.49,24.41 218.64,24.26 RH629.1 218.64,23.63 219.43,22.84
  TOP w0.102: v2(291.07,50.21) 290.85,49.99 v1(290.85,47.6) 290.85,43.22 291.7,42.37 291.7,39.92 290.95,39.17 288.96,39.17 286.1,36.31 286.1,33.22 279.62,26.74 279.62,24.62 281.69,22.55 281.69,21.25 279.95,19.51 v2(279.95,17.91) ; QZ15.1 283.26,2.12 283.96,1.42 290.94,1.42 291.32,1.8 291.32,3.96 291.5,4.14 298.42,4.14 299.64,5.36 299.64,8.91 298.87,9.69 298.87,18.35 298.99,18.48 v2(298.99,18.55) ; v2(219.85,22.47) 219.8,22.47 219.43,22.84
  TOP w0.104: UE1.D9 v2(320.52,38.35)
  IN3 w0.102: v2(298.99,18.55) 298.91,18.55 298.27,17.91 295.51,17.91 294.99,17.39 287.04,17.39 286.4,18.03 280.07,18.03 v2(279.95,17.91) 279.17,17.91 278.52,17.26 266.9,17.26 266.36,17.8 262.99,17.8 262.7,18.1 258.9,18.1 258.49,17.68 255.92,17.68 255.63,17.97 250.61,17.97 250.32,17.68 235.89,17.68 232.64,20.92 231.45,20.92 230.7,21.68 230.32,21.68 229.72,22.27 223.69,22.27 223.47,22.05 221.8,22.05 220.98,22.87 220.25,22.87 v2(219.85,22.47)
  BOTTOM w0.089: 219.1,22.51 218.86,22.75 218.65,22.75 217.85,23.56 215.73,23.56 215.56,23.74 215.23,23.74 215.05,23.56 214.24,23.56 214.06,23.37 UH1.BD42
  BOTTOM w0.102: 219.1,22.51 219.15,22.47 v2(219.85,22.47) ; v2(291.07,50.21) 302.53,50.21 304.08,48.67 313.05,48.67 315.79,51.41 320.77,51.41 322.45,49.73 322.45,49.5 322.63,49.33 322.63,48.31 321,46.68 321,44.51 321.55,43.96 321.55,43.42 322.47,42.5 322.47,40.97 322.55,40.89 322.55,40.58 321.5,39.53 321.16,39.53 320.94,39.31 320.94,38.98 320.52,38.56 v2(320.52,38.35)
SKL_CNL#: length 10.1
  TOP w0.102: v2(77.82,51.4) 77.8,51.42 77.61,51.42 75.89,49.7 v1(75.89,49.03) 75.89,48.48 RC171.2
  BOTTOM w0.102: UC1.BN1 82.37,53.11 80.37,51.1 78.12,51.1 v2(77.82,51.4)
SLEEVE: length 1
  TOP w0.102: v2(348.16,37.29) v1(349.16,37.29)
  vias: v2(347.51,37.28)
SLEEVE_R: length 19.5
  IN1 w1.27: JHP1.4 366.97,25.67 365.32,24.03 357.93,24.03 356.28,25.68 356.28,32.58
  vias: v2(350.44,38.25) v2(350.82,37.62) v2(353.13,33.4) v2(353.76,33.4) v2(354.9,33.55) v2(355.53,33.55)
SLOT2_SATA_LED#: length 5.2
  BOTTOM w0.102: JNGFF2.10 326.9,60.68 326.9,62.39 RN101.1 327.83,63.35 327.36,63.82 327.36,65.29 v1(327.34,65.32)
SLP_WLAN#_GATE: length 82.4
  TOP w0.102: v1(286.27,1.84) 285.94,2.17 QZ15.2 285.05,2.17 284.34,2.88 v2(284.34,2.88) 283.87,3.35 282.51,3.35 282.18,3.02 RZ518.2 282.15,3.45 282.02,3.58 280.91,3.58 280.52,3.19 280.52,2.12 280.42,2.03 QZ16.2
  IN1 w0.099: v2(284.34,2.88) 284.45,3 290.56,3 291.34,3.78 296.54,3.78 296.92,3.41 313.46,3.41 315.21,5.16 315.38,5.16 316.85,6.63 318.41,6.63 319.53,5.51 322.78,5.51 332.5,15.23 v2(332.5,15.44)
  BOTTOM w0.102: v2(332.5,15.44) 332.25,15.44 330.28,17.41 330.28,18.1 328.63,19.74 328.63,23.22 326.06,25.79 325.46,25.79 324.67,26.58 324.67,27.19 324.19,27.67 324.19,28.9 RE552.1
SLP_WLAN#_M: length 12.5
  TOP w0.102: DZ9.3 289.81,1.8 v1(287.92,1.8) 287.37,1.8 RZ71.1 285.71,3.47 QZ15.3 284.52,3.47 284.23,3.76 282.82,3.76 282.77,3.81 281.48,3.81 281.19,4.1 RZ375.2 279.84,4.32 QZ16.3
SML0_SMBCLK: length 164.5
  TOP w0.107: RH67.2 220.75,32.29 v2(220.88,32.42) ; UL1.28 317.33,87.3 v2(317.16,87.47)
  IN1 w0.099: v2(317.16,87.47) 317.58,87.04 317.88,87.04 318.24,86.68 318.24,81.8 317.04,80.59 317.04,78.68 319.62,76.1 320.72,76.1 322.14,74.68 322.14,68.09 319.51,65.46 315.67,65.46 312.98,62.77 309.16,62.77 296.06,49.67 296.06,46.32 291.64,41.9 291.64,39.47 290.32,38.15 290.32,36.55 v2(290.37,36.5)
  IN3 w0.102: v2(282.6,25.51) 282.54,25.57 282.54,25.93 282.16,26.31 281.51,26.31 280.04,24.85 272.57,24.85 271.16,23.43 265.36,23.43 265,23.06 261.97,23.06 261.59,23.44 257.19,23.44 256.89,23.14 253.71,23.14 253.05,23.8 239.19,23.8 237.18,25.82 236.49,25.82 235.71,26.6 234.58,26.6 229.05,32.14 229.05,32.33 227.72,33.66 224.12,33.66 223.91,33.45 221.81,33.45 220.88,32.52 v2(220.88,32.42)
  BOTTOM w0.089: UH1.BF25 214.97,31.79 215.2,31.55 218.54,31.55 218.7,31.39 220.4,31.39 220.77,31.76 CC318.1 220.77,32.31 v2(220.88,32.42)
  BOTTOM w0.107: v2(282.6,25.51) 282.55,25.56 282.55,28.31 290.37,36.13 v2(290.37,36.5)
SML0_SMBDATA: length 163.8
  TOP w0.107: v2(317.16,86.14) 317.2,86.1 UL1.31 ; RH77.2 222.17,32.93 v2(222.17,32.51)
  IN1 w0.099: v2(289.78,36.5) 289.84,36.55 289.84,38.35 291.16,39.67 291.16,42.1 295.58,46.52 295.58,49.86 308.96,63.25 312.79,63.25 315.47,65.94 319.31,65.94 321.66,68.29 321.66,74.48 320.52,75.62 319.42,75.62 316.56,78.48 316.56,80.79 317.76,82 317.76,86.48 317.68,86.56 317.58,86.56 v2(317.16,86.14)
  IN3 w0.102: v2(222.17,32.51) 222.04,32.64 222.04,32.87 222.14,32.97 224.11,32.97 224.32,33.17 227.52,33.17 228.56,32.13 228.56,31.94 234.38,26.12 235.51,26.12 236.29,25.34 236.98,25.34 238.99,23.32 252.85,23.32 253.51,22.66 257.09,22.66 257.39,22.96 261.39,22.96 261.77,22.58 265.2,22.58 265.56,22.94 271.36,22.94 272.77,24.36 280.24,24.36 281.71,25.83 281.96,25.83 282.06,25.73 282.06,25.56 v2(282.01,25.51)
  BOTTOM w0.089: UH1.BE24 214.42,32.48 214.5,32.55 214.84,32.55 214.98,32.41 218.46,32.41 218.62,32.57 219.48,32.57 219.86,32.95 221.56,32.95 221.72,32.79
  BOTTOM w0.107: v2(282.01,25.51) 282.06,25.56 282.06,28.51 289.78,36.23 v2(289.78,36.5) ; 221.72,32.79 222,32.51 v2(222.17,32.51)
SML1_SMBCLK: length 148.5
  TOP w0.107: RH80.2 224.94,29.73 224.46,30.21 224.46,31.29 224.62,31.45 225.68,31.45 226.15,30.98 CC319.1 226.63,31.08 225.98,31.74 223.15,31.74 222.81,31.4 v2(222.81,31.15) ; v2(319.72,38.35) UE1.D8
  IN1 w0.099: v2(318.78,19.45) 319.27,19.94 319.27,20.38 321.4,22.5 321.4,23.89 322.9,25.39 322.9,27.21 323.48,27.79 323.48,34.89 323.78,35.2 323.78,36.4 323.3,36.88 323.19,36.88 322.94,37.13 322.21,37.13 322.2,37.13 321.2,37.13 320.94,37.39 320.94,37.67 320.64,37.97 320.36,37.97 319.98,38.35 v2(319.72,38.35)
  IN3 w0.102: v2(318.78,19.45) 318.77,19.43 316.6,19.43 315.13,20.9 309.5,20.9 309.4,21.01 303.11,21.01 298.93,25.18 298.93,26.23 298.57,26.59 293.83,26.59 290.89,23.65 273.07,23.65 271.62,22.2 265.84,22.2 265.31,21.67 261.51,21.67 260.94,22.24 257.91,22.24 257.61,21.95 253.07,21.95 252.41,22.61 238.7,22.61 236.69,24.62 236,24.62 235.21,25.41 234.09,25.41 228.42,31.07 227.52,31.07 226.9,31.7 223.05,31.7 222.81,31.46 v2(222.81,31.15)
  BOTTOM w0.089: UH1.BF27 214.96,30.59 215.21,30.85 218.17,30.85 218.32,30.69 222.35,30.69
  BOTTOM w0.102: 222.35,30.69 v2(222.81,31.15)
SML1_SMBDATA: length 140.8
  TOP w0.107: v2(322.12,36.75) UE1.E11 ; v2(222.18,31.16) 222.18,31.65 222.75,32.22 226.19,32.22 226.54,31.87 RH81.2
  IN1 w0.099: v2(322.12,36.75) 322.22,36.65 322.67,36.65 322.93,36.4 323.1,36.4 323.3,36.2 323.3,35.39 323,35.09 323,27.99 322.42,27.41 322.42,25.58 320.92,24.09 320.92,22.7 318.79,20.57 318.79,20.13 v2(318.77,20.12)
  IN3 w0.102: v2(318.77,20.12) 318.57,19.91 316.8,19.91 315.33,21.38 309.7,21.38 309.6,21.49 303.31,21.49 299.42,25.38 299.42,26.43 298.77,27.08 293.63,27.08 290.69,24.13 272.87,24.13 271.42,22.68 265.64,22.68 265.11,22.15 261.71,22.15 261.14,22.73 257.71,22.73 257.41,22.43 253.27,22.43 252.61,23.09 238.9,23.09 236.89,25.11 236.2,25.11 235.41,25.89 234.29,25.89 228.62,31.56 227.72,31.56 227.1,32.18 222.94,32.18 222.25,31.5 222.25,31.26 222.18,31.19 v2(222.18,31.16)
  BOTTOM w0.089: UH1.BE27 214.5,30.83 214.92,30.83 215.12,31.02 218.26,31.02 218.42,30.87 221.69,30.87 221.9,31.08 222.09,31.08
  BOTTOM w0.102: 222.09,31.08 v2(222.18,31.16)
SNUB_1.8VALW: length 1.1
  BOTTOM w0.102: PC506.1 v1(129.55,4.52)
SNUB_1VS_VCCIO: length 1.1
  BOTTOM w0.102: v1(141.06,60.27) 141.41,59.92 PC403.1
SNUB_+1VALWP: length 1.7
  TOP w0.102: PR303.2 v1(173.97,2.25)
SNUB_CHG1: length 1.2
  TOP w0.102: PC940.1 v1(11.68,25.42)
SNUB_CHG2: length 1.5
  TOP w0.102: PR924.2 v1(11.4,14.97)
SPKR: length 169.5
  TOP w0.089: RH86.2 219.72,27.68 v1(220.37,27.02) 220.44,26.96 v2(221.59,26.96)
  IN1 w0.099: v2(221.59,26.96) 213.47,26.96 212.11,28.31 212.11,28.42 211.68,28.85 v2(211.68,29.01)
  IN2 w0.102: v2(338.43,25.31) 337.37,24.24 336.49,24.24 331.57,29.17 331.57,30.9 329.84,32.63 329.84,34.62 329.64,34.82 327.46,34.82 327.37,34.73 324.49,34.73 323.57,33.81 323.57,32.69 322.67,31.78 322.67,28.96 322.13,28.42 318.93,28.42 318.59,28.76 318.59,29.23 318.28,29.54 313.91,29.54 313.01,30.43 311.73,30.43 308.04,34.12 300.99,34.12 297.04,30.17 288.9,30.17 288.25,30.82 284.58,30.82 278.85,25.09 262.55,25.09 262.31,24.85 257.06,24.85 256.82,25.09 229.73,25.09 227.5,27.32 223.31,27.32 222.79,26.81 221.85,26.81 221.85,26.81 221.73,26.81 v2(221.59,26.96)
  BOTTOM w0.089: UH1.AW29 211.5,29.18 v2(211.68,29.01)
  BOTTOM w0.102: RA12.2 345.28,30.64 348.02,27.9 348.02,25.82 347.88,25.68 338.8,25.68 v2(338.43,25.31)
SPKR_R: length 9.6
  TOP w0.254: RA51.1 CA72.1 352.76,35.75 v1(352.09,35.75) 351.6,35.75 350.54,34.7 CA27.1 349.86,33.84 v2(349.86,33.64)
  BOTTOM w0.254: v2(349.86,33.64) 349.39,33.17 347.9,33.17 347.65,33.43 RA12.1
SRTCRST#: length 6.1
  TOP w0.102: v2(213.75,21.93) 213.75,21.88 214.4,21.23 214.4,19.47 v1(214.16,19.23) 213.71,18.78 CH41.2 213.71,18.1 214.44,17.37 RH201.2
  BOTTOM w0.089: v2(213.75,21.93) 213.76,21.92 213.97,21.49 UH1.BD46
SS_1VS_VCCIO: length 2.8
  BOTTOM w0.254: PU401.7 151.73,61.73 151.93,61.93 151.93,62.29 151.62,62.6 PR427.2 151.62,63.09 PC409.1
SUSACK#: length 132.2
  TOP w0.104: UE1.K12 322.92,32.75 322.92,31.35 323.13,31.14 323.79,31.14 323.9,31.04 323.9,30.89 324.17,30.62 324.17,27.69 324.79,27.08 324.79,26.69 325.55,25.93 325.55,23.9 324.61,22.96 324.61,21.39 v1(324.02,20.8) v2(324.02,19.51)
  IN1 w0.089: 223.61,27.32 222.96,27.32 v2(222.03,26.39)
  IN1 w0.099: 223.61,27.32 225.2,27.32 226.04,26.48 226.04,25.89 227.98,23.95 230.79,23.95 231.21,23.54 233.54,23.54 234.49,22.6 238.64,22.6 238.84,22.4 239.44,22.4 240.85,20.98 241.74,20.98 242.93,19.79 246.9,19.79 247.65,20.54 289.97,20.54 290.17,20.74 294.6,20.74 295.39,21.53 296.28,21.53 298.03,23.29 307.44,23.29 307.72,23.01 310.33,23.01 311.3,22.05 311.3,19.09 313.62,16.76 317.25,16.76 317.8,16.21 318.34,15.67 320.41,15.67 324.02,19.29 v2(324.02,19.51)
  BOTTOM w0.089: RH443.2 220.18,27.52 220.19,27.51 220.19,27.49 221.22,26.47 221.96,26.47 v2(222.03,26.39)
SUSACK#_R: length 6.4
  BOTTOM w0.089: UH1.BE35 214.46,26.7 214.53,26.62 214.81,26.62 215.06,26.87 217.97,26.87 218.68,27.58 RH443.1 219.26,27.13 219.25,27.12 RH327.1
SUSCLK: length 156.1
  TOP w0.102: RH83.1 215.07,20.94 214.4,21.6 214.4,22.09 v2(214.2,22.29)
  TOP w0.107: v2(334.26,17.35) 334.26,16.99 334.2,16.92 334.2,14.6 334.82,13.98 334.82,11.71 335.34,11.19 v1(340.67,11.19) 343.4,11.19 343.82,10.77 RN99.2
  IN1 w0.089: 214.53,22.29 v2(214.2,22.29)
  IN1 w0.099: v2(310.51,17.98) 309.96,18.53 309.96,19.67 308.45,21.18 303.08,21.18 302.67,21.59 298.22,21.59 296.78,20.14 296.48,20.14 295.75,19.41 294.98,19.41 294.12,18.55 286.13,18.55 285.47,19.21 254.32,19.21 252.76,17.64 250.64,17.64 250.21,18.08 242.22,18.08 241.03,19.27 239.19,19.27 238.45,20.01 229.66,20.01 228.55,21.12 225.18,21.12 224.68,21.62 219.55,21.62 217.91,23.26 215.5,23.26 214.53,22.29
  IN3 w0.102: v2(334.26,17.35) 333.9,17.35 333.43,16.89 318.01,16.89 317.34,17.56 310.94,17.56 v2(310.51,17.98)
  BOTTOM w0.089: v2(214.2,22.29) 214.19,22.23 214.33,21.98 UH1.BE45
  BOTTOM w0.107: v2(310.51,17.98) 310.26,18.24 310.26,22.75 306.5,26.51 RZ56.1
SUSCLK_R: length 8.3
  TOP w0.102: RN99.1 344.32,9.12 v1(344.32,7.53) v2(344.32,6.17)
  BOTTOM w0.102: v2(344.32,6.17) 344.47,6.02 344.47,3.3 343.8,2.63 JNGFF3.68
SW1_2PH: length 10.1
  TOP w0.203: PR1749.2 52.93,72.01 PR1763.2 51.94,71.96 v1(51.94,66.65) 51.94,64.78 v2(52.57,64.14)
  BOTTOM w0.254: v2(52.57,64.14) PL2000.2
SW1_4PH: length 20.6
  TOP w0.152: v2(59.13,92.39) 58.72,91.97 PR1747.1
  IN1 w0.152: v2(75.78,91.7) 75.36,92.13 59.39,92.13 v2(59.13,92.39)
  BOTTOM w0.152: PR1757.1 59.05,91.34 v1(59.11,91.4) 59.11,92.36 v2(59.13,92.39)
  BOTTOM w0.254: PL1802.2 76,91.91 v2(75.78,91.7)
SW2_4PH: length 29.7
  TOP w0.152: v2(59.17,93.07) 59.17,93.47 59.02,93.62 58.78,93.62 PR1750.1
  IN1 w0.152: v2(83.91,91.62) 83.86,91.62 83.08,92.4 59.83,92.4 v2(59.17,93.07)
  BOTTOM w0.102: v1(59.62,92.63) 59.18,93.07 v2(59.17,93.07)
  BOTTOM w0.152: PR1764.1 58.91,93.11 59.13,93.11 v2(59.17,93.07)
  BOTTOM w0.254: v2(83.91,91.62) 83.52,92 PL1803.2
SW3_4PH: length 38.4
  TOP w0.152: PR1751.1 59.6,94.51 59.75,94.36 v1(59.75,93.88) v2(59.75,93.15)
  IN1 w0.152: v2(59.75,93.15) 60.22,92.68 60.5,92.68 62.16,94.35 88.64,94.35 90.42,92.57 90.42,92.02 v2(90.59,91.86)
  BOTTOM w0.152: PR1765.1 58.29,93.5 59.41,93.5 v2(59.75,93.15)
  BOTTOM w0.254: v2(90.59,91.86) 90.63,91.86 91.04,92.27 PL1900.2
SW4_4PH: length 47.9
  TOP w0.152: PR1752.1 59.15,95.78 v1(59.52,95.41) 60.36,94.57 v2(60.36,93.15)
  IN1 w0.152: v2(60.36,93.15) 61.83,94.63 96.31,94.63 v2(99.02,91.92)
  BOTTOM w0.152: PR1766.1 59.13,94.39 v2(60.36,93.15)
  BOTTOM w0.254: v2(99.02,91.92) 98.57,92.37 PL1901.2
SW_1PH: length 65
  TOP w0.102: v2(114.23,91.03) v1(113.69,91.03)
  IN1 w0.152: v2(68.37,86.98) 69.3,86.98 71.84,89.52 71.84,90.92 72.16,91.24 75.93,91.24 76.69,92 82.77,92 83.63,91.15 84.16,91.15 86.36,93.34 88.49,93.34 90.44,91.39 90.73,91.39 91.51,92.18 98.15,92.18 98.86,91.47 99.4,91.47 102.51,94.58 106.77,94.58 107.16,94.97 107.16,96.11 108.62,97.57 112.61,97.57 114.23,95.95 v2(114.23,91.03)
  BOTTOM w0.203: v2(68.37,86.98) 68.02,86.63 68.02,85.13 PR1702.2
  BOTTOM w0.254: PL2001.2 114.23,92.24 v2(114.23,91.03)
SW_USB20_1_N4: length 34.1
  TOP w0.089: RT122.2 16.61,111.91 16.87,111.91 16.97,111.82 16.97,110.68 16.68,110.4 16.68,106.57 18.45,104.8 19.12,104.8 24,99.92 27.19,99.92 29.85,97.26 30.48,97.26 v2(30.81,96.93)
  BOTTOM w0.076: UT5.L7 33.46,90.77 33.46,92.01 33.66,92.22 33.66,92.95 33.9,93.18 33.9,93.37
  BOTTOM w0.089: 33.9,93.37 33.9,95.25 v4(32.7,96.44) 31.76,97.38 30.58,97.38 30.45,97.25 30.45,97.06 30.58,96.93 v2(30.81,96.93)
SW_USB20_1_N4_R: length 10.4
  TOP w0.089: v2(6.88,113.37) 7.08,113.58 7.2,113.59 7.59,113.59 8.5,112.68 10.45,112.68 10.54,112.59 10.93,112.59 11.08,112.44 DT40.9 DT40.1 12.76,112.44 12.98,112.66 v4(13.39,112.66) 13.7,112.66 14.47,111.89 15.07,111.89 RT122.1
  BOTTOM w0.089: v2(6.88,113.37) 6.87,113.38 JUSBC1.B7
SW_USB20_1_P4: length 34.2
  TOP w0.089: v2(30.78,97.79) 30.44,97.44 29.93,97.44 27.27,100.11 24.08,100.11 19.2,104.99 18.53,104.99 16.87,106.65 16.87,110.32 17.15,110.6 17.15,111.9 16.95,112.1 16.56,112.1 16.29,112.37 RT123.2
  BOTTOM w0.076: 34.08,93.37 34.08,93.36 34.07,93.34 34.07,93.3 34.06,93.29 34.06,93.12 33.83,92.88 33.83,92.15 33.62,91.94 33.62,90.59 33.38,90.35 UT5.K7
  BOTTOM w0.089: 34.08,93.37 34.08,95.33 33.06,96.35 33.06,96.39 32.65,96.8 32.61,96.8 31.84,97.57 31,97.57 v2(30.78,97.79)
SW_USB20_1_P4_R: length 10.4
  TOP w0.089: RT123.1 14.95,112.08 14.55,112.08 13.75,112.88 12.82,112.88 12.76,112.94 DT40.2 DT40.8 11.17,112.94 11.01,112.78 10.61,112.78 10.52,112.86 8.58,112.86 7.67,113.78 7.19,113.78 7.07,113.77 v2(6.85,113.97)
  BOTTOM w0.089: JUSBC1.B6 6.76,113.88 v2(6.85,113.97)
SW_USB20_2_N4: length 38.6
  TOP w0.089: v2(30.25,96.21) 30.64,96.21 30.73,96.13 30.73,95.92 30.35,95.54 29.49,95.54 29.08,95.94 29.08,96.83 27.07,98.84 23.53,98.84 15.16,107.22 15.16,108.91 15.86,109.61 15.86,110.64 16.11,110.89 v2(16.11,110.95)
  BOTTOM w0.076: 33.13,93.37 33.13,93.36 33.14,93.34 33.14,93.3 33.15,93.29 33.15,92.29 32.96,92.1 32.96,90.77 UT5.L6
  BOTTOM w0.089: v2(30.25,96.21) 30.55,96.21 30.96,95.81 31.09,95.81 31.43,95.47 31.57,95.47 31.58,95.46 32.67,95.46 33.13,95 33.13,93.37 ; RT121.1 16.22,113.68 16.53,113.37 17.13,113.37 17.45,113.06 17.45,111.98 16.87,111.4 16.01,111.4 15.92,111.31 15.92,111.05 16.02,110.95 v2(16.11,110.95)
SW_USB20_2_N4_R: length 8.2
  BOTTOM w0.089: RT121.2 14.97,113.37 14.84,113.37 14.41,113.81 DT39.8 DT39.2 12.54,113.81 12.41,113.68 11.68,113.68 11.29,114.07 10.46,114.07 10.36,113.97 8.42,113.97 8.26,114.13 JUSBC1.A7
SW_USB20_2_P4: length 38.6
  TOP w0.089: v2(15.53,110.95) 15.67,110.81 15.67,109.69 14.97,108.99 14.97,107.14 23.45,98.65 27,98.65 28.9,96.75 28.9,95.87 29.41,95.35 30.43,95.35 30.92,95.84 30.92,96 v2(31.14,96.21)
  BOTTOM w0.076: UT5.K6 33.13,90.43 33.13,92.03 33.31,92.22 33.31,93.37
  BOTTOM w0.089: 33.31,93.37 33.31,95.08 32.75,95.65 31.55,95.65 31.14,96.06 v2(31.14,96.21) ; v2(15.53,110.95) 15.6,110.95 15.73,111.09 15.73,111.39 15.93,111.59 16.8,111.59 17.26,112.05 17.26,112.98 17.05,113.18 16.62,113.18 RT120.1
SW_USB20_2_P4_R: length 8.3
  BOTTOM w0.076: 13.66,113.31 DT39.9
  BOTTOM w0.089: RT120.2 14.91,113.18 14.76,113.18 14.52,113.43 14.46,113.43 14.34,113.31 DT39.9 ; JUSBC1.A6 8.26,113.63 8.42,113.78 10.44,113.78 10.54,113.88 11.21,113.88 11.63,113.46 v4(11.92,113.46) 12.38,113.46 12.54,113.31 DT39.1 13.66,113.31
SYS_PWROK: length 344.4
  TOP w0.089: 212.25,50.17 212.25,48.62 213.33,47.54 214.05,47.54 v2(214.06,47.53)
  TOP w0.102: 212.25,50.17 212.25,50.44 213.14,51.33 v3(213.14,52.29) 213.14,53.53 210.59,56.08 v2(210.59,56.48) ; RC129.1 57.07,45.62 58.21,46.76 58.21,52.2 57.26,53.15 56.96,53.15 56.49,53.62 56.49,54.77 v2(56.45,54.81)
  BOTTOM w0.089: UH1.AU3 210.38,42.64 210.6,42.87 210.6,43.38 210.63,43.4 210.63,44.49 213.67,47.53 v2(214.06,47.53) 214.63,48.1 215.9,48.1 216.02,48.23 RH199.1
  BOTTOM w0.102: RE548.1 312.17,41.52 RE56.1 311.55,42.14 311.5,42.14 311.25,42.39 311.25,43.89 308.89,46.25 306.84,46.25 305.37,47.73 303.62,47.73 302.26,49.09 290.7,49.09 285.97,44.35 285.97,37.73 280.71,32.47 269.88,32.47 269.06,33.29 252.13,33.29 251.79,33.62 246.33,33.62 244.18,35.77 241.89,35.77 237.86,39.8 230.85,39.8 229.33,41.31 229.33,45 219.19,55.14 211.93,55.14 v2(210.59,56.48) 210.01,57.06 210.01,57.61 203.76,63.87 203.15,63.87 200.48,66.54 200.48,66.7 197.43,69.74 171.75,69.74 170.35,68.35 170.35,67.65 163.45,60.74 163.45,59.07 159.33,54.96 159.33,52.96 150.04,43.66 61.42,43.66 57.43,47.66 57.43,54.54 57.16,54.81 v2(56.45,54.81)
SYS_PWROK_R: length 278.3
  TOP w0.102: JXDP1.47 44.17,40.33 44.15,40.35 44.15,40.63 43.48,41.3 43.48,42.21 43.93,42.66 47.7,42.66 48.96,43.92 52.33,43.92 53.18,44.78 CC33.1 53.36,44.78 RC129.2 RC133.2 ; v2(230,12.36) 230.07,12.43 230.07,12.44 232.29,14.66 232.29,17.58 233.22,18.5 233.22,20.98 234.42,22.18
  TOP w0.107: 234.42,22.18 234.42,24.7 234.76,25.04 234.76,29.95 234.42,30.29 234.42,36.19 233.9,36.71 233.9,43.36 224.07,53.18 222.75,53.18 219.96,50.39 218.67,50.39 217.99,51.08 217.99,53.03 208.4,62.62 194.09,62.62 v1(192.91,63.8) 191.11,65.61 187.34,65.61 v2(183.69,69.26) ; RC129.2 55.09,44.73 57.32,44.73 58.89,46.3 58.89,52.31 57.02,54.18 v2(56.94,54.18)
  BOTTOM w0.102: v2(230,12.36) 230.08,12.36 230.45,12.72 RC128.2
  BOTTOM w0.107: v2(183.69,69.26) 172.2,69.26 170.85,67.9 170.85,65.02 161.52,55.69 161.52,54.1 150.6,43.18 60.75,43.18 56.94,46.98 v2(56.94,54.18)
SYS_RESET#: length 58.5
  TOP w0.102: JAPS1.13 178.82,45.35 179.64,46.16 179.64,53.02 180.91,54.29 192.67,54.29 193.7,55.32 v1(195.67,55.32) 198.42,55.32 v2(200.81,52.93)
  IN1 w0.099: v2(200.81,52.93) 202.79,52.93 204.09,51.63 211.2,51.63 213.24,49.59 214.14,49.59 v2(214.82,48.92)
  BOTTOM w0.089: 215.93,49.58 215.86,49.51 RH66.2 215.41,49.51 v2(214.82,48.92) 212.79,46.9 CC302.1 211.79,46.43 211.79,45.92 210.44,44.56 210.44,43.48 210.35,43.39 UH1.AU2
  BOTTOM w0.102: 215.93,49.58 215.95,49.6 UC3.4
SYSTEM_ID: length 6.7
  TOP w0.104: UE1.J10 v2(321.32,33.55)
  BOTTOM w0.102: RE300.2 325.45,33.66 325.45,33.2 v1(324.96,32.71) 324.65,32.71 324.09,32.16 323.26,32.16 322.99,32.43 CE47.1
  BOTTOM w0.104: CE47.1 322.58,33.14 321.95,33.14 321.93,33.17 321.7,33.17 v2(321.32,33.55)
TACH_FAN1: length 161.1
  TOP w0.102: RE51.2 204.31,67.6 v2(204.31,68.39) 204.47,68.54 v1(205.28,68.54)
  TOP w0.104: UE1.E3 v2(314.92,37.55)
  BOTTOM w0.102: v2(314.92,37.55) 314.92,37.58 314.5,38 314.5,39.9 312.95,41.45 312.95,43.75 313.37,44.17 314.65,44.17 314.91,44.42 314.91,46.23 313.86,47.27 311.47,47.27 310.3,48.44 303.92,48.44 302.55,49.8 290.41,49.8 285.25,44.65 285.25,38.85 279.68,33.27 270.08,33.27 269.36,34 267.14,34 266.53,34.61 246.34,34.61 244.47,36.48 242.19,36.48 238.16,40.51 237.9,40.51 237.9,40.51 231.14,40.51 230.42,41.22 230.42,44.91 219.48,55.85 213.07,55.85 203.36,65.57 202.71,65.57 201.6,66.68 201.6,68.61 201.85,68.86 203.84,68.86 v2(204.31,68.39) 204.84,67.86 JFAN1.3
TBT_FORCE_PWR: length 4.4
  TOP w0.089: T260.1 217.63,36.62 v2(217.63,36.97)
  BOTTOM w0.089: UH1.BE15 214.48,36.87 214.54,36.93 214.97,36.93 215.23,36.67 217.34,36.67 v2(217.63,36.97)
TBT_PWR_EN: length 4.9
  BOTTOM w0.089: 218.96,36.48 215.15,36.48 214.92,36.71 UH1.BF15
  BOTTOM w0.102: 218.96,36.48 219.32,36.48 T269.1
TBT_RESET_N_EC_R: length 6.7
  TOP w0.089: 318.18,28.35 318.18,28.63 318.99,29.44 318.99,30.54 319.02,30.56 319.02,32.04 UE1.L8
  TOP w0.102: v1(317.59,26.36) 317.59,27.7 RE95.2 318.18,28.35
TBT_RTD3_WAKE#: length 19.1
  TOP w0.107: v2(223.59,26.92) 223.39,26.92 v1(223.13,26.65) 223.1,26.62 RH125.1
  IN1 w0.099: v2(209.79,28.01) 209.84,28.05 209.84,28.56 210.02,28.74 210.87,28.74 212.27,27.34 212.27,27.1 213.58,25.79 214.68,25.79 215.65,26.76 220.9,26.76 221.69,25.96 222.27,25.96 223.22,26.92 v2(223.59,26.92)
  BOTTOM w0.089: UH1.AR32 209.27,28.53 v2(209.79,28.01)
TBTA_CC1: length 47.6
  IN1 w0.508: v2(14.6,112.83) 14.6,111.31 14.23,110.94 14.23,109.52 13.57,108.86 12.15,108.86 11.61,108.32 11.61,102.82 13.16,101.27 14.6,101.27 14.68,101.19 14.71,101.19 17.59,98.31 23.89,98.31 24.87,97.33 27.68,97.33 29.41,95.61 31.92,95.61 31.97,95.66 32.21,95.66 32.76,96.21 35.86,96.21 v2(35.95,96.3)
  BOTTOM w0.254: UT5.L9 34.38,91.71 34.59,91.92 34.59,92.14 36.09,93.64 36.09,93.73 36.39,94.03 RT104.2
  BOTTOM w0.457: 8.62,113.25 v2(9.44,113.25)
  BOTTOM w0.508: RT104.2 36.55,94.76 36.73,94.94 36.73,95.38 ; 36.73,95.38 36.58,95.38 36.13,95.82 36.13,95.83 36.08,95.89 36.08,96.17 v2(35.95,96.3) ; 36.73,95.38 CT86.1
  vias: v1(14.12,113.93)
TBTA_CC2: length 51.6
  TOP w0.381: 19.55,107.13 18.39,107.13 17.71,107.8 17.71,107.85 17.7,107.86 v1(17.7,108.84) 17.7,109.93 17.96,110.19 17.96,112.29 15.55,114.69 13.31,114.69 13.05,114.44 DT40.5 DT40.6 10.81,114.44 10.69,114.32 9.28,114.32 8.9,113.93 8.19,113.93 7.57,114.55 v2(6.93,114.55)
  TOP w0.508: v2(32.42,99.34) 31.42,99.34 30.91,99.85 30.59,99.85 29.07,101.37 29.07,101.75 28.03,102.79 27.36,102.79 26.49,103.66 24.49,103.66 22.68,105.47 22.68,105.48 22.18,105.98 22.17,105.98 22.01,106.14 20.53,106.14 19.55,107.13
  BOTTOM w0.254: UT5.L10 34.88,90.97 34.89,90.98 34.89,91.23 36.31,92.65 36.92,92.65 37.08,92.81 37.08,93.78 37.33,94.03 RT105.2
  BOTTOM w0.305: v2(6.93,114.55) 6.71,114.55 6.53,114.38 JUSBC1.B5
  BOTTOM w0.508: v2(32.42,99.34) 32.58,99.34 33.21,98.71 33.25,98.71 33.27,98.69 36.12,98.69 37.86,96.94 38.05,96.94 38.27,96.72 38.27,95.9 38.16,95.78 38.16,95.76 37.79,95.39 CT85.1 37.51,95.29 37.51,94.57 37.58,94.51 RT105.2
TBTA_DBG_CTL1: length 2.3
  TOP w0.102: v1(32,87.35) 31.87,87.22 v2(31.39,87.22) ; 31.07,86.89 RT106.1
  TOP w0.104: v2(31.39,87.22) 31.07,86.89
  BOTTOM w0.076: v2(31.39,87.22) 31.5,87.22 31.88,87.6 UT5.E4
TBTA_DBG_CTL2: length 2.2
  TOP w0.102: RT107.1 31.03,86.38 31.38,86.73 v2(31.83,86.73)
  BOTTOM w0.076: v2(31.83,86.73) 32.28,87.19 UT5.D5
TBTA_DEBUG1: length 4.1
  BOTTOM w0.076: UT5.L2 30.81,90.77 30.81,91.49 30.53,91.76 29.94,91.76 29.77,91.93 29.77,92.31 29.11,92.96 RT92.2
TBTA_DEBUG2: length 4.9
  BOTTOM w0.076: RT93.2 28.22,93.4 v1(29.15,92.47) 29.6,92.02 29.6,91.87 29.87,91.6 30.46,91.6 30.64,91.42 30.64,90.43 UT5.K2
TBTA_DEBUG3: length 7.9
  BOTTOM w0.076: UT5.L3 31.38,90.88 31.11,91.16 31.11,91.62 v4(30.43,92.29) 29.8,92.93 29.8,94
  BOTTOM w0.089: RT89.2 27.82,97.1 28.43,96.49 28.43,96.25 28.95,95.73 28.99,95.73 29.8,94.93 29.8,94
