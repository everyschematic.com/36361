# Allegro board LA-F711P R05-0112.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CNV_PTX_DRX_N0: length 97.3
  IN1 w0.089: 219.04,41.64 219.02,41.65 219.02,41.83
  IN1 w0.099: v2(292.56,22.97) 292.36,22.77 292.18,22.77 291.99,22.95 291.52,22.95 290.95,22.38 289.45,22.38 289.3,22.23 281.64,22.23 281.22,22.65 280.17,22.65 280.07,22.75 280.07,22.87 279.85,23.1 279.37,23.1 279.15,22.87 279.15,22.75 279.05,22.65 278.76,22.65 278.66,22.75 278.66,22.87 278.43,23.1 277.96,23.1 277.74,22.87 277.74,22.75 277.64,22.65 277.34,22.65 277.24,22.75 277.24,22.87 277.02,23.1 276.55,23.1 276.33,22.87 276.33,22.75 276.23,22.65 275.93,22.65 275.83,22.75 275.83,22.87 275.61,23.1 275.14,23.1 274.91,22.87 274.91,22.75 274.82,22.65 274.52,22.65 274.42,22.75 274.42,22.87 274.2,23.1 273.72,23.1 273.5,22.87 273.5,22.75 273.4,22.65 273.11,22.65 273.01,22.75 273.01,22.87 272.78,23.1 271.28,23.1 271.16,23.22 269.66,23.22 267.38,25.5 264.04,25.5 263.71,25.17 261.14,25.17 261.02,25.05 260.45,25.05 260.35,25.15 260.35,25.28 260.13,25.5 259.65,25.5 259.43,25.28 259.43,25.15 259.33,25.05 257.77,25.05 257.67,25.15 257.67,25.28 257.45,25.5 256.98,25.5 256.76,25.28 256.76,25.15 256.66,25.05 242.53,25.05 241.12,26.45 240.72,26.45 240.51,26.66 238.26,26.66 236.72,28.19 234.05,28.19 228.38,33.87 228.38,35.26 223,40.64 221.75,40.64 220.85,41.54 219.14,41.54 219.04,41.64 ; v2(216.78,41.7) 216.94,41.54 217.9,41.54 218.1,41.73 218.1,42.9 218.32,43.12 218.8,43.12 219.02,42.9 219.02,41.83
  BOTTOM w0.089: UH1.BE6 214.44,40.77 214.53,40.68 214.77,40.68 214.8,40.71 215.87,40.71 216.78,41.62 v2(216.78,41.7)
  BOTTOM w0.097: JNGFF1.65 293.95,22.61 293.79,22.45 293.51,22.45 293.19,22.77 292.76,22.77 v2(292.56,22.97)
CNV_PTX_DRX_N1: length 97.8
  IN1 w0.099: v2(217.98,44.1) 218.33,44.1 218.53,44.3 218.85,44.3 219.44,43.71 219.58,43.71 219.88,44.01 220.26,44.01 220.56,43.71 220.56,43.39 220.05,42.88 220.05,42.72 220.25,42.52 220.4,42.52 221.51,43.63 221.82,43.63 222.16,43.29 222.16,42.95 221.45,42.24 221.45,42.1 221.69,41.86 221.83,41.86 222.53,42.56 222.85,42.56 223.16,42.25 223.16,41.94 223.08,41.86 223.08,41.72 229.56,35.24 229.56,33.89 234.44,29.01 237.06,29.01 238.6,27.48 241.55,27.48 243.15,25.87 255.79,25.87 256.24,26.32 260.79,26.32 261.12,25.98 263.37,25.98 263.7,26.32 267.72,26.32 270,24.04 271.52,24.04 271.64,23.92 280.73,23.92 281.17,23.47 281.87,23.47 282.28,23.06 288.98,23.06 289.39,23.47 290.88,23.47 291.36,23.95 292.53,23.95 292.67,23.96 v2(292.89,24.2)
  BOTTOM w0.089: UH1.BG6 215.24,41.18 215.15,41.27 215.15,41.35 215.26,41.47 215.67,41.47 215.72,41.52 215.72,41.73 216.74,42.76 217.28,42.76 218.09,43.57 218.09,43.98 v2(217.98,44.1)
  BOTTOM w0.097: v2(292.89,24.2) 293.15,23.95 293.69,23.95 293.85,24.11 JNGFF1.59
CNV_PTX_DRX_P0: length 97.5
  IN1 w0.089: 218.81,41.83 218.81,41.6 218.85,41.56
  IN1 w0.099: 218.85,41.56 219.06,41.35 220.03,41.35 220.05,41.33 220.77,41.33 221.67,40.43 222.91,40.43 228.16,35.18 228.16,33.78 233.97,27.98 236.64,27.98 238.17,26.45 240.42,26.45 240.63,26.24 241.04,26.24 242.44,24.84 256.75,24.84 256.97,25.06 256.97,25.19 257.07,25.29 257.36,25.29 257.46,25.19 257.46,25.06 257.69,24.84 259.42,24.84 259.64,25.06 259.64,25.19 259.74,25.29 260.04,25.29 260.14,25.19 260.14,25.06 260.36,24.84 261.11,24.84 261.22,24.96 263.8,24.96 264.13,25.29 267.29,25.29 269.57,23.01 271.08,23.01 271.2,22.89 272.7,22.89 272.8,22.79 272.8,22.66 273.02,22.44 273.49,22.44 273.71,22.66 273.71,22.79 273.81,22.89 274.11,22.89 274.21,22.79 274.21,22.66 274.43,22.44 274.9,22.44 275.13,22.66 275.13,22.79 275.22,22.89 275.52,22.89 275.62,22.79 275.62,22.66 275.84,22.44 276.32,22.44 276.54,22.66 276.54,22.79 276.64,22.89 276.93,22.89 277.03,22.79 277.03,22.66 277.26,22.44 277.73,22.44 277.95,22.66 277.95,22.79 278.05,22.89 278.35,22.89 278.45,22.79 278.45,22.66 278.67,22.44 279.14,22.44 279.36,22.66 279.36,22.79 279.46,22.89 279.76,22.89 279.86,22.79 279.86,22.66 280.08,22.44 281.13,22.44 281.55,22.02 289.39,22.02 289.54,22.17 291.03,22.17 291.61,22.74 291.91,22.74 292.09,22.56 292.38,22.56 v2(292.56,22.38) ; v2(216.78,41.11) 217,41.33 217.99,41.33 218.31,41.64 218.31,42.81 218.41,42.91 218.71,42.91 218.81,42.81 218.81,41.83
  BOTTOM w0.089: v2(216.78,41.11) 216.52,41.11 215.94,40.53 215.87,40.53 215.85,40.52 214.9,40.52 214.88,40.5 214.15,40.5 UH1.BD7
  BOTTOM w0.097: v2(292.56,22.38) 292.76,22.58 293.11,22.58 293.43,22.26 293.87,22.26 294.03,22.11 JNGFF1.67
CNV_PTX_DRX_P1: length 97.7
  IN1 w0.099: v2(292.93,23.53) 292.69,23.75 292.54,23.74 291.45,23.74 290.97,23.26 289.47,23.26 289.07,22.85 282.19,22.85 281.78,23.26 281.09,23.26 280.64,23.7 271.55,23.7 271.43,23.82 269.91,23.82 267.63,26.11 263.79,26.11 263.46,25.77 261.03,25.77 260.7,26.11 256.33,26.11 255.88,25.66 243.07,25.66 241.46,27.26 238.51,27.26 236.98,28.8 234.35,28.8 229.35,33.8 229.35,35.15 222.87,41.63 222.87,41.94 222.95,42.02 222.95,42.16 222.76,42.35 222.62,42.35 221.92,41.65 221.6,41.65 221.24,42.01 221.24,42.33 221.95,43.04 221.95,43.21 221.74,43.42 221.6,43.42 220.48,42.3 220.16,42.3 219.84,42.63 219.84,42.97 220.35,43.48 220.35,43.62 220.17,43.8 219.97,43.8 219.67,43.5 219.35,43.5 218.76,44.09 218.62,44.09 218.45,43.92 218.45,43.88 v2(218.45,43.59)
  BOTTOM w0.089: UH1.BF6 214.96,41.18 215.22,40.92 215.49,40.92 215.7,41.14 215.7,41.26 215.9,41.45 215.9,41.66 216.82,42.58 217.35,42.58 218.36,43.59 v2(218.45,43.59)
  BOTTOM w0.097: JNGFF1.61 293.86,23.61 293.71,23.76 293.16,23.76 v2(292.93,23.53)
CNV_RF_RST: length 44.6
  IN2 w0.102: v2(321.93,29.44) 321.74,29.63 321.74,36.98 321.59,37.13 313.02,37.13 311.62,38.53 308.09,38.53 v2(306.24,36.69)
  BOTTOM w0.102: v2(306.24,36.69) 307.16,37.6 307.16,41.46 306.1,42.52 304.52,42.52 304.03,43.01 301.16,43.01 298.9,45.27 296.4,45.27 295.92,44.8 QZ17.6 ; RZ377.2 294.97,43.05 v1(294.99,43.03) ; RE100.1 321.86,29.5 v2(321.93,29.44)
CNV_RF_RST#: length 115.3
  TOP w0.089: v2(218.98,35.75) 219.02,35.75 RH617.2
  IN2 w0.102: v2(305.74,34.76) 305.35,35.14 302.68,35.14 301.95,34.42 300.13,34.42 298.77,33.06 296.14,33.06 295.16,32.08 282.81,32.08 281.99,31.26 269.59,31.26 267.52,33.34 251.65,33.34 251.25,33.74 243.51,33.74 241.31,35.94 237.1,35.94 236.41,35.25 235.05,35.25 234.11,36.19 229.09,36.19 228.58,35.69 224.7,35.69 224.57,35.81 224.21,35.81 223.41,35.01 219.54,35.01 218.98,35.57 v2(218.98,35.75)
  BOTTOM w0.089: UH1.BE16 214.41,36.35 214.52,36.24 214.86,36.24 215.01,36.08 218.65,36.08 v2(218.98,35.75)
  BOTTOM w0.102: QZ17.2 297.86,43.82 298.5,43.82 RZ3.1 299.61,43.69 v1(300.12,43.18) 300.52,42.79 303.93,42.79 304.43,42.29 306,42.29 306.82,41.48 306.82,37.87 305.74,36.79 v2(305.74,34.76)
CNV_RF_RST#_R: length 11.6
  BOTTOM w0.102: JNGFF1.10 301.47,36.36 301.1,36.73 301.1,40.64 v1(300.61,41.13) RZ3.2 297.93,43.1 QZ17.3 297.18,43.21 296.44,42.47 RZ378.2
CNV_RGI_PRX_DTX: length 119.6
  TOP w0.102: v2(214.65,47.53) 214.65,46.8 RH613.2
  IN3 w0.102: v2(307.58,28.42) 307.58,27.82 306.59,26.83 304.09,26.83 302.05,28.87 302.05,29.8 298.12,33.73 285.45,33.73 282.34,30.62 273.24,30.62 271.54,28.92 268.83,28.92 268.06,28.15 261.03,28.15 260.77,27.89 252.05,27.89 250.81,29.13 242.38,29.13 241.54,29.97 239.89,29.97 239.21,30.65 237.6,30.65 235.49,32.75 235.49,32.83 228.13,40.19 226.8,40.19 223.11,43.89 219.08,43.89 217.99,44.98 216.65,44.98 214.65,46.98 v2(214.65,47.53)
  BOTTOM w0.089: UH1.AV3 210.79,42.45 210.79,43.14 210.82,43.17 210.82,44.41 213.58,47.17 214.28,47.17 v2(214.65,47.53)
  BOTTOM w0.102: RZ1383.1 306.66,30.31 307.58,29.4 v2(307.58,28.42)
CNV_RGI_PRX_DTX_R: length 3.8
  BOTTOM w0.102: v1(304.74,29.3) 304.96,29.52 RZ1383.2 304.92,30.36 JNGFF1.34
CNV_RGI_PTX_DRX: length 14.9
  TOP w0.089: v2(218.19,47.25) 218.19,47.31
  TOP w0.102: v2(218.19,47.25) 218.67,46.78 RH606.1 217.82,46.52 RH605.1 ; 218.19,47.31 218.19,47.8 218.42,48.03 RZ1382.1 219.76,48.87 v1(219.76,49.11)
  BOTTOM w0.089: UH1.BA4 212.55,42.29 212.15,42.68 212.15,43.73 212.15,43.73 212.15,44.84 212.18,44.86 213.27,45.95 214.13,45.95 214.68,46.5 217.46,46.5 217.78,46.83 217.78,47.07 217.96,47.25 v2(218.19,47.25)
CNV_RGI_PTX_DRX_R: length 108.5
  TOP w0.102: v2(223.25,45.28) v1(223.25,46.06) 223.25,46.57 221.53,48.28 220.09,48.28 RZ1382.2
  IN3 w0.102: v2(306.54,31.2) 306.54,30.58 305.96,30 305.96,27.81 305.67,27.52 304.37,27.52 302.74,29.15 302.74,30.08 299.78,33.04 298.41,34.41 285.16,34.41 283.34,32.59 281.79,32.59 280.65,31.44 273.1,31.44 271.26,29.61 268.54,29.61 268.3,29.36 251.87,29.36 251.41,29.82 244.9,29.82 243.83,30.88 239.94,30.88 239.49,31.33 237.88,31.33 236.24,32.97 236.24,33.05 228.41,40.88 228.17,40.88 223.84,45.2 223.33,45.2 v2(223.25,45.28)
  BOTTOM w0.102: JNGFF1.32 304.62,30.86 304.96,31.2 v2(306.54,31.2)
CNV_WT_RCOMP: length 10.1
  BOTTOM w0.089: 212.9,45.27 212.8,45.17 212.75,45.17 212.34,44.76 212.34,43.89 212.4,43.84 UH1.BA1
  BOTTOM w0.152: 212.9,45.27 213.36,45.73 214.22,45.73 214.76,46.26 217.7,46.26 218.3,46.86 219.06,46.86 v1(219.27,47.08) 219.27,47.97 RH612.2
COMP_1PH: length 7.5
  TOP w0.102: PC1710.2 66.98,84.73 v1(66.98,85.09)
  TOP w0.203: PU1700.50 61.29,83.99 61.34,84.04 62.7,84.04 63.14,84.48 65.14,84.48 PC1709.2 65.5,84.12 PC1710.2
COMP_2PH: length 6.6
  TOP w0.203: PC1721.2 56.89,73.08 PC1717.2 56.7,74.12 v1(56.7,75.04) 56.89,75.23 56.89,77.33 57.33,77.77 PU1700.33
COMP_4PH: length 3.8
  TOP w0.203: PR1737.1 57.73,89.19 PC1714.1 v2(57.73,87.6) PU1700.6
COMP_ISL88738: length 4
  TOP w0.203: v2(6.42,34.58) 6.42,34.37 v1(6.66,34.13) 6.77,34.02 6.96,34.02 6.97,34.01 PU901.28
  BOTTOM w0.254: PR934.1 6.54,35.16 6.95,35.16 7.16,34.95 PC943.1 6.56,34.44 v2(6.42,34.58)
CONTACTLESS_DET#: length 114.5
  IN2 w0.102: v2(276.09,16.7) 276.17,16.7 276.59,17.12 277.11,17.12 277.36,16.87 281.88,16.87 282.81,17.8 296.45,17.8 299.37,14.87 302.84,14.87 v2(302.86,14.85)
  BOTTOM w0.089: UH1.BG8 215.55,40.23 216.06,40.23 216.47,40.64 216.82,40.64 217.02,40.84 217.14,40.96 217.14,41.13 220.4,44.39
  BOTTOM w0.102: v2(276.09,16.7) 276.53,17.13 276.53,24.05 272.64,27.94 270.23,30.35 268.19,30.35 266.42,32.12 263.23,32.12 262.54,32.8 v1(261.36,32.8) 251.93,32.8 251.59,33.14 246.13,33.14 243.98,35.28 241.69,35.28 237.66,39.31 230.64,39.31 228.01,41.95 228.01,44.71 225.39,47.33 224.76,47.33 RH90.2 222.63,46.62 220.4,44.39 ; v2(302.86,14.85) 301.12,13.11 DZ8.2
CONTACTLESS_DET#_R: length 7.7
  BOTTOM w0.102: JUSH1.23 301.33,8.57 301.05,8.85 300.11,8.85 298.91,10.04 298.91,10.38 299.15,10.62 299.15,12.52 DZ8.1 299.42,13.64 v1(299.78,13.99)
CORE_SW1:
  vias: v1(74.6,93.56) v2(73.88,93.54)
CORE_SW2: length 2.2
  TOP w0.102: PC1825.1 v1(84.68,94.06)
  TOP w0.508: PC1825.1 83.61,94.69 v2(83.24,95.06)
CORE_SW3: length 0.8
  TOP w0.508: PC1909.1 v2(91.33,95.94)
  vias: v1(92.22,96.68)
CORE_SW4: length 0.7
  TOP w0.508: PC1919.1 v2(96.44,92.91)
  vias: v1(102.26,96.42)
CPU_2_PCH_TRIGGER: length 115.2
  TOP w0.102: v2(115.31,68.95) 115.46,68.8 115.46,68.53 115.22,68.29 RC177.1
  IN1 w0.099: v2(173.43,65.51) 170.54,65.51 170.53,65.52 163.11,65.52 159.04,69.6 151.81,69.6 148.26,66.04 120.75,66.04 120.52,66.27 119.66,66.27 118.97,66.95 118.97,67.84 118.52,68.29 118.52,68.3 117.51,69.3 115.66,69.3 v2(115.31,68.95)
  BOTTOM w0.089: 208.16,50.17 208.16,49.48 208.12,49.43 208.12,48.42 207.93,48.23 207.93,46.89 207.02,45.98 207.02,44.34 206.86,44.17 206.86,42.93 UH1.AK2
  BOTTOM w0.102: v2(173.43,65.51) 173.66,65.51 173.84,65.7 188.38,65.7 v1(191.6,62.47) 195.03,59.04 202.29,59.04 208.16,53.17 208.16,50.17
CPU_2_PCH_TRIGGER_R: length 2.2
  TOP w0.102: v1(116.91,68.29) RC177.2 115.93,68.79 v2(116.06,68.91)
  BOTTOM w0.102: UC1.J23 115.73,69.23 v2(116.06,68.91)
CPU_24MHZ_R_D: length 99.6
  IN1 w0.076: 119.79,73.52 119.79,73.54 119.82,73.57 119.82,73.83 119.5,74.15 118.85,74.15 118.27,74.73 118.27,74.96 v2(118.07,75.17)
  IN1 w0.099: v2(183.14,48.96) 182.96,49.15 179.44,49.15 174.71,53.88 174.71,66.34 173.39,67.66 163.55,67.66 159.79,71.42 150.09,71.42 148.5,69.83 139.57,69.83 138.42,68.68 127.7,68.68 127.09,68.07 121.23,68.07 120.67,68.63 120.67,68.85 119.38,70.14 119.38,71.04 119.79,71.45 119.79,73.52
  BOTTOM w0.094: v2(118.07,75.17) 118.07,75.17 118.07,75.2 118.38,75.51 UC1.E31
  BOTTOM w0.097: RH169.1 187.5,42.15 186.8,42.15 183.81,45.14 183.81,48.96 183.64,49.13 183.32,49.13 v2(183.14,48.96)
CPU_24MHZ_R_D#: length 99.4
  IN1 w0.076: v2(118.7,75.16) 118.44,74.89 118.44,74.8 118.92,74.32 119.56,74.32 119.98,73.9 119.98,73.57 120,73.54 120,73.52
  IN1 w0.099: 120,73.52 120,71.37 119.59,70.95 119.59,70.23 120.88,68.94 120.88,68.72 121.32,68.28 127,68.28 127.61,68.89 138.33,68.89 139.48,70.04 148.41,70.04 150,71.63 159.88,71.63 163.64,67.87 173.48,67.87 174.92,66.43 174.92,53.96 179.52,49.36 182.96,49.36 v2(183.14,49.54)
  BOTTOM w0.094: v2(118.7,75.16) 119.03,75.49 UC1.D31
  BOTTOM w0.097: RH170.1 187.46,42.33 186.88,42.33 183.99,45.22 183.99,49.04 183.71,49.32 183.37,49.32 v2(183.14,49.54)
CPU_B+: length 0.9
  TOP w0.254: PR1753.1 50.43,85.24 v2(50.28,85.09)
  vias: v2(36.56,66.08) v2(36.57,65.46) v2(36.57,64.82) v2(36.57,64.19) v2(36.57,63.55) v2(36.57,62.92) v2(37.13,66.13) v2(37.14,65.51) v2(37.14,64.87) v2(37.14,64.24) v2(37.14,63.6) v2(37.14,62.97) v2(37.77,66.13) v2(37.78,65.51) v2(37.78,64.87) v2(37.78,64.24) v2(37.78,63.6) v2(37.78,62.97) v2(38.4,66.13) v2(38.41,65.51) v2(38.41,64.87) v2(38.41,64.24) v2(38.41,63.6) v2(38.41,62.97) v2(39.04,66.13) v2(39.05,65.51) v2(39.05,64.87) v2(39.05,64.24) v2(39.05,63.6) v2(39.05,62.97) v2(63.36,95.19) v2(63.7,95.71) v2(64,95.12) v2(64.35,96.23) v2(64.35,95.64) v2(64.64,95.12) v2(65.05,96.21) v2(65.05,95.63) v2(71.45,99.59) v2(71.45,98.93) v2(72.32,101.04) v2(72.5,99.58) v2(72.51,98.93) v2(72.89,101.03) v2(80.93,99.77) v2(80.95,99.12) v2(81.66,101.4) v2(81.96,100.84) v2(81.97,99.72) v2(81.97,99.11) v2(82.29,101.4) v2(82.58,100.85) v2(85.9,101.41) v2(87.02,100.98) v2(87,99.81) v2(87.37,101.8) v2(87.64,100.96) v2(87.64,99.8) v2(95.13,102.86) v2(95.16,102.2) v2(95.16,101.61) v2(95.46,101.09) v2(95.73,102.83) v2(95.74,102.21) v2(95.74,101.6) v2(96.62,101.09) v2(96.64,99.92) v2(97.25,101.09) v2(97.29,99.9) v2(104.62,100.82) v2(105.26,100.82) v2(105.89,100.82) v2(106.53,100.82) v3(72.44,100.35)
CPU_C10_GATE#: length 129.3
  TOP w0.089: 211.54,50.17 211.54,47.74 RH616.1
  TOP w0.102: v2(155.24,82.38) 155.24,62.7 153.34,60.79 153.34,59.33 152.64,58.64 150.59,58.64 PR2009.1 ; v2(175.85,74.42) 175.85,72.43 185.63,62.65 189.24,62.65 v1(190.87,61.02) 192.49,59.39 206.27,59.39 211.54,54.13 211.54,50.17
  BOTTOM w0.102: v2(175.85,74.42) 172.84,74.42 169.28,77.98 159.64,77.98 v2(155.24,82.38) 150.58,87.05 144.81,87.05 144.05,87.81 140.63,87.81 139.07,86.25 139.07,82.3 139.54,81.83 RZ543.1 140.89,82.59 UZ61.2
CPU_DP1_N0: length 80.1
  TOP w0.097: v2(103.52,116.35) 103.27,116.6 103.27,117.35 101.82,118.8 101.82,119.78 CV32.1
  IN1 w0.099: v2(103.52,116.35) 103.33,116.16 103.33,115.56 104.41,114.48 104.75,114.48 105.53,115.26 105.91,115.26 106.18,114.99 106.18,114.61 105.17,113.61 105.17,112.72 105.41,112.48 106.09,112.48 106.41,112.8 106.41,112.93 106.69,113.21 107.55,113.21 107.82,112.93 107.82,112.09 108.18,111.73 112.71,111.73 113.29,111.16 124.07,111.16 126.16,109.07 126.16,107.18 130.6,102.74 130.6,100.6 131.49,99.71 131.49,90.96 127,86.46 124.25,86.46 122.7,84.92 122.7,84.66 v2(122.89,84.48)
  BOTTOM w0.076: 114.94,81 114.94,80.98 114.93,80.97 114.93,79.04 115.06,78.91 115.15,78.91 115.23,78.99 UC1.K37
  BOTTOM w0.097: 114.94,81 114.94,81.87 116.91,83.84 122.25,83.84 v2(122.89,84.48)
CPU_DP1_N1: length 80.1
  TOP w0.097: CV34.1 105.36,119.74 105.36,118.79 104.9,118.33 104.9,116.81 v2(105.26,116.45)
  IN1 w0.099: v2(105.26,116.45) 105.26,116.39 105.1,116.23 104.88,116.23 104.78,116.33 104.78,117.32 104.93,117.47 105.47,117.47 106.09,116.85 106.09,115.98 107.18,114.89 108.72,114.89 110.71,112.89 111.11,112.89 111.28,112.72 111.28,112.47 111.56,112.2 112.19,112.2 112.47,112.47 112.47,112.84 112.69,113.06 113.32,113.06 114.73,111.66 125.19,111.66 126.58,110.27 126.58,107.45 131.03,103 131.03,100.83 131.92,99.94 131.92,90.76 127.14,85.99 125.54,85.99 123.95,84.4 123.95,84.12 122.62,82.79 122.52,82.79 122.2,83.11 v2(122.2,83.41)
  BOTTOM w0.076: 115.75,81 115.75,80.98 115.76,80.97 115.76,80.15 115.55,79.95 115.55,77.51 115.74,77.33 115.89,77.33 UC1.J34
  BOTTOM w0.097: 115.75,81 115.75,82.08 117.09,83.42 121.2,83.42 121.56,83.06 121.84,83.06 v2(122.2,83.41)
CPU_DP1_N2: length 80.3
  TOP w0.097: v2(109.86,116.47) 109.54,116.8 109.54,117.56 112.23,120.25 112.23,120.92 CV36.1
  IN1 w0.099: v2(121.87,80.82) 122.14,80.82 122.49,81.17 122.49,81.72 124.73,83.96 126.02,83.96 132.56,90.49 132.56,102.39 132.36,102.6 132.1,102.6 131.83,102.87 131.83,103.87 132.1,104.15 132.41,104.15 132.56,104.3 132.56,104.88 132.32,105.12 129.83,105.12 127.85,107.1 127.85,110.4 125.95,112.29 115.37,112.29 113.42,114.25 110.57,114.25 110.23,114.58 110.23,115.01 110.64,115.41 111.46,115.41 111.65,115.59 111.65,116.04 110.73,116.96 109.42,116.96 109.35,116.89 109.35,116.73 109.61,116.47 v2(109.86,116.47)
  BOTTOM w0.076: 117.49,81.69 117.49,81.58 117.04,81.12 117.04,80.04 117.01,80.01 117.01,79.68 117.24,79.45 117.24,79.19 116.81,78.75 UC1.H36
  BOTTOM w0.097: v2(121.87,80.82) 122.09,80.82 122.2,80.92 122.2,81.17 122.1,81.26 120.87,81.26 120.14,81.99 117.73,81.99 117.49,81.76 117.49,81.69
CPU_DP1_N3: length 79.9
  TOP w0.097: CV38.2 108.92,119.74 108.92,118.99 107.4,117.48 107.4,116.82 v2(107.74,116.48)
  IN1 w0.099: v2(124.37,82.38) 124.38,82.36 124.38,82.3 124.76,81.92 124.9,81.92 133.19,90.22 133.19,106.09 134.15,107.04 134.15,109.5 131.62,112.03 127.29,112.03 126.4,112.92 116.03,112.92 111.36,117.59 108.1,117.59 107.29,116.78 107.29,116.36 107.42,116.23 107.61,116.23 107.74,116.36 v2(107.74,116.48)
  BOTTOM w0.076: 116.36,81.66 116.36,81.65 116.37,81.64 116.37,80.88 116.49,80.75 116.49,80.52 116.42,80.45 116.26,80.45 116.18,80.36 116.18,80.23 116.26,80.14 116.42,80.14 116.49,80.07 116.49,79.86 116.41,79.78 116.3,79.78 UC1.J38
  BOTTOM w0.097: 116.36,81.66 116.36,81.76 117.4,82.81 120.55,82.81 121.33,82.04 123.13,82.04 123.29,82.2 124.19,82.2 v2(124.37,82.38)
CPU_DP1_P0: length 80.1
  TOP w0.097: v2(102.94,116.35) 103.09,116.5 103.09,117.27 101.63,118.73 101.63,119.8 CV31.1
  IN1 w0.099: v2(122.3,84.48) 122.49,84.67 122.49,85.01 124.16,86.67 126.91,86.67 131.28,91.04 131.28,99.63 130.39,100.51 130.39,102.65 125.95,107.09 125.95,108.98 123.98,110.95 113.2,110.95 112.63,111.52 108.09,111.52 107.61,112 107.61,112.85 107.46,113 106.77,113 106.62,112.85 106.62,112.71 106.17,112.27 105.32,112.27 104.96,112.63 104.96,113.7 105.97,114.7 105.97,114.91 105.82,115.05 105.62,115.05 104.84,114.27 104.32,114.27 103.12,115.47 103.12,116.16 v2(102.94,116.35)
  BOTTOM w0.076: UC1.K36 115.23,78.51 114.77,78.97 114.77,80.97 114.76,80.98 114.76,81
  BOTTOM w0.097: 114.76,81 114.76,81.95 116.84,84.03 122.15,84.03 122.3,84.18 v2(122.3,84.48)
CPU_DP1_P1: length 80.1
  TOP w0.097: CV33.1 105.17,119.74 105.17,118.87 104.71,118.41 104.71,116.76 v2(104.37,116.42)
  IN1 w0.099: v2(122.14,82.57) 122.7,82.57 124.16,84.03 124.16,84.31 125.62,85.78 127.22,85.78 132.13,90.68 132.13,100.02 131.24,100.91 131.24,103.09 126.79,107.54 126.79,110.36 125.28,111.87 114.81,111.87 113.41,113.27 112.6,113.27 112.26,112.93 112.26,112.56 112.11,112.41 111.64,112.41 111.49,112.56 111.49,112.81 111.2,113.11 110.8,113.11 108.81,115.1 107.27,115.1 106.3,116.07 106.3,116.94 105.56,117.69 104.84,117.69 104.57,117.41 104.57,116.62 v2(104.37,116.42)
  BOTTOM w0.076: UC1.J35 116.15,77.85 116.25,77.75 116.25,77.6 116.15,77.49 115.81,77.49 115.72,77.58 115.72,79.88 115.92,80.09 115.92,80.97 115.93,80.98 115.93,81
  BOTTOM w0.097: 115.93,81 115.93,82 117.17,83.24 121.12,83.24 121.48,82.87 121.85,82.87 v2(122.14,82.57)
CPU_DP1_P2: length 80.3
  TOP w0.097: v2(109.02,116.47) 109.35,116.8 109.35,117.63 112.04,120.33 112.04,120.92 CV35.1
  IN1 w0.099: v2(122.7,80.8) 122.7,81.64 124.81,83.75 126.11,83.75 132.77,90.41 132.77,102.48 132.44,102.81 132.19,102.81 132.04,102.96 132.04,103.78 132.19,103.94 132.5,103.94 132.77,104.21 132.77,104.97 132.41,105.33 129.92,105.33 128.06,107.19 128.06,110.48 126.04,112.5 115.46,112.5 113.51,114.46 110.65,114.46 110.45,114.67 110.45,114.92 110.72,115.2 111.55,115.2 111.86,115.5 111.86,116.13 110.82,117.17 109.33,117.17 109.14,116.98 109.14,116.59 v2(109.02,116.47)
  BOTTOM w0.076: 117.31,81.69 117.31,81.63 116.87,81.19 116.87,80.11 116.84,80.08 116.84,79.61 117.08,79.38 117.08,79.26 116.97,79.15 UC1.H37
  BOTTOM w0.097: v2(122.7,80.8) 122.48,80.8 122.38,80.9 122.38,81.25 122.18,81.45 120.95,81.45 120.22,82.18 117.65,82.18 117.31,81.83 117.31,81.69
CPU_DP1_P3: length 80
  TOP w0.097: CV37.2 108.73,119.74 108.73,119.07 107.22,117.56 107.22,116.82 v2(106.88,116.48)
  IN1 w0.099: v2(124.36,81.71) 124.99,81.71 133.4,90.13 133.4,106 134.36,106.96 134.36,109.59 131.71,112.24 127.38,112.24 126.49,113.13 116.12,113.13 111.44,117.8 108.01,117.8 107.07,116.87 107.07,116.68 v2(106.88,116.48)
  BOTTOM w0.076: 116.54,81.66 116.54,81.65 116.53,81.64 116.53,80.95 116.66,80.82 116.66,79.79 UC1.J37
  BOTTOM w0.097: 116.54,81.66 116.54,81.69 117.48,82.63 120.48,82.63 121.25,81.85 123.21,81.85 123.37,82.01 124.06,82.01 v2(124.36,81.71)
CPU_DP2_AUXN: length 168
  IN1 w0.099: v2(23.15,102.23) 23.15,103.13 23.92,103.9 28.41,103.9 28.94,104.43 60.52,104.43 61.46,105.37 72.67,105.37 77.28,109.98 92.35,109.98 94.38,112.01 100.01,112.01 104.91,107.12 121.25,107.12 123.11,105.25 123.11,104.82 124.21,103.72 124.62,103.72 126.87,101.47 126.87,92.35 124.87,90.35 122.65,90.35 120.65,88.34 119.76,88.34 117.22,85.8 117.22,84.23 116.02,83.04 116.02,80.39 115.24,79.61 115.24,78.06 115.74,77.56 115.74,75.54 115.35,75.15 115.35,74.31 116.8,72.86 118.38,72.86 118.59,72.65 118.59,72.16 v2(118.72,72.03)
  BOTTOM w0.094: UC1.E26 118.72,72 v2(118.72,72.03)
  BOTTOM w0.097: CT116.1 23.35,103.89 23.35,103.15 23.48,103.02 23.48,102.56 v2(23.15,102.23) 23.48,101.9 23.48,99.37 24.88,97.97 24.88,96.04 25.29,95.63 25.29,92.67 26.81,91.15 CT81.1
CPU_DP2_AUXN_C: length 4.8
  BOTTOM w0.076: UT5.J2 30.64,89.45 30.14,89.45 29.36,90.23 29.36,90.74 29.07,91.03 29.07,91.04 29.06,91.04 29.05,91.04
  BOTTOM w0.104: RT95.1 28.17,90.44 CT81.2 28.36,91.34 28.59,91.34 28.88,91.04 29.05,91.04
CPU_DP2_AUXN_C_MUX: length 3.7
  BOTTOM w0.097: CT116.2 22.98,105.19 RT131.1 23.29,106.34 23.29,106.51 23.21,106.58 22.7,106.58 22.47,106.82 22.47,107.59 22.4,107.65 UT9.32
CPU_DP2_AUXP: length 167.9
  IN1 w0.099: v2(118.07,72.03) 118.1,72.03 118.38,72.31 118.38,72.56 118.29,72.65 116.71,72.65 115.14,74.22 115.14,75.24 115.53,75.63 115.53,77.47 115.03,77.98 115.03,79.69 115.81,80.48 115.81,83.13 117.01,84.32 117.01,85.88 119.67,88.55 120.56,88.55 122.57,90.56 124.78,90.56 126.66,92.44 126.66,101.38 124.53,103.51 124.12,103.51 122.9,104.73 122.9,105.17 121.16,106.91 104.82,106.91 99.93,111.8 94.47,111.8 92.44,109.77 77.37,109.77 72.76,105.16 61.55,105.16 60.61,104.21 29.02,104.21 28.5,103.69 24.01,103.69 23.36,103.05 23.36,102.59 23.73,102.22 v2(24.12,102.22)
  BOTTOM w0.094: UC1.F26 117.73,71.69 v2(118.07,72.03)
  BOTTOM w0.097: CT115.1 23.54,103.94 23.54,103.23 23.67,103.09 23.67,102.67 v2(24.12,102.22) 23.67,101.76 23.67,99.45 25.07,98.05 25.07,96.11 25.47,95.71 25.47,92.75 26.88,91.34 27.14,91.34 CT80.1
CPU_DP2_AUXP_C: length 4.2
  BOTTOM w0.076: UT5.J1 30.31,89.61 30.21,89.61 29.52,90.3 29.52,90.81 29.23,91.1 29.23,91.12 29.06,91.29 29.05,91.29
  BOTTOM w0.089: CT80.2 28.17,92.5 RT96.1
  BOTTOM w0.104: CT80.2 28.37,91.58 28.69,91.58 28.99,91.29 29.05,91.29
CPU_DP2_AUXP_C_MUX: length 3.8
  BOTTOM w0.097: UT9.31 22.75,107.63 22.65,107.53 22.65,106.9 22.78,106.77 23.29,106.77 23.47,106.58 23.47,106.43 23.85,106.06 RT130.1 23.85,105.19 CT115.2
CPU_DP2_N0: length 151.3
  IN1 w0.099: v2(117.16,76.87) 116.77,77.26 116.77,77.52 116,78.29 116,79.08 116.76,79.84 116.76,82.66 117.86,83.77 117.86,85.57 119.67,87.38 120.72,87.38 123.03,89.69 125.1,89.69 127.49,92.07 127.49,102.15 121.91,107.73 111.29,107.73 110.51,108.51 104.49,108.51 100.36,112.63 94.01,112.63 92.53,111.15 77.58,111.15 72.41,105.98 61.18,105.98 60.24,105.04 29,105.04 26.72,107.32 26.72,112.12 27.76,113.16 28.93,113.16 29.04,113.05 29.04,112.9 29.17,112.78 v2(29.32,112.78)
  BOTTOM w0.076: UC1.H33 116.9,76.55 117.16,76.82 v2(117.16,76.87)
  BOTTOM w0.097: v2(29.32,112.78) 29.32,112.79 29.05,113.05 28.76,113.05 28.44,112.74 CT104.1
CPU_DP2_N0_C: length 3.6
  BOTTOM w0.097: CT104.2 27.53,112.81 27.22,113.12 27.15,113.12 26.91,112.88 26.91,112.67 25.92,111.68 25.56,111.68 25.48,111.6 UT9.18
CPU_DP2_N1: length 146
  IN1 w0.099: v2(117.96,81.61) 118.08,81.49 118.08,81.28 117.95,81.15 117.62,81.15 117.38,81.39 117.38,81.96 119.76,84.34 119.76,85.32 123.49,89.05 125.43,89.05 128.4,92.03 128.4,102.32 122.38,108.35 121.79,108.35 121.27,108.86 111.5,108.86 111.12,109.24 104.64,109.24 100.62,113.27 93.65,113.27 92.15,111.76 77.33,111.76 72.16,106.6 60.9,106.6 59.99,105.69 29.26,105.69 27.54,107.4 27.54,111.11 27.88,111.45 28.63,111.45 v2(28.94,111.14)
  BOTTOM w0.094: v2(117.96,81.61) 117.96,81.5 117.34,80.88 117.34,80.49 117.55,80.28 117.55,79.84 117.52,79.8 UC1.G38
  BOTTOM w0.097: CT106.1 28,110.98 28.33,111.31 28.76,111.31 v2(28.94,111.14)
CPU_DP2_N1_C: length 2.8
  BOTTOM w0.097: UT9.21 25.35,110.55 25.44,110.64 25.96,110.64 26.34,111.01 26.34,111.2 26.48,111.35 26.7,111.35 CT106.2
CPU_DP2_N2: length 146.2
  IN1 w0.076: v2(117.16,78.18) 117.16,77.99 117.27,77.88 117.35,77.88 117.43,77.8 117.56,77.8 117.69,77.93 117.69,78.32 117.4,78.6 117.4,78.88 117.38,78.9 117.38,78.93
  IN1 w0.099: v2(29.44,109.54) 29.44,109.65 29.89,110.1 30.57,110.1 32.57,108.1 57.11,108.1 57.6,107.62 62.89,107.62 63.77,108.5 66.22,108.5 67.92,110.19 71.7,110.19 74.29,112.78 91.39,112.78 93.39,114.78 100.94,114.78 104.81,110.91 112.26,110.91 112.99,110.18 123.78,110.18 125.23,108.73 125.23,106.94 129.48,102.69 129.48,91.53 125.68,87.74 123.78,87.74 120.85,84.81 120.85,81.96 121.18,81.62 121.18,81.14 119.97,79.93 117.88,79.93 117.38,79.43 117.38,78.93
  BOTTOM w0.076: UC1.F35 117.48,77.85 v2(117.16,78.18)
  BOTTOM w0.097: CT108.1 28,109.26 28.31,109.57 28.57,109.57 28.82,109.82 29.17,109.82 v2(29.44,109.54)
CPU_DP2_N2_C: length 2.4
  BOTTOM w0.097: UT9.24 25.51,109.5 25.54,109.53 26.76,109.53 27.09,109.21 CT108.2
CPU_DP2_N3: length 143.5
  IN1 w0.099: v2(119.81,80.59) 120.02,80.8 120.27,80.8 120.49,81.02 120.49,81.67 120.44,81.71 120.44,85.04 123.69,88.29 125.57,88.29 129.04,91.75 129.04,102.56 123.86,107.73 123.86,109.22 123.33,109.75 112.82,109.75 112.07,110.5 104.52,110.5 100.7,114.32 93.72,114.32 91.78,112.38 76.92,112.38 73.44,108.89 67.49,108.89 65.81,107.21 60.64,107.21 59.73,106.3 29.51,106.3 28.24,107.57 28.24,107.93 28.33,108.02 28.71,108.02 v2(28.94,107.78)
  BOTTOM w0.076: UC1.E36 118.38,78.73 118.67,79.03 118.67,79.55 118.56,79.65 118.56,80.49 118.92,80.85 119.55,80.85 v2(119.81,80.59)
  BOTTOM w0.097: CT110.1 28.45,107.85 28.87,107.85 v2(28.94,107.78)
CPU_DP2_N3_C: length 3.1
  BOTTOM w0.097: CT110.2 26.77,107.72 26.46,107.72 25.99,108.19 25.99,108.56 25.68,108.88 25.56,108.88 25.48,108.8 UT9.26
CPU_DP2_P0: length 151.3
  IN1 w0.099: v2(29.32,113.37) 27.67,113.37 26.51,112.21 26.51,107.23 28.91,104.83 60.32,104.83 61.27,105.77 72.5,105.77 77.67,110.94 92.62,110.94 94.1,112.42 100.28,112.42 104.4,108.3 110.42,108.3 111.2,107.52 121.82,107.52 127.28,102.06 127.28,92.16 125.01,89.9 122.95,89.9 120.64,87.59 119.58,87.59 117.65,85.66 117.65,83.86 116.55,82.75 116.55,79.93 115.79,79.16 115.79,78.2 116.56,77.43 116.56,77.03 v2(116.4,76.88)
  BOTTOM w0.076: v2(116.4,76.88) 116.48,76.88 UC1.H34
  BOTTOM w0.097: v2(29.32,113.37) 29.19,113.24 28.82,113.24 28.44,113.61 CT103.1
CPU_DP2_P0_C: length 3.6
  BOTTOM w0.097: CT103.2 27.53,113.61 27.22,113.3 27.07,113.3 26.72,112.95 26.72,112.75 25.84,111.86 25.56,111.86 25.48,111.95 UT9.17
CPU_DP2_P1: length 146.1
  IN1 w0.099: v2(117.93,80.75) 117.73,80.94 117.53,80.94 117.17,81.3 117.17,82.05 119.55,84.43 119.55,85.41 123.4,89.26 125.34,89.26 128.19,92.11 128.19,102.23 122.29,108.13 121.7,108.13 121.19,108.65 111.42,108.65 111.03,109.03 104.55,109.03 100.53,113.05 93.74,113.05 92.24,111.55 77.41,111.55 72.25,106.39 60.99,106.39 60.08,105.48 29.17,105.48 27.33,107.32 27.33,111.19 27.8,111.66 28.88,111.66 v2(28.94,111.72)
  BOTTOM w0.094: UC1.F37 117.59,79.57 117.74,79.71 117.74,80.35 117.52,80.57 117.52,80.8 117.64,80.92 117.81,80.92 117.93,80.8 v2(117.93,80.75)
  BOTTOM w0.097: CT105.1 28.35,111.5 28.64,111.5 28.86,111.72 v2(28.94,111.72)
CPU_DP2_P1_C: length 2.8
  BOTTOM w0.097: UT9.20 24.88,110.9 25.3,110.9 25.36,110.83 25.89,110.83 26.15,111.09 26.15,111.28 26.4,111.53 26.77,111.53 CT105.2
CPU_DP2_P2: length 146.1
  IN1 w0.076: v2(117.2,77.52) 117.31,77.63 117.62,77.63 117.85,77.86 117.85,78.38 117.57,78.67 117.57,78.88 117.59,78.9 117.59,78.93
  IN1 w0.099: v2(29.45,110.31) 30.66,110.31 32.66,108.31 57.2,108.31 57.69,107.83 62.8,107.83 63.68,108.71 66.13,108.71 67.83,110.4 71.62,110.4 74.2,112.99 91.31,112.99 93.3,114.99 101.03,114.99 104.9,111.12 112.35,111.12 113.08,110.39 123.86,110.39 125.44,108.81 125.44,107.02 129.69,102.77 129.69,91.45 125.77,87.53 123.87,87.53 121.06,84.72 121.06,82.04 121.39,81.71 121.39,81.06 120.06,79.72 117.97,79.72 117.59,79.34 117.59,78.93
  BOTTOM w0.076: v2(117.2,77.52) 117.27,77.52 UC1.F34
  BOTTOM w0.097: CT107.1 28.32,109.75 28.5,109.75 28.74,110 29.14,110 v2(29.45,110.31)
CPU_DP2_P2_C: length 2.4
  BOTTOM w0.097: CT107.2 26.97,110.07 26.61,109.71 25.62,109.71 25.48,109.85 UT9.23
CPU_DP2_P3: length 143.4
  IN1 w0.099: v2(119.83,81.22) 120.04,81.01 120.18,81.01 120.28,81.11 120.28,81.58 120.23,81.63 120.23,85.13 123.61,88.5 125.49,88.5 128.82,91.84 128.82,102.47 123.65,107.64 123.65,109.13 123.24,109.54 112.74,109.54 111.99,110.29 104.44,110.29 100.62,114.11 93.81,114.11 91.86,112.17 77.01,112.17 73.52,108.68 67.58,108.68 65.9,107 60.73,107 59.82,106.09 29.43,106.09 28.03,107.49 28.03,108.02 28.24,108.23 28.69,108.23 28.83,108.37 v2(28.94,108.37)
  BOTTOM w0.076: v2(119.83,81.22) 119.62,81.01 118.86,81.01 118.4,80.56 118.4,80.5 118.32,80.42 118.17,80.42 118.08,80.33 118.08,80.2 118.17,80.12 118.32,80.12 118.4,80.04 118.4,79.59 118.5,79.48 118.5,79.27 UC1.E37
  BOTTOM w0.097: CT109.1 28.25,108.04 28.61,108.04 v2(28.94,108.37)
CPU_DP2_P3_C: length 3.1
  BOTTOM w0.097: UT9.25 25.48,109.15 25.56,109.06 25.75,109.06 26.18,108.64 26.18,108.27 26.54,107.91 26.7,107.91 CT109.2
CPU_DP3_AUXN: length 178.8
  TOP w0.097: v2(264.39,32.6) 264.57,32.78 264.57,34.96 266.11,36.49 268.38,36.49 CV74.1
  IN1 w0.099: v2(122.45,71.81) 122.63,71.63 122.63,71.16 122.85,70.94 125.03,70.94 126.4,72.31 131.26,72.31 133.14,74.19 160.22,74.19 163.73,70.67 173.49,70.67 176.91,67.25 176.91,57.99 180.86,54.04 193.02,54.04 194.22,55.25 213.13,55.25 215.05,53.33 221.23,53.33 227.26,47.3 227.8,47.3 236.78,38.33 239.06,38.33 242.78,34.61 244.83,34.61 245.76,33.68 249.62,33.68 249.98,33.31 251.43,33.31 252.16,32.59 260.72,32.59 261.17,33.04 264.44,33.04 264.54,32.94 264.54,32.74 v2(264.39,32.6)
  BOTTOM w0.076: v2(122.45,71.81) 122.68,72.05 122.68,72.15 122.57,72.27 121.48,72.27 121.19,71.97 120.81,71.97 120.58,72.2 120.58,72.38 120.5,72.45 UC1.B27
CPU_DP3_AUXN_C: length 3.1
  TOP w0.097: CV112.2 323.1,72.56 323.3,72.56 v4(323.77,72.1) 324.33,71.53 324.58,71.53 324.68,71.43 UV6.3
CPU_DP3_AUXN_C_RD: length 2.3
  TOP w0.097: UV9.29 270.81,36.99 270.66,36.84 v4(270.07,36.84) 269.85,36.84 269.5,36.49 269.42,36.49 CV74.2
CPU_DP3_AUXN_RD: length 73.1
  TOP w0.097: RV71.1 268.88,38.04 269.05,38.04 269.15,38.14 269.15,38.45 269.52,38.83 270.05,38.83 270.26,38.61 270.26,38.45 v2(270.48,38.24) 270.16,37.92 270.16,37.85 270.33,37.67 270.68,37.67 270.88,37.88 270.88,37.9 270.97,37.99 UV9.27 ; CV112.1 321.8,72.23 321.33,72.69 319.73,72.69 v2(319.45,72.41)
  IN1 w0.099: v2(319.45,72.41) 319.45,72.48 319.18,72.75 312.98,72.75 310.94,70.71 310.94,68.13 286.26,43.45 277.81,43.45 276.98,42.61 276.32,42.61 272.59,38.89 270.41,38.89 270.17,38.65 270.17,38.53 270.47,38.24 v2(270.48,38.24)
CPU_DP3_AUXP: length 178.8
  TOP w0.097: CV73.1 268.38,36.31 266.18,36.31 264.76,34.88 264.76,32.82 v2(264.98,32.6)
  IN1 w0.099: v2(123.23,71.84) 123.07,71.84 122.84,71.61 122.84,71.25 122.94,71.15 124.94,71.15 126.31,72.52 131.17,72.52 133.05,74.4 160.3,74.4 163.82,70.88 173.58,70.88 177.12,67.34 177.12,58.08 180.95,54.25 192.93,54.25 194.13,55.46 213.22,55.46 215.14,53.54 221.31,53.54 227.34,47.51 227.89,47.51 236.86,38.54 239.15,38.54 242.87,34.82 244.91,34.82 245.84,33.89 249.71,33.89 250.07,33.52 251.52,33.52 252.25,32.8 260.63,32.8 261.09,33.25 264.53,33.25 264.75,33.03 264.75,32.83 v2(264.98,32.6)
  BOTTOM w0.076: v2(123.23,71.84) 122.85,72.22 122.64,72.43 121.42,72.43 121.12,72.14 120.87,72.14 120.74,72.27 120.74,72.38 120.82,72.45 UC1.A27
CPU_DP3_AUXP_C: length 3.2
  TOP w0.097: CV111.2 323.13,72.75 323.38,72.75 323.67,72.46 323.72,72.46 324.14,72.05 324.14,71.99 324.41,71.72 324.58,71.72 324.68,71.83 UV6.2
CPU_DP3_AUXP_C_RD: length 2.3
  TOP w0.097: CV73.2 269.42,36.31 269.57,36.31 269.88,36.62 270.37,36.62 270.41,36.66 270.65,36.66 270.82,36.49 UV9.30
CPU_DP3_AUXP_RD: length 72.8
  TOP w0.097: v2(319.45,73.05) 319.62,72.88 321.61,72.88 CV111.1 ; UV9.28 270.25,37.49 269.97,37.77 269.97,38.16 v2(269.89,38.24) 270.08,38.43 270.08,38.53 269.97,38.64 269.6,38.64 269.33,38.37 269.33,38.06 269.13,37.85 268.88,37.85 RV77.1
  IN1 w0.099: v2(269.89,38.24) 269.96,38.31 269.96,38.74 270.32,39.1 272.51,39.1 276.23,42.82 276.89,42.82 277.72,43.66 286.17,43.66 310.73,68.21 310.73,70.8 312.9,72.96 319.37,72.96 v2(319.45,73.05)
CPU_DP3_N0: length 185.2
  TOP w0.097: v2(265.56,32.65) 265.56,31.68 268.21,29.04 271.9,29.04 272.18,29.32 272.18,29.84 CV66.1
  IN1 w0.099: v2(265.56,32.65) 265.56,33.56 265.46,33.66 260.86,33.66 260.4,33.2 252.47,33.2 251.74,33.93 250.44,33.93 250.08,34.29 246.01,34.29 244.61,35.69 242.57,35.69 239.32,38.94 238.45,38.94 235.36,42.03 234.19,42.03 228.31,47.92 227.51,47.92 221.46,53.97 215.29,53.97 213.39,55.86 193.97,55.86 192.76,54.66 181.4,54.66 177.55,58.51 177.55,67.48 173.75,71.28 164.23,71.28 160.14,75.38 130.31,75.38 128.44,73.51 126.23,73.51 125.39,74.35 125.39,74.58 v2(125.14,74.83)
  BOTTOM w0.076: 122.47,77.63 122.46,77.63 122.45,77.64 122.24,77.64 121.74,77.14 120.32,77.14 119.88,76.69 119.47,76.69 119.28,76.88 119.28,77.03 119.13,77.18 UC1.D34
  BOTTOM w0.097: v2(125.14,74.83) 125.4,75.09 125.4,75.33 124.96,75.78 124.96,76.54 123.86,77.63 122.47,77.63
CPU_DP3_N0_C: length 2.9
  TOP w0.097: UV6.6 324.68,70.23 324.58,70.33 324.24,70.33 323.83,69.92 323.12,69.92 CV108.2
CPU_DP3_N0_C_RD: length 2.7
  TOP w0.097: CV66.2 272,30.7 272,30.93 272.43,31.36 272.43,31.41 272.92,31.9 272.92,32.12 273,32.2 UV9.39
CPU_DP3_N0_RD: length 63.5
  TOP w0.097: UV9.22 273,40.07 272.84,40.23 272.84,40.31 274.11,41.59 275.07,41.59 275.29,41.81 275.96,41.81 276.18,41.59 276.33,41.59 v2(276.53,41.39) ; v2(320.88,69.73) 321.11,69.96 321.48,69.96 321.85,69.59 CV108.1
  IN1 w0.099: v2(276.53,41.39) 276.69,41.55 276.97,41.55 277.18,41.76 277.18,41.94 277.99,42.76 287.62,42.76 290.22,45.36 290.22,46.54 311.74,68.05 317.46,68.05 319.52,70.11 320.51,70.11 v2(320.88,69.73)
CPU_DP3_N1: length 183.1
  TOP w0.097: v2(275.21,29.86) 275.09,29.98 275.09,30.28 CV68.1
  IN1 w0.099: v2(275.21,29.86) 275.21,30.73 273.34,32.59 268.29,32.59 266.4,34.48 254.61,34.48 252.46,35.1 249.7,35.12 246.35,35.12 244.7,36.77 242.66,36.77 239.55,39.87 238.68,39.87 235.7,42.86 234.54,42.86 222.58,54.81 215.61,54.81 212.94,57.48 205.29,57.48 204.69,56.87 192.97,56.87 192.45,56.34 183.37,56.34 182.07,57.64 182.07,58.5 178.37,62.2 178.37,67.83 174.09,72.11 164.57,72.11 160.35,76.33 131.45,76.33 130.94,76.83 126.55,76.83 126.36,76.65 126.36,76.18 v2(126.28,76.1)
  BOTTOM w0.076: 122.47,78.38 122.46,78.38 122.45,78.39 121.94,78.39 121.76,78.21 121.43,78.21 121.17,77.95 120.69,77.95 120.56,78.08 120.39,78.08 120.31,78 UC1.B34
  BOTTOM w0.097: 122.47,78.38 125.06,78.38 126.61,76.83 126.61,76.42 v2(126.28,76.1)
CPU_DP3_N1_C: length 3.8
  TOP w0.097: UV6.8 324.72,69.43 324.6,69.54 324.38,69.54 324.15,69.31 v4(324.15,68.96) 324.15,68.46 323.8,68.11 323.09,68.11 CV110.2
CPU_DP3_N1_C_RD: length 2.2
  TOP w0.097: CV68.2 274.94,31.27 274.94,31.49 274.72,31.71 274.54,31.71 274.42,31.83 274.42,32.19 274.5,32.27 UV9.42
CPU_DP3_N1_RD: length 62
  TOP w0.097: CV110.1 321.85,67.84 321.49,68.2 320.96,68.2 320.47,68.69 320.32,68.69 319.98,68.35 v2(319.98,68.34) ; UV9.19 274.5,40.21 274.37,40.34 274.37,40.63 274.54,40.79 277.85,40.79 278.06,41 278.06,41.3 v2(278.34,41.59)
  IN1 w0.099: v2(319.98,68.34) 319.61,68.71 319.35,68.71 317.44,66.81 311.36,66.81 291,46.44 291,45.27 287.73,42 278.28,42 278.18,41.9 278.18,41.75 v2(278.34,41.59)
CPU_DP3_N2: length 184.9
  TOP w0.097: CV70.1 276.27,30.2 276.27,30.02 v2(276.47,29.82)
  IN1 w0.076: 119.69,76.6 119.67,76.6 119.64,76.57 119.13,76.57 118.95,76.39 118.53,76.39 118.41,76.51 118.41,76.71 118.46,76.76 v2(118.69,76.76)
  IN1 w0.099: 119.69,76.6 120.42,76.6 121.27,75.75 124.2,75.75 125.9,77.45 160.1,77.45 164.83,72.72 174.34,72.72 178.99,68.08 178.99,62.46 184.41,57.03 192.26,57.03 192.72,57.48 204.17,57.48 204.78,58.09 213.2,58.09 215.85,55.44 222.82,55.44 232.64,45.63 232.73,45.63 234.88,43.47 235.95,43.47 238.91,40.51 239.78,40.51 242.91,37.38 246.82,37.38 254.7,35.1 266.66,35.1 268.49,33.26 274.16,33.26 276.28,31.14 276.28,30.01 v2(276.47,29.82)
  BOTTOM w0.076: v2(118.69,76.76) 118.38,76.45 UC1.E33
CPU_DP3_N2_C_RD: length 2
  TOP w0.097: UV9.45 276,32.31 275.85,32.16 275.85,31.81 276.21,31.45 276.21,31.26 CV70.2
CPU_DP3_N3: length 185.1
  TOP w0.097: v2(277.78,29.86) 277.56,30.08 277.56,30.21 CV72.1
  IN1 w0.099: v2(122.2,76.16) 122.2,76.87 123.41,78.08 160.46,78.08 164.75,73.79 174.15,73.79 179.62,68.31 179.62,62.75 184.28,58.1 203.18,58.1 203.79,58.71 213.45,58.71 216.1,56.06 223.08,56.06 232.85,46.29 232.94,46.29 235.14,44.09 236.21,44.09 239.17,41.13 240.61,41.13 243.74,38 246.91,38 254.78,35.71 267,35.71 268.42,34.3 272.79,34.3 272.88,34.21 274.75,34.21 277.59,31.37 277.59,30.05 v2(277.78,29.86)
  BOTTOM w0.076: UC1.B33 120.24,76.39 120.11,76.26 120.11,76.14 120.25,76 120.39,76 120.74,76.34 121.17,76.34 121.4,76.57 122.38,76.57 122.54,76.41 122.54,76.25 122.46,76.16 v2(122.2,76.16)
CPU_DP3_N3_C_RD: length 1.9
  TOP w0.097: CV72.2 277.42,31.32 277.42,32.11 277.5,32.19 UV9.48
CPU_DP3_P0: length 185.1
  TOP w0.097: v2(266.14,32.65) 266.13,32.65 265.74,32.27 265.74,31.76 268.28,29.22 271.82,29.22 272,29.39 272,29.5 271.61,29.89 CV65.1
  IN1 w0.099: v2(125.86,74.85) 125.86,74.83 125.61,74.58 125.61,74.43 126.32,73.72 128.36,73.72 130.22,75.59 160.22,75.59 164.32,71.49 173.83,71.49 177.76,67.57 177.76,58.6 181.49,54.87 192.67,54.87 193.88,56.07 213.48,56.07 215.37,54.18 221.55,54.18 227.6,48.13 228.4,48.13 234.28,42.24 235.44,42.24 238.53,39.15 239.4,39.15 242.66,35.9 244.7,35.9 246.1,34.5 250.17,34.5 250.53,34.14 251.83,34.14 252.56,33.41 260.31,33.41 260.77,33.87 265.55,33.87 265.77,33.64 265.77,33.01 266.13,32.65 v2(266.14,32.65)
  BOTTOM w0.076: UC1.C34 119.61,77.19 119.45,77.03 119.45,76.95 119.54,76.86 119.81,76.86 120.25,77.31 121.67,77.31 122.18,77.81 122.45,77.81 122.46,77.82 122.47,77.82
  BOTTOM w0.097: v2(125.86,74.85) 125.6,75.11 125.6,75.39 125.14,75.85 125.14,76.61 123.94,77.82 122.47,77.82
CPU_DP3_P0_C: length 2.9
  TOP w0.097: UV6.5 324.68,70.63 324.58,70.52 324.11,70.52 v4(323.89,70.3) 323.69,70.1 323.11,70.1 CV107.2
CPU_DP3_P0_C_RD: length 2.8
  TOP w0.097: UV9.38 272.5,32.3 272.74,32.07 272.74,31.98 v4(272.06,31.31) 271.81,31.06 271.81,30.69 CV65.2
CPU_DP3_P0_RD: length 63.6
  TOP w0.097: v2(276.53,41.97) 276.33,41.77 276.25,41.77 276.03,41.99 275.21,41.99 274.99,41.77 274.04,41.77 272.66,40.39 272.66,40.23 272.5,40.07 UV9.23 ; CV107.1 321.78,70.45 321.48,70.15 321.05,70.15 v2(320.88,70.32)
  IN1 w0.099: v2(276.53,41.97) 276.74,41.76 276.88,41.76 276.97,41.84 276.97,42.03 277.91,42.97 287.53,42.97 290.01,45.45 290.01,46.63 311.65,68.26 317.38,68.26 319.43,70.32 v2(320.88,70.32)
CPU_DP3_P1: length 183.1
  TOP w0.097: v2(274.63,29.86) 274.85,30.08 274.85,30.22 274.66,30.41 CV67.1
  IN1 w0.099: v2(274.63,29.86) 275,30.23 275,30.64 273.26,32.38 268.2,32.38 266.31,34.27 254.58,34.27 252.43,34.89 249.7,34.91 246.26,34.91 244.61,36.56 242.57,36.56 239.47,39.66 238.6,39.66 235.61,42.65 234.45,42.65 222.49,54.6 215.52,54.6 212.86,57.26 205.38,57.26 204.77,56.66 193.06,56.66 192.53,56.13 183.28,56.13 181.86,57.56 181.86,58.42 178.16,62.11 178.16,67.74 174,71.9 164.49,71.9 160.27,76.12 131.36,76.12 130.85,76.62 126.64,76.62 126.57,76.56 126.57,76.39 126.87,76.09 v2(127.12,76.09)
  BOTTOM w0.076: UC1.B36 120.41,78.24 120.63,78.24 120.76,78.12 121.11,78.12 121.36,78.37 121.69,78.37 121.87,78.55 122.45,78.55 122.46,78.56 122.47,78.56
  BOTTOM w0.097: 122.47,78.56 125.14,78.56 126.79,76.91 126.79,76.42 v2(127.12,76.09)
CPU_DP3_P1_C: length 3.8
  TOP w0.097: CV109.2 323.13,68.3 323.72,68.3 323.97,68.54 323.97,68.63 323.92,68.67 323.92,69.35 324.3,69.73 324.62,69.73 324.72,69.83 UV6.7
CPU_DP3_P1_C_RD: length 2.2
  TOP w0.097: CV67.2 274.75,31.16 274.75,31.41 274.64,31.52 274.47,31.52 274.37,31.62 274.24,31.75 274.24,32.2 274,32.43 UV9.41
CPU_DP3_P1_RD: length 61.9
  TOP w0.097: CV109.1 321.56,68.38 321.03,68.38 320.55,68.87 320.03,68.87 v2(319.98,68.92) ; v2(277.76,41.59) 277.88,41.47 277.88,41.08 277.77,40.98 274.46,40.98 274.19,40.7 274.19,40.36 274,40.17 UV9.20
  IN1 w0.099: v2(277.76,41.59) 277.97,41.8 277.97,41.99 278.19,42.21 287.65,42.21 290.79,45.36 290.79,46.53 311.27,67.02 317.36,67.02 319.26,68.92 v2(319.98,68.92)
CPU_DP3_P2: length 184.7
  TOP w0.097: v2(275.89,29.82) 276.09,30.02 276.09,30.17 CV69.1
  IN1 w0.076: v2(118.06,76.73) 118.25,76.54 118.25,76.44 118.46,76.22 119.02,76.22 119.2,76.41 119.64,76.41 119.67,76.39 119.69,76.39
  IN1 w0.099: v2(275.89,29.82) 276.07,30.01 276.07,31.05 274.07,33.05 268.41,33.05 266.57,34.89 254.67,34.89 246.79,37.17 242.83,37.17 239.69,40.3 238.83,40.3 235.87,43.26 234.79,43.26 232.64,45.41 232.55,45.41 222.73,55.23 215.76,55.23 213.11,57.88 204.87,57.88 204.26,57.27 192.8,57.27 192.35,56.82 184.33,56.82 178.78,62.37 178.78,67.99 174.26,72.51 164.74,72.51 160.02,77.24 125.98,77.24 124.29,75.54 121.18,75.54 120.34,76.39 119.69,76.39
  BOTTOM w0.076: UC1.F33 117.73,76.41 v2(118.06,76.73)
CPU_DP3_P2_C_RD: length 2
  TOP w0.097: CV69.2 276.03,31.17 276.03,31.38 275.67,31.74 275.67,32.16 275.5,32.33 UV9.44
CPU_DP3_P3: length 184.8
  TOP w0.097: v2(277.2,29.86) 277.36,30.03 277.36,30.16 CV71.1
  IN1 w0.099: v2(277.2,29.86) 277.38,30.05 277.38,31.28 274.67,34 272.79,34 272.7,34.09 268.33,34.09 266.91,35.5 254.75,35.5 246.88,37.79 243.65,37.79 240.52,40.92 239.08,40.92 236.12,43.88 235.05,43.88 232.85,46.08 232.76,46.08 222.99,55.85 216.01,55.85 213.37,58.49 203.87,58.49 203.27,57.89 184.19,57.89 179.41,62.66 179.41,68.23 174.06,73.58 164.66,73.58 160.37,77.86 123.5,77.86 122.41,76.78 122.41,76.53 122.76,76.18 v2(122.97,76.18)
  BOTTOM w0.076: UC1.C33 119.93,76.39 120.21,76.67 120.49,76.67 120.66,76.51 121.1,76.51 121.33,76.73 122.45,76.73 122.7,76.48 122.7,76.44 v2(122.97,76.18)
CPU_DP3_P3_C_RD: length 1.8
  TOP w0.097: UV9.47 277,32.35 277.24,32.12 277.24,31.11 CV71.2
CPU_VIDALERT#: length 26.7
  TOP w0.102: RC153.2 72.09,85.38 72.55,84.92 v1(74.74,84.92) 75.51,84.92 76.25,84.19 76.26,84.19 76.87,83.58 76.87,83.43 76.48,83.04 76.48,82.89 76.62,82.75 76.77,82.75 77.16,83.14 77.3,83.14 77.47,82.98 77.47,79.91 77.63,79.75 77.77,79.75 78.1,80.08 78.24,80.08 78.39,79.93 78.39,79.79 78.06,79.46 78.06,79.32 78.2,79.17 78.35,79.17 78.68,79.5 78.82,79.5 78.96,79.36 78.96,79.22 78.63,78.89 78.63,78.74 79.98,77.4 80.12,77.4 80.44,77.71 80.58,77.71 80.72,77.57 80.72,77.43 80.41,77.11 80.41,76.97 80.55,76.83 80.7,76.83 81.01,77.14 81.15,77.14 81.3,77 81.3,76.85 80.98,76.54 80.98,76.39 81.2,76.17 82.14,76.17 82.32,76.35 82.87,76.35 83.59,75.64 83.79,75.64 83.89,75.74 83.89,76.25 83.99,76.35 84.2,76.35 84.3,76.25 84.3,75.74 84.4,75.64 84.85,75.64 v2(84.92,75.57)
  BOTTOM w0.076: UC1.BH31 85.24,75.25 v2(84.92,75.57)
CPU_XDP_HOOK6: length 4.5
  TOP w0.102: JXDP1.46 v1(43.67,46.99) 43.67,47.13 42.83,47.97 RC144.1 RC115.1
CPU_XDP_PRDY#: length 76.4
  TOP w0.102: v2(32.05,41.68) 32.94,40.79 33.19,40.79 33.67,40.32 JXDP1.5 33.67,37.8 34.07,37.4 T189.1 ; RC314.1 75.62,70.28 76.29,70.28 76.91,70.9 77.68,70.9 78.09,71.31 v2(78.15,71.31)
  IN1 w0.099: v2(78.15,71.31) 76.25,71.31 72.02,67.08 71.13,67.08 55.95,51.9 39.53,51.9 38.96,51.33 36.24,51.33 34.87,49.96 33.87,49.96 31.32,47.41 31.32,42.41 v2(32.05,41.68)
  BOTTOM w0.076: UC1.BP27 81.16,71.73 79.37,71.73 79.23,71.59 79.23,71.58 78.95,71.31 v2(78.15,71.31)
CPU_XDP_PREQ#: length 85
  TOP w0.102: v2(31.42,41.55) 32.43,40.54 33.04,40.54 33.17,40.41 JXDP1.3 33.17,37.77 33.68,37.25 RC138.2
  IN1 w0.099: v2(79.71,74.14) 79.64,74.06 77.18,74.06 75.24,72.12 72.63,72.12 71.02,70.51 71.02,70.49 59.23,58.7 56.08,58.7 54.4,57.02 53.03,57.02 51.22,55.21 50.05,55.21 49.09,54.25 48.12,54.25 47.45,54.93 42.54,54.93 40.32,52.7 36.29,52.7 31.1,47.51 31.1,41.87 v2(31.42,41.55)
  BOTTOM w0.076: UC1.BL30 83.26,74.13 79.72,74.13 v2(79.71,74.14)
  BOTTOM w0.102: v2(79.71,74.14) 79.51,73.94 77.77,73.94 77.67,74.04 76.54,74.04 76.28,73.79 76.28,72.96 74.74,71.41 T190.1 73.68,71.41 73.41,71.14 RC315.1
CPU_XDP_PRS: length 12.6
  TOP w0.107: RC127.1 51.61,54.19 v1(51.61,50.47) 51.61,48.03 50.23,46.66 47.82,46.66 47.17,46 JXDP1.60
CPU_XDP_TCLK: length 64.5
  TOP w0.107: JXDP1.57 46.67,38.24 47.54,37.36 54.17,37.36 59.51,42.69 59.51,53.98 T181.1 57.49,54.63 56.61,55.52 56.61,56.75 v2(56.86,57)
  IN1 w0.099: v2(72.82,69.24) 71.27,69.24 59.09,57.06 56.92,57.06 v2(56.86,57)
  BOTTOM w0.076: UC1.BR28 80.66,72.67 79.75,72.67 79.5,72.41 79.04,72.41 79.02,72.39 77.24,72.39 76.74,71.89
  BOTTOM w0.107: v2(72.82,69.24) 73.02,69.44 RC143.1 73.4,69.87 73.91,70.38 74.29,70.38 RC139.1 76.18,71.01 76.18,71.34 76.74,71.89
CPU_XDP_TDI: length 57.7
  TOP w0.102: JXDP1.56 46.17,46.4 47.14,47.37 49.17,47.37 49.58,47.78 RC229.1 49.86,48.16 50.12,48.42 50.12,54.09 T185.1 49.45,54.76 v2(48.84,54.76)
  IN1 w0.099: v2(48.84,54.76) 51.49,57.42 54.36,57.42 55.95,59 59.22,59 66.93,66.72 66.93,66.74 72.54,72.34 75.14,72.34 77.09,74.29 79.29,74.29 79.54,74.54 82.89,74.54 v2(83.34,74.99)
  BOTTOM w0.102: v2(83.34,74.99) 83.34,75.51 UC1.BL32
CPU_XDP_TDO: length 51.7
  TOP w0.102: v2(48.03,53.62) 47.86,53.45 T184.1 47.86,51.84 47.93,51.78 47.93,48.54 47.48,48.1 RC230.1 RC135.1 CC306.1 45.17,47.64 JXDP1.52
  IN1 w0.099: v2(78.7,73.02) 78.69,73.02 77.34,71.67 72.84,71.67 58.84,57.67 55.78,57.67 52.14,54.02 48.43,54.02 v2(48.03,53.62)
  BOTTOM w0.102: v2(78.7,73.02) 79.05,73.36 80.01,73.36 UC1.BT28
CPU_XDP_TMS: length 52.8
  TOP w0.102: JXDP1.58 46.68,44.95 46.68,46.2 47.62,47.14 49.96,47.14 50.59,47.78 RC228.1 50.7,48.16 51.12,48.58 51.12,51.91 51.12,51.92 T180.1 51.12,52.58 51.12,52.58 51.12,54 50.37,54.76 v2(50.37,54.76)
  IN1 w0.099: v2(50.37,54.76) 50.38,54.75 52.55,54.75 55.69,57.89 58.75,57.89 72.75,71.89 76.36,71.89 v2(77.54,73.07)
  BOTTOM w0.076: UC1.BP28 81.23,73.44 80.25,73.44 80.1,73.59 79.37,73.59
  BOTTOM w0.102: 79.37,73.59 78.07,73.59 77.54,73.07 v2(77.54,73.07)
CPU_XDP_TRST#: length 241.2
  TOP w0.089: 210.73,50.17 210.73,49.93 v2(210.85,49.81)
  TOP w0.102: v2(169.22,55.47) 168.77,55.93 168.77,57.77 172.58,61.59 183.68,61.59 188.24,57.03 189.19,57.03 190.54,58.38 206.33,58.38 210.73,53.99 210.73,50.17 ; v2(76.36,75.22) 75.61,74.47 74.73,74.47 72.89,72.64 72.89,71.34 CC308.1 72.4,70.84 72.4,69.08 72.69,68.79 72.69,66.92 63.24,57.48 48.93,57.48 48.43,56.98 T179.1 48.43,54 49.02,53.42 49.02,48.56 48.61,48.16 RC136.1 48.56,47.7 48.46,47.6 46.73,47.6 45.67,46.54 JXDP1.54
  IN3 w0.102: v2(169.22,55.47) 167.84,55.47 166.72,56.59 166.72,59.4 148.17,77.95 147.17,77.95 142.15,82.96 137.14,82.96 132.55,87.55 121.78,87.55 119.5,85.27 118.89,85.27 117.84,84.22 117.73,84.22 116,82.49 103.93,82.49 103.5,82.92 101.5,82.92 100.43,83.99 81.04,83.99 80.36,83.31 78.22,83.31 75.88,80.97 75.88,77.25 76.36,76.78 v2(76.36,75.22)
  BOTTOM w0.076: UC1.BP30 81.36,74.88 81,74.88 80.84,75.05 79.44,75.05 79.4,75.09 78.32,75.09
  BOTTOM w0.089: v2(210.85,49.81) 210.65,49.81 210.37,49.53 210.36,49.53 209.93,49.1 209.93,48.25 209.16,47.48 209.16,46.78 207.92,45.54 207.92,43.98 207.73,43.79 207.73,43.46 207.93,43.26 207.93,42.96 207.96,42.93 207.96,42.24 UH1.AM4
  BOTTOM w0.102: 78.32,75.09 78.19,75.22 v2(76.36,75.22)
CSCOMP_2PH: length 15
  TOP w0.203: PU1700.31 56.53,77.92 56.03,77.42 55.62,77.42 PC1728.1 55.17,76.09 PC1726.1 55.21,76.02 PR1742.2 56.04,76.01 PR1744.1 56.04,69.61 55.43,68.99 v1(54.09,68.99) v2(53.36,68.99)
  BOTTOM w0.203: v2(53.36,68.99) PH1702.1
CSCOMP_4PH: length 23.5
  TOP w0.203: PU1700.8 56.93,86.92 v1(56.35,87.5) 56.03,87.82 PC1725.2 56.03,89.25 PC1724.1 56.02,90.13 PR1743.1 56.25,90.14 56.58,89.81 56.58,89.57 PR1741.1 57.04,89.46 v2(57.04,90.05)
  IN3 w0.122: v2(57.04,90.05) 57.33,90.05 58.71,88.67 64.86,88.67 65.3,89.11 68.4,89.11 69.54,90.25 v2(70.06,90.25)
  BOTTOM w0.102: PH1701.1 71.8,90.68 71.38,90.26 70.08,90.26 v2(70.06,90.25)
CSIN_ISL88738: length 23.7
  TOP w0.203: v2(13.25,34.82) 13,34.82 12.59,34.41 PU901.14
  TOP w0.254: PR910.2 12.38,52.22 12.38,51.17 11.9,50.69 v2(11.81,50.69) ; PC925.2 13.44,34.63 v2(13.25,34.82)
  IN1 w0.254: v2(11.81,50.69) 11.48,50.36 11.48,46.35 11.93,45.9 11.93,35.64 12.75,34.82 v2(13.25,34.82)
  BOTTOM w0.102: v1(12.33,33.49) 12.51,33.67 PC927.1
  BOTTOM w0.254: v2(13.25,34.82) 12.96,34.53 PC927.1
CSIP_ISL88738: length 21.9
  TOP w0.203: PU901.15 12.48,34.81 13.13,35.46 v2(13.25,35.46)
  TOP w0.254: PC925.1 13.35,35.55 v2(13.25,35.46) ; PR909.2 12,51.98 12,51.47 v2(11.8,51.27)
  IN1 w0.254: v2(11.8,51.27) 11.91,51.27 12.29,50.89 12.29,50.49 11.86,50.05 11.86,46.51 12.32,46.06 12.32,35.89 12.75,35.46 v2(13.25,35.46)
  BOTTOM w0.254: v2(13.25,35.46) 13.2,35.4 PC926.1
CSN_1PH: length 64
  TOP w0.152: PR1703.1 66.23,82.34 v2(66.36,82.47)
  IN3 w0.102: v2(66.36,82.47) 66.36,82.5 69.69,85.84 72.35,85.84 72.96,85.23 76.7,85.23 76.98,84.95 78.77,84.95 79.08,85.26 106.51,85.26 107.19,84.58 109.76,84.58 110.41,85.23 116.73,85.23 118.39,86.88 v2(118.39,90.12)
  BOTTOM w0.152: v2(118.39,90.12) PH1700.1 114.42,90.12 114.19,89.89 PL2001.3
