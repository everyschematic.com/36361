# Allegro board LA-F711P R05-0112.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A_D36: length 71.9
  IN3 w0.076: v2(83.44,50.65) 82.89,50.65 82,49.76 82,49.54
  IN3 w0.097: 82,49.54 82,48.13 78.53,44.65 62.24,44.65 41.81,24.22 41.81,23.97 41.71,23.87 41.49,23.87 41.4,23.78 41.4,23.58 41.49,23.49 41.71,23.49 41.81,23.39 41.81,23.01 41.73,22.93 41.6,22.93 41.36,23.16 41.22,23.17 41.09,23.04 41.09,22.89 41.32,22.66 41.32,22.52 41.19,22.39 41.05,22.39 40.99,22.44 40.86,22.44 40.72,22.31 40.72,22.17 40.78,22.11 40.78,21.98 39.29,20.49 39.29,19.68 39.45,19.53 39.45,18.67 39.35,18.57 39,18.57 38.87,18.7 v2(38.87,18.99)
  BOTTOM w0.076: UC1.BG2 86.11,53.59 85.83,53.31 85.83,53.03 85.98,52.88 85.98,52.02 84.88,50.93 84.3,50.93 84.02,50.65 v2(83.44,50.65)
  BOTTOM w0.107: JDIMM1.49 40.22,20.69 39.4,19.87 39.4,19.52 v2(38.87,18.99)
DDR_A_D37: length 70.6
  IN3 w0.076: v2(83.02,50.17) 82.72,50.17 82.3,49.76 82.3,49.43
  IN3 w0.097: 82.3,49.43 82.3,48 78.65,44.35 62.36,44.35 42.11,24.1 42.11,22.88 39.75,20.52 39.75,17.12 39.53,16.9 39.39,16.9 39.18,17.11 v2(38.88,17.11)
  BOTTOM w0.076: UC1.BG1 86.11,53.05 86.2,52.96 86.2,51.91 84.89,50.6 84.4,50.6 83.97,50.17 v2(83.02,50.17)
  BOTTOM w0.107: JDIMM1.50 40.47,15.52 v2(38.88,17.11)
DDR_A_D38: length 71.2
  IN3 w0.076: 85.16,48.64 85.29,48.77 85.29,50.09 86.84,51.64 86.84,52.4 v2(87.29,52.85)
  IN3 w0.097: 85.16,48.64 85.02,48.5 85.02,47.69 79.59,42.26 63.24,42.26 46.39,25.41 46.39,24.65 45.69,23.95 45.69,23.43 43.73,21.48 43.73,15.57 43.61,15.44 43.24,15.44 43.14,15.54 43.14,16 43.04,16.1 42.86,16.1 42.76,16 42.76,15.54 42.66,15.44 42.41,15.44 42.31,15.54 42.31,15.99 42.21,16.09 v2(41.95,16.09)
  BOTTOM w0.076: UC1.BF1 86.97,53.18 v2(87.29,52.85)
  BOTTOM w0.107: v2(41.95,16.09) 42.47,15.57 JDIMM1.58
DDR_A_D39: length 71.4
  IN3 w0.076: v2(87.27,53.47) 86.53,52.74 86.53,51.84 85.1,50.41 85.1,49.01 84.87,48.78
  IN3 w0.097: v2(41.99,17.74) 42.37,17.37 42.37,16.84 42.47,16.74 43.33,16.74 43.44,16.84 43.44,21.6 43.61,21.78 45.39,23.56 45.39,24.08 46.09,24.77 46.09,25.53 63.11,42.56 79.46,42.56 84.72,47.82 84.72,48.63 84.87,48.78
  BOTTOM w0.076: UC1.BF2 86.92,53.83 v2(87.27,53.47)
  BOTTOM w0.107: v2(41.99,17.74) 42.77,16.96 42.77,15.67 43.47,14.97 JDIMM1.62
DDR_A_D40: length 70.1
  IN3 w0.097: v2(86.08,50.23) 86.25,50.05 86.25,49.51 86.06,49.32 86.06,48.95 86.01,48.9 86.01,47.55 79.92,41.46 64.08,41.46 53.39,30.76 53.25,30.76 53.15,30.87 53.01,30.87 52.88,30.73 52.88,30.59 52.98,30.49 52.98,30.35 52.85,30.22 52.71,30.22 52.6,30.32 52.47,30.32 52.33,30.18 52.33,30.05 52.44,29.94 52.44,29.81 52.3,29.67 52.16,29.67 52.06,29.77 51.92,29.77 51.79,29.64 51.79,29.5 51.89,29.4 51.89,29.26 51.75,29.12 51.62,29.12 51.51,29.23 51.38,29.23 51.24,29.09 51.24,28.96 51.34,28.85 51.34,28.72 51.21,28.58 51.07,28.58 50.97,28.68 50.83,28.68 50.69,28.55 50.69,28.41 50.8,28.31 50.8,28.17 50.66,28.03 50.52,28.03 50.42,28.14 50.28,28.14 50.15,28 50.15,27.86 50.25,27.76 50.25,27.62 50.11,27.49 49.98,27.49 49.87,27.59 49.74,27.59 47.19,25.04 47.19,23.8 45.16,21.76 45.16,21.27 45.16,19.54 44.91,19.29 v2(44.21,19.29)
  BOTTOM w0.076: v2(86.08,50.23) 87.05,50.23 88.41,51.58 88.41,52.87 88.34,52.94 88.34,53.3 88.63,53.59 UC1.BD2
  BOTTOM w0.107: v2(44.21,19.29) 45.72,20.81 JDIMM1.71
DDR_A_D41: length 69.2
  IN3 w0.076: v2(85.67,49.11) 85.71,49.07 85.71,48.41
  IN3 w0.097: v2(44.21,20.84) 44.73,20.84 44.86,20.98 44.86,21.89 46.89,23.92 46.89,25.2 54.13,32.44 54.26,32.44 54.37,32.33 54.5,32.33 54.64,32.47 54.64,32.61 54.54,32.71 54.54,32.85 54.67,32.98 54.81,32.98 54.91,32.88 55.05,32.88 55.19,33.02 55.19,33.15 55.08,33.26 55.08,33.39 55.22,33.53 55.36,33.53 55.46,33.43 55.6,33.43 55.73,33.56 55.73,33.7 55.63,33.8 55.63,33.94 55.76,34.08 55.9,34.08 56.01,33.97 56.14,33.97 56.28,34.11 56.28,34.25 56.17,34.35 56.17,34.49 56.31,34.62 56.45,34.62 56.55,34.52 56.69,34.52 56.83,34.65 56.83,34.79 56.72,34.9 56.72,35.03 56.86,35.17 56.99,35.17 57.1,35.06 57.24,35.06 57.37,35.2 57.37,35.34 57.27,35.44 57.27,35.58 57.4,35.71 57.54,35.71 57.64,35.61 57.78,35.61 57.92,35.75 57.92,35.88 57.81,35.99 57.81,36.12 57.95,36.26 58.09,36.26 58.19,36.16 58.33,36.16 58.46,36.29 58.46,36.43 58.36,36.53 58.36,36.67 58.5,36.81 58.63,36.81 58.74,36.7 58.87,36.7 59.01,36.84 59.01,36.98 58.91,37.08 58.91,37.22 59.04,37.35 59.18,37.35 59.28,37.25 59.42,37.25 59.56,37.38 59.56,37.52 59.45,37.63 59.45,37.76 59.59,37.9 59.72,37.9 59.83,37.79 59.97,37.79 60.1,37.93 60.1,38.07 60,38.17 60,38.31 60.13,38.45 60.27,38.45 60.38,38.34 60.51,38.34 60.65,38.48 60.65,38.61 60.54,38.72 60.54,38.86 60.68,38.99 60.82,38.99 60.92,38.89 61.06,38.89 61.19,39.02 61.19,39.16 61.09,39.26 61.09,39.4 61.23,39.54 61.36,39.54 61.47,39.43 61.6,39.43 61.74,39.57 61.74,39.71 61.64,39.81 61.64,39.95 61.77,40.08 61.91,40.08 62.01,39.98 62.15,39.98 63.93,41.76 79.8,41.76 85.71,47.67 85.71,48.41
  BOTTOM w0.076: v2(85.67,49.11) 85.99,49.11 86.58,49.71 87.05,49.71 88.63,51.29 UC1.BD1
  BOTTOM w0.107: JDIMM1.67 44.72,21.36 v2(44.21,20.84)
DDR_A_D42: length 71.2
  IN3 w0.097: v2(47.49,20.76) 47.49,20.96 47.57,21.04 47.86,21.04 47.98,20.92 47.98,19.48 48.08,19.37 48.27,19.37 48.37,19.48 48.37,20.93 48.48,21.03 48.66,21.03 48.76,20.93 48.76,19.28 48.86,19.18 49.18,19.18 49.28,19.28 49.28,24.17 50.4,25.29 50.91,25.29 64.98,39.36 80.79,39.36 88.11,46.68 88.11,48.04 89.18,49.12 89.18,49.46 89.18,49.46 89.18,54.33 89.65,54.8 v2(89.86,54.8)
  BOTTOM w0.076: v2(89.86,54.8) 89.53,55.13 UC1.BC4
  BOTTOM w0.107: v2(47.49,20.76) 47.72,20.98 JDIMM1.79
DDR_A_D43: length 72
  IN3 w0.097: v2(89.87,55.45) 88.98,55.45 88.48,54.95 88.48,52.72 88.88,52.32 88.88,49.24 87.81,48.17 87.81,46.81 80.66,39.66 64.86,39.66 50.79,25.59 50.27,25.59 48.98,24.3 48.98,21.44 48.88,21.34 48.65,21.34 48.55,21.43 48.55,22.22 48.44,22.33 48.26,22.33 48.17,22.24 48.17,21.43 48.07,21.34 47.27,21.34 47.01,21.08 47.01,19.71 47.38,19.33 v2(47.38,18.96)
  BOTTOM w0.076: UC1.BC5 89.55,55.78 v2(89.87,55.45)
  BOTTOM w0.107: JDIMM1.83 48.72,20.3 v2(47.38,18.96)
DDR_A_D44: length 71.7
  IN3 w0.097: v2(87.26,51.57) 87.35,51.48 87.35,50.42 86.85,49.92 86.85,49.27 86.66,49.08 86.66,48.7 86.61,48.65 86.61,47.3 80.17,40.86 64.37,40.86 50.29,26.78 49.78,26.78 47.79,24.79 47.79,23.55 45.76,21.52 45.76,19.29 45.25,18.79 45.25,16.62 45.15,16.52 44.6,16.52 44.49,16.41 44.49,16.23 44.58,16.13 45.15,16.13 45.25,16.04 45.25,15.81 45.15,15.71 v2(44.18,15.71)
  BOTTOM w0.076: v2(87.26,51.57) 88.02,52.32 88.02,55.17 UC1.BD5
  BOTTOM w0.107: v2(44.18,15.71) 44.47,15.43 JDIMM1.66
DDR_A_D45: length 71.1
  IN3 w0.097: v2(86.89,51.08) 86.89,50.55 86.55,50.21 86.55,49.39 86.36,49.2 86.36,48.82 86.31,48.78 86.31,47.43 80.04,41.16 64.24,41.16 50.17,27.08 49.65,27.08 47.49,24.92 47.49,23.67 45.46,21.64 45.46,21.39 45.46,19.42 44.95,18.91 44.95,17.14 44.85,17.04 44.67,17.04 44.57,17.14 44.57,17.44 44.47,17.54 v2(44.21,17.54)
  BOTTOM w0.076: UC1.BD4 88.26,54.76 88.26,53.76 88.18,53.68 88.18,52.77 88.24,52.71 88.24,51.97 87.36,51.08 v2(86.89,51.08)
  BOTTOM w0.107: JDIMM1.70 45.47,15.79 44.72,16.54 44.72,17.03 v2(44.21,17.54)
DDR_A_D46: length 70
  IN3 w0.097: v2(47.44,17.09) 47.85,17.5 47.85,18.7 47.95,18.8 48.19,18.8 48.29,18.7 48.29,17.8 48.39,17.7 48.57,17.7 48.68,17.8 48.68,18.69 48.78,18.8 49.48,18.8 49.58,18.9 49.58,24.05 50.52,24.99 51.03,24.99 65.11,39.06 80.91,39.06 88.41,46.56 88.41,47.92 89.48,48.99 89.48,49.33 89.48,49.33 89.48,52.42 v2(89.9,52.84)
  BOTTOM w0.076: v2(89.9,52.84) 89.56,53.18 UC1.BC1
  BOTTOM w0.107: v2(47.44,17.09) 48.97,15.55 JDIMM1.84
DDR_A_D47: length 69.9
  IN3 w0.097: v2(89.86,53.5) 90.47,52.89 90.47,52.24 89.78,51.55 89.78,48.87 88.71,47.8 88.71,46.43 81.03,38.76 65.23,38.76 51.16,24.69 50.64,24.69 49.88,23.93 49.88,18.69 49.07,17.88 49.07,16.76 48.98,16.66 48.78,16.66 48.69,16.76 48.69,17.23 48.59,17.32 48.36,17.32 48.26,17.22 48.26,15.53 48.15,15.43 v2(47.47,15.43)
  BOTTOM w0.076: UC1.BC2 89.53,53.83 v2(89.86,53.5)
  BOTTOM w0.107: JDIMM1.80 47.97,15.02 47.56,15.43 v2(47.47,15.43)
DDR_A_D48: length 51.2
  IN1 w0.076: 82.35,49.38 82.35,50.1 84.71,52.45 84.71,53.14 85.77,54.2 85.77,57.51 86.23,57.96 86.23,60.05 86.31,60.13 86.59,60.13 v2(86.78,59.95)
  IN1 w0.097: v2(84.48,17.28) 84.33,17.42 83.83,17.42 83.74,17.52 83.74,21.04 83.58,21.2 83.58,46.91 83.48,47.01 82.45,47.01 82.35,47.1 82.35,49.38
  BOTTOM w0.076: v2(86.78,59.95) 86.52,59.69 UC1.BG11
  BOTTOM w0.107: JDIMM1.212 82.97,15.77 v2(84.48,17.28)
DDR_A_D49: length 50.8
  IN1 w0.076: 85.49,53.42 85.49,53.47 85.99,53.96 85.99,57.41 86.41,57.83 86.41,58.99 v2(86.78,59.36)
  IN1 w0.097: v2(84.48,18.8) 84.38,18.71 84.14,18.71 84.04,18.8 84.04,21.02 84.14,21.12 84.3,21.12 84.4,21.22 84.4,21.41 84.29,21.53 83.98,21.53 83.88,21.62 83.88,21.84 83.98,21.94 84.29,21.94 84.4,22.05 84.4,22.24 84.3,22.33 83.98,22.33 83.88,22.43 83.88,22.63 83.98,22.73 84.3,22.73 84.4,22.83 84.4,23.03 84.3,23.13 83.98,23.13 83.88,23.22 83.88,47.41 83.77,47.52 82.9,47.52 82.72,47.7 82.72,48.94 83.36,49.58 83.36,49.69 83.52,49.85 83.52,50.17 85.49,52.14 85.49,52.27 85.5,52.27 85.5,52.65 85.49,52.65 85.49,53.42
  BOTTOM w0.076: UC1.BG10 86.45,59.04 v2(86.78,59.36)
  BOTTOM w0.107: JDIMM1.211 82.72,20.91 83.61,20.01 83.61,19.67 v2(84.48,18.8)
DDR_A_D50: length 49.3
  IN1 w0.076: 85.82,53.35 86.22,53.75 86.22,57.37 86.78,57.93 v2(86.78,58.06)
  IN1 w0.097: 85.82,53.35 85.8,53.33 85.8,52.01 83.83,50.04 83.83,49.73 83.66,49.57 83.66,49.45 83.02,48.81 83.02,48.16 83.33,47.85 83.87,47.85 84.2,47.52 84.2,30.46 84.28,30.38 84.59,30.38 84.69,30.28 84.69,30.08 84.59,29.98 84.28,29.98 84.18,29.88 84.18,29.68 84.28,29.58 84.59,29.58 84.69,29.49 84.69,29.29 84.59,29.19 84.28,29.19 84.18,29.09 84.18,28.89 84.28,28.79 84.59,28.79 84.69,28.69 84.69,28.49 84.59,28.4 84.28,28.4 84.18,28.3 84.18,28.1 84.28,28 84.59,28 84.69,27.9 84.69,27.7 84.59,27.6 84.28,27.6 84.18,27.5 84.18,27.31 84.28,27.21 84.59,27.21 84.69,27.11 84.69,26.91 84.59,26.81 84.28,26.81 84.18,26.71 84.18,26.51 84.28,26.41 84.59,26.41 84.69,26.32 84.69,26.12 84.59,26.02 84.28,26.02 84.18,25.92 84.18,25.72 84.28,25.62 84.59,25.62 84.69,25.52 84.69,25.33 84.59,25.23 84.28,25.23 84.18,25.13 84.18,24.93 84.28,24.83 84.56,24.83 84.68,24.71 84.68,24.55 84.56,24.43 84.28,24.43 84.18,24.33 84.18,23.59 84.28,23.49 84.61,23.49 84.7,23.39 84.7,21.07 84.47,20.84 v2(84.47,20.5)
  BOTTOM w0.076: v2(86.78,58.06) 86.45,57.74 UC1.BG8
  BOTTOM w0.107: v2(84.47,20.5) 83.72,21.25 JDIMM1.215
DDR_A_D51: length 50
  IN1 w0.076: v2(87.69,58.07) 87.69,57.95 88.07,57.57 88.07,56.72 88.51,56.28 88.51,55.93 88.34,55.75
  IN1 w0.097: 88.15,55.56 88,55.41 88,51.19 87.96,51.15 87.96,51.14 86.78,49.97 86.78,49.93 86.56,49.7 86.56,49.39 86.38,49.21 86.38,48.82 86.28,48.72 86.28,32.44 87.64,31.07 87.64,28.75 87.54,28.65 87.41,28.65 87.31,28.55 87.31,28.35 87.41,28.25 87.54,28.25 87.64,28.15 87.64,27.96 87.54,27.86 87.2,27.86 87.1,27.76 87.1,27.56 87.2,27.46 87.54,27.46 87.64,27.36 87.64,27.16 87.54,27.06 87.2,27.06 87.1,26.96 87.1,26.77 87.2,26.67 87.54,26.67 87.64,26.57 87.64,26.37 87.54,26.27 87.2,26.27 87.1,26.17 87.1,25.97 87.2,25.87 87.54,25.87 87.64,25.78 87.64,25.58 87.54,25.48 87.2,25.48 87.1,25.38 87.1,25.18 87.2,25.08 87.54,25.08 87.64,24.98 87.64,24.79 87.54,24.69 87.2,24.69 87.1,24.59 87.1,24.39 87.2,24.29 87.54,24.29 87.64,24.19 87.64,23.99 87.54,23.89 87.2,23.89 87.1,23.79 87.1,23.6 87.2,23.5 87.54,23.5 87.64,23.4 87.64,23.2 87.54,23.1 87.2,23.1 87.1,23 87.1,22.8 87.2,22.71 87.54,22.71 87.64,22.61 87.64,22.41 87.54,22.31 87.2,22.31 87.1,22.21 87.1,22.01 87.2,21.91 87.54,21.91 87.64,21.81 87.64,21.62 87.54,21.52 87.2,21.52 87.1,21.42 87.1,21.22 87.2,21.12 87.54,21.12 87.64,21.02 v2(87.64,20.55)
  IN1 w0.099: 88.15,55.56 88.34,55.75
  BOTTOM w0.076: UC1.BF8 87.35,57.74 v2(87.69,58.07)
  BOTTOM w0.107: v2(87.64,20.55) 87.64,20.91 87.22,21.33 JDIMM1.229
DDR_A_D52: length 51.5
  IN1 w0.076: v2(87.69,59.95) 88.08,59.56 88.08,59.3 88.22,59.16 88.22,57.98 88.52,57.68 88.52,56.87 88.9,56.49 88.9,55.52 88.59,55.22 88.59,51.26 88.88,50.97 88.88,50.34 87.36,48.82 87.27,48.82 86.98,48.53
  IN1 w0.097: 86.98,48.53 86.93,48.48 86.93,32.68 88.35,31.26 88.35,16.38 88.26,16.29 87.77,16.29 87.68,16.19 87.68,16 87.77,15.9 88.46,15.9 88.57,15.79 88.57,15.59 88.48,15.49 87.42,15.49 v2(87.29,15.63)
  BOTTOM w0.076: v2(87.69,59.95) 87.43,59.69 UC1.BF11
  BOTTOM w0.107: v2(87.29,15.63) 86.97,15.31 JDIMM1.228
DDR_A_D53: length 51.5
  IN1 w0.076: v2(87.69,59.36) 88.06,59 88.06,57.85 88.28,57.64 88.28,56.83 88.7,56.4 88.7,55.68 88.53,55.51
  IN1 w0.097: 88.53,55.51 88.31,55.28 88.31,51.06 87.6,50.34 87.33,50.06 87.11,49.83 86.86,49.57 86.86,49.26 86.68,49.09 86.68,48.66 86.63,48.61 86.63,32.56 88.05,31.14 88.05,16.98 87.95,16.88 86.7,16.88 86.61,16.97 86.61,17.21 86.72,17.32 87.56,17.32 v2(87.61,17.28)
  BOTTOM w0.076: v2(87.69,59.36) 87.37,59.04 UC1.BF10
  BOTTOM w0.107: v2(87.61,17.28) 86.31,15.98 86.31,15.19 85.97,14.85 JDIMM1.224
DDR_A_D54: length 48.9
  IN1 w0.076: 86.13,53.24 86.41,53.52 86.41,57.04 v2(86.78,57.41)
  IN1 w0.097: v2(84.53,15.68) 84.53,15.87 84.63,15.97 85.56,15.97 85.67,16.08 85.67,16.27 85.57,16.37 85.14,16.37 85.04,16.47 85.04,16.67 85.14,16.77 85.59,16.77 85.7,16.88 85.7,17.07 85.61,17.16 85.14,17.16 85.04,17.26 85.04,17.46 85.14,17.56 85.51,17.56 85.64,17.69 85.64,17.89 85.51,18.02 85.1,18.02 84.91,18.22 84.91,20.78 85,20.87 85,31.49 84.51,31.97 84.51,49.58 84.73,49.8 84.73,50.52 86.13,51.92 86.13,53.24
  BOTTOM w0.076: v2(86.78,57.41) 86.45,57.09 UC1.BG7
  BOTTOM w0.107: v2(84.53,15.68) 83.97,15.12 JDIMM1.216
DDR_A_D55: length 50.1
  IN1 w0.097: v2(87.69,57.41) 87.69,55.64 87.7,55.63 87.7,51.32 86.48,50.1 86.48,50.06 86.25,49.83 86.25,49.51 86.08,49.34 86.08,48.94 85.98,48.84 85.98,32.26 86.77,31.46 86.77,31.15 86.87,31.05 87.17,31.05 87.27,30.95 87.27,30.75 87.17,30.65 86.43,30.65 86.34,30.56 86.34,30.35 86.44,30.25 87.18,30.25 87.28,30.15 87.28,29.95 87.18,29.85 86.42,29.85 86.31,29.75 86.31,29.56 86.42,29.45 87.18,29.45 87.28,29.35 87.28,29.16 87.18,29.06 86.42,29.06 86.31,28.96 86.31,28.77 86.42,28.67 86.85,28.67 86.95,28.57 86.95,28.31 86.85,28.21 86.31,28.21 86.23,28.13 86.23,25.96 86.78,25.41 86.78,19.84 v2(87.59,19.03)
  BOTTOM w0.076: v2(87.69,57.41) 87.37,57.09 UC1.BF7
  BOTTOM w0.107: JDIMM1.225 86.22,21.01 86.76,20.47 86.76,19.86 v2(87.59,19.03)
DDR_A_D56: length 50.6
  IN1 w0.076: v2(90.43,59.95) 90.92,59.46 90.92,59.11 91.79,58.24 91.79,49.02 90.7,47.93
  IN1 w0.097: 90.7,47.9 90.7,34.28 93.43,31.55 93.43,16.79 93.33,16.69 93.17,16.69 93.07,16.79 93.07,17.13 92.98,17.23 v2(92.85,17.23)
  IN1 w0.099: 90.7,47.93 90.7,47.9
  BOTTOM w0.076: v2(90.43,59.95) 90.18,59.69 UC1.BB11
  BOTTOM w0.107: JDIMM1.246 91.47,15.85 v2(92.85,17.23)
DDR_A_D57: length 50.1
  IN1 w0.076: v2(89.52,59.95) 88.97,59.4 88.97,57.99 88.74,57.76 88.74,56.93 89.09,56.58 89.09,55.26 88.92,55.09 88.92,51.51 89.18,51.26 89.18,50.16 87.44,48.43 87.44,48.21
  IN1 w0.097: 87.44,48.21 87.44,32.89 88.86,31.47 88.86,28.59 88.96,28.49 89.07,28.49 89.16,28.4 89.16,28.2 89.07,28.11 88.96,28.11 88.86,28.01 88.86,27.82 88.96,27.72 89.07,27.72 89.16,27.63 89.16,27.43 89.07,27.34 88.96,27.34 88.86,27.24 88.86,27.05 88.96,26.95 89.07,26.95 89.16,26.85 89.16,26.66 89.07,26.56 88.96,26.56 88.86,26.47 88.86,16.21 89.06,16.01 89.06,15.91 89.27,15.7 v2(89.47,15.7)
  BOTTOM w0.076: v2(89.52,59.95) 89.26,59.69 UC1.BC11
  BOTTOM w0.107: v2(89.47,15.7) 89.47,15.72 88.97,15.22 JDIMM1.236
DDR_A_D58: length 49.4
  IN1 w0.076: 90.08,47.9 90.08,48.16 91.19,49.27 91.19,51.67 91.21,51.69 91.21,57.29 v2(90.43,58.06)
  IN1 w0.097: 90.08,47.9 90.08,33.68 92.72,31.04 92.72,29.42 92.62,29.32 92.31,29.32 92.21,29.22 92.21,29.03 92.31,28.93 92.62,28.93 92.72,28.83 92.72,28.63 92.62,28.53 92.31,28.53 92.21,28.43 92.21,28.23 92.31,28.13 92.62,28.13 92.72,28.04 92.72,27.84 92.62,27.74 92.31,27.74 92.21,27.64 92.21,27.44 92.31,27.34 92.62,27.34 92.72,27.24 92.72,27.05 92.62,26.95 92.31,26.95 92.21,26.85 92.21,26.65 92.31,26.55 92.62,26.55 92.72,26.45 92.72,26.25 92.62,26.15 92.31,26.15 92.21,26.05 92.21,25.86 92.31,25.76 92.62,25.76 92.72,25.66 92.72,25.46 92.62,25.36 92.31,25.36 92.21,25.26 92.21,25.06 92.31,24.96 92.62,24.96 92.72,24.87 92.72,24.67 92.62,24.57 92.31,24.57 92.21,24.47 92.21,24.27 92.31,24.17 92.62,24.17 92.72,24.07 92.72,23.88 92.62,23.78 92.31,23.78 92.21,23.68 92.21,23.48 92.31,23.38 92.62,23.38 92.72,23.28 92.72,23.08 92.62,22.98 92.54,22.98 92.44,22.88 92.44,22.69 92.54,22.59 92.62,22.59 92.72,22.49 92.72,22.29 92.62,22.19 92.56,22.19 92.44,22.06 92.44,20.32 v2(92.56,20.2)
  BOTTOM w0.076: UC1.BB8 90.11,57.74 v2(90.43,58.06)
  BOTTOM w0.107: JDIMM1.249 92.22,20.54 v2(92.56,20.2)
DDR_A_D59: length 48.8
  IN1 w0.076: v2(89.52,58.06) 89.52,57.91 89.16,57.56 89.16,57.07 89.48,56.76 89.48,55.07 89.4,54.99 89.4,51.84 89.68,51.57 89.68,49.96 88.22,48.5 88.22,48.21
  IN1 w0.097: v2(89.6,20.5) 89.6,22.2 89.7,22.3 89.9,22.3 90,22.4 90,22.6 89.9,22.7 89.7,22.7 89.6,22.8 89.6,23.08 89.7,23.18 90.25,23.18 90.35,23.28 90.35,24.05 90.25,24.14 89.87,24.14 89.77,24.24 89.77,24.44 89.87,24.54 90.25,24.54 90.35,24.64 90.35,24.84 90.25,24.94 89.87,24.94 89.77,25.04 89.77,25.23 89.87,25.33 90.25,25.33 90.35,25.43 90.35,25.63 90.25,25.73 89.87,25.73 89.77,25.83 89.77,26.03 89.87,26.13 90.25,26.13 90.35,26.22 90.35,26.42 90.25,26.52 89.87,26.52 89.77,26.62 89.77,26.82 89.87,26.92 90.25,26.92 90.35,27.02 90.35,27.22 90.25,27.31 89.87,27.31 89.77,27.41 89.77,27.61 89.87,27.71 90.25,27.71 90.35,27.81 90.35,28.01 90.25,28.11 89.87,28.11 89.77,28.21 89.77,28.41 89.87,28.51 90.25,28.51 90.35,28.61 90.35,30.84 88.22,32.97 88.22,48.21
  BOTTOM w0.076: v2(89.52,58.06) 89.19,57.74 UC1.BC8
  BOTTOM w0.107: v2(89.6,20.5) 89.22,20.88 JDIMM1.237
DDR_A_D60: length 49.2
  IN1 w0.076: v2(89.52,59.36) 89.15,58.99 89.15,57.86 88.97,57.68 88.97,56.97 89.28,56.66 89.28,55.17 89.18,55.07 89.18,51.64 89.38,51.44 89.38,50.01 87.74,48.37 87.74,48.21
  IN1 w0.097: 87.74,48.21 87.74,33.02 89.18,31.58 89.18,31.16 89.28,31.06 89.68,31.06 89.79,30.96 89.79,30.77 89.68,30.67 89.48,30.67 89.39,30.57 89.39,30.36 89.49,30.26 89.9,30.26 90,30.16 90,29.97 89.9,29.86 89.54,29.86 89.44,29.76 89.44,29.57 89.54,29.47 89.9,29.47 90,29.37 90,29.12 89.9,29.02 89.57,29.02 89.46,28.92 89.46,23.38 89.19,23.11 89.19,19.13 v2(89.33,18.98)
  BOTTOM w0.076: v2(89.52,59.36) 89.19,59.04 UC1.BC10
  BOTTOM w0.107: v2(89.33,18.98) 88.54,19.77 88.54,21.16 88.22,21.48 JDIMM1.233
DDR_A_D61: length 50.7
  IN1 w0.076: v2(90.43,59.36) 90.88,58.92 90.88,57.96 91.49,57.35 91.49,49.15 90.4,48.05 90.4,47.9
  IN1 w0.097: 90.4,47.9 90.4,33.83 93.12,31.1 93.12,21.25 93.03,21.16 92.83,21.16 92.74,21.06 92.74,20.87 92.83,20.77 93.03,20.77 93.12,20.68 93.12,17.93 92.83,17.63 92.53,17.63 92.43,17.73 92.43,18.47 v2(92.58,18.63)
  BOTTOM w0.076: v2(90.43,59.36) 90.11,59.04 UC1.BB10
  BOTTOM w0.107: JDIMM1.245 91.22,19.99 v2(92.58,18.63)
DDR_A_D62: length 47.5
  IN1 w0.076: 88.56,48.21 88.56,48.48 89.96,49.89 89.96,51.79 90.27,52.09 90.27,56.27 89.52,57.02 v2(89.52,57.41)
  IN1 w0.097: 88.56,48.21 88.56,33.06 90.66,30.96 90.66,20.6 90.33,20.27 90.33,17.41 90.23,17.31 v2(89.34,17.31)
  BOTTOM w0.076: v2(89.52,57.41) 89.19,57.09 UC1.BC7
  BOTTOM w0.107: v2(89.34,17.31) 89.34,17.33 88.24,16.23 88.24,15.32 87.97,15.05 JDIMM1.232
DDR_A_D63: length 49.1
  IN1 w0.076: v2(90.43,57.41) 91,56.84 91,51.81 90.89,51.69 90.89,49.4 89.78,48.29 89.78,47.9
  IN1 w0.097: v2(92.8,15.7) 92.31,16.2 91.5,16.2 91.39,16.3 91.39,16.53 91.5,16.63 92.03,16.63 92.13,16.73 92.13,23.1 91.85,23.38 91.85,29.65 91.95,29.75 92.29,29.75 92.39,29.85 92.39,30.05 92.29,30.14 91.95,30.14 91.85,30.24 91.85,30.46 91.94,30.55 92.28,30.55 92.38,30.65 92.38,30.85 92.28,30.95 91.94,30.95 91.87,31.02 91.87,31.46 89.78,33.55 89.78,47.9
  BOTTOM w0.076: UC1.BB7 90.11,57.09 v2(90.43,57.41)
  BOTTOM w0.107: v2(92.8,15.7) 92.47,15.37 JDIMM1.250
DDR_A_DQS0: length 80.5
  IN3 w0.076: 77.01,53.61 77.03,53.61 77.04,53.62 77.45,53.62 78.44,54.62 78.7,54.62 78.78,54.54 v2(78.78,54.35)
  IN3 w0.089: 77.01,53.61 75.63,53.61 72.34,56.89 66.86,56.89 60.64,50.67 59.62,50.67 49.61,40.67 48.62,40.67 46.07,38.12 45.16,38.12 30.43,23.38 30.43,23.1 30.22,22.89 30,22.89 29.91,22.8 29.91,22.54 30,22.45 30.91,22.45 31.13,22.23 31.13,21.83 30.91,21.61 30,21.61 29.91,21.52 29.91,21.26 30,21.17 30.22,21.17 30.43,20.96 30.43,19.57 30.43,19.33 30.15,19.06 29.89,19.06 v2(29.67,18.84)
  BOTTOM w0.076: v2(78.78,54.35) 78.78,54.56 78.61,54.74 78.61,55.02 78.93,55.35 79.32,55.35 79.66,55.68 80.67,55.68 80.85,55.86 81.32,55.86 UC1.BP5
  BOTTOM w0.089: v2(29.67,18.84) 29.81,18.98 30.12,18.98 30.54,19.39 30.54,20.56 31.02,21.04 31.02,21.27 31.22,21.48 JDIMM1.13
DDR_A_DQS1: length 75.2
  IN3 w0.076: 78.7,48.67 78.76,48.73 78.76,48.75 79.53,49.52 79.53,49.72 79.53,49.73 79.53,49.99 79.99,50.45 80.18,50.45 80.21,50.42 v2(80.21,50.12)
  IN3 w0.089: v2(35.23,17.28) 35.62,17.68 35.77,17.68 36.11,18.02 36.11,19.12 35.78,19.46 35.78,21.77 36.75,22.75 36.75,23.83 49.65,36.73 50.62,36.73 61.06,47.17 77.19,47.17 78.63,48.61 78.65,48.61 78.7,48.67
  BOTTOM w0.076: v2(80.21,50.12) 80.43,50.12 80.59,49.96 81.05,49.96 82.98,51.89 83.33,51.89 84.44,53 84.44,53.35 84.08,53.71 84.08,54.17 UC1.BK3
  BOTTOM w0.089: v2(35.23,17.28) 34.92,17.59 34.81,17.59 34.62,17.4 34.62,16.59 35.13,16.08 35.71,16.08 36.15,15.64 36.15,15.31 36.47,14.99 JDIMM1.34
DDR_A_DQS2: length 52.9
  IN1 w0.076: v2(81.37,59.22) 81.39,59.25 81.49,59.25 81.7,59.45 81.7,59.6 81.46,59.83 80.58,59.83 79.78,59.03 79.1,59.03 78.95,58.88 78.95,58.43 78,57.48 78,57.46 77.99,57.44
  IN1 w0.089: 77.99,57.44 77.82,57.28 77.68,57.28 74.95,54.55 74.95,43.11 74.22,42.38 74.22,20.88 74.31,20.79 74.58,20.79 74.79,20.58 74.79,20.17 74.58,19.96 74.31,19.96 74.18,19.83 74.18,19.33 74.36,19.15 75.28,19.15 75.38,19.25 75.38,19.47 v2(75.28,19.57)
  BOTTOM w0.076: v2(81.37,59.22) 81.41,59.22 81.66,58.97 UC1.BP9
  BOTTOM w0.089: JDIMM1.179 74.72,21.39 74.4,21.07 74.4,20.9 74.75,20.55 74.75,19.23 74.83,19.15 75.36,19.15 75.43,19.23 75.43,19.42 v2(75.28,19.57)
DDR_A_DQS3: length 51.1
  IN1 w0.089: v2(80.57,16.42) 80.57,16.85 80.73,17 81.11,17 81.47,17.37 81.47,18.24 80.99,18.72 80.99,26.18 78.58,28.6 78.58,49.79 82.57,53.78 82.57,55.7 83.07,56.2 83.42,56.2 83.47,56.25 83.47,56.25 83.69,56.47
  IN1 w0.091: 83.69,56.47 83.75,56.53 83.75,56.53 83.89,56.67 83.89,58.51 v2(84.1,58.71)
  BOTTOM w0.076: UC1.BJ9 84.42,58.39 v2(84.1,58.71)
  BOTTOM w0.089: v2(80.57,16.42) 80.57,16.88 80.51,16.94 80.11,16.94 79.9,16.74 79.9,15.87 79.78,15.75 79.78,15.24 79.97,15.04 JDIMM1.200
DDR_A_DQS4: length 72.2
  IN3 w0.076: v2(83.71,48.9) 83.71,49.1 83.55,49.26 83.33,49.26 83.05,48.98 83.05,48.04 83.06,48.02 83.06,48.01
  IN3 w0.089: v2(40.39,18.33) 40.39,18.46 40.54,18.61 41.11,18.61 41.44,18.94 41.44,19.84 41.21,20.08 41.08,20.08 40.78,20.38 40.78,20.57 43.18,22.97 43.18,24.18 62.65,43.66 79.01,43.66 83.06,47.71 83.06,48.01
  BOTTOM w0.076: v2(83.71,48.9) 83.98,48.9 84.09,48.79 84.37,48.79 84.98,49.4 84.98,49.61 84.98,49.96 86.65,51.62 86.65,52.95 86.57,53.03 86.57,53.98 86.64,54.05 86.64,54.26 UC1.BF3
  BOTTOM w0.089: JDIMM1.55 41.72,21.33 41.56,21.18 41.56,20.43 41.38,20.24 41.38,18.77 41.13,18.53 40.59,18.53 v2(40.39,18.33)
DDR_A_DQS5: length 71
  IN3 w0.089: v2(87.65,49.7) 87.94,49.7 88.04,49.6 88.04,49.38 87.52,48.86 87.11,48.46 87.11,47.09 80.37,40.36 64.57,40.36 50.5,26.28 49.98,26.28 48.29,24.59 48.29,24.01 48.29,23.34 46.26,21.31 46.26,19.19 46.41,19.04 46.41,17.74 46.06,17.39 45.9,17.39 45.75,17.54 45.75,17.82 v2(45.78,17.86)
  BOTTOM w0.076: v2(87.65,49.7) 87.82,49.7 88.02,49.5 88.34,49.5 89.08,50.25 89.08,54.2 UC1.BC3
  BOTTOM w0.089: JDIMM1.76 46.97,15.23 46.86,15.34 46.86,17.05 46.26,17.66 45.99,17.66 v2(45.78,17.86)
DDR_A_DQS6: length 49.9
  IN1 w0.076: v2(87.67,58.71) 87.31,58.71 87.14,58.55 87.14,58.45 87.31,58.28 87.31,56.74 86.85,56.28 86.85,53.27 86.87,53.26 86.87,53.24
  IN1 w0.089: v2(86.07,19.23) 86.07,18.99 85.93,18.85 85.74,18.85 85.61,18.98 85.61,20.32 85.82,20.52 86.03,20.52 86.24,20.73 86.24,21.16 86.03,21.36 85.82,21.36 85.73,21.45 85.73,21.71 85.82,21.8 86.03,21.8 86.24,22.01 86.24,22.44 86.03,22.64 85.82,22.64 85.73,22.73 85.73,23.11 85.82,23.2 86.03,23.2 86.24,23.4 86.24,23.83 86.03,24.04 85.82,24.04 85.73,24.12 85.73,24.48 85.82,24.57 86.06,24.57 86.26,24.77 86.26,25.2 86.06,25.41 85.82,25.41 85.73,25.49 85.73,31.77 85.26,32.24 85.26,49.34 85.42,49.51 85.42,50.22 86.87,51.67 86.87,53.24
  BOTTOM w0.076: UC1.BF9 87.34,58.39 v2(87.67,58.71)
  BOTTOM w0.089: v2(86.07,19.23) 86.07,19.02 85.87,18.81 85.58,18.81 85.22,19.17 JDIMM1.221
DDR_A_DQS7: length 49.5
  IN1 w0.076: v2(90.43,58.71) 90.06,58.34 90.06,57.18 90.72,56.52 90.72,51.94 90.51,51.72 90.51,49.64 89.24,48.37 89.24,48.24 89.25,48.23 89.25,48.21
  IN1 w0.089: 89.25,48.21 89.25,33.35 91.35,31.25 91.35,23.03 91.62,22.77 91.62,19.94 91.42,19.73 91.12,19.73 91.03,19.64 91.03,19.38 91.12,19.29 91.42,19.29 91.62,19.09 91.62,17.49 91.42,17.29 91.23,17.29 v2(90.93,16.99)
  BOTTOM w0.076: UC1.BB9 90.3,58.71 v2(90.43,58.71)
  BOTTOM w0.089: JDIMM1.242 90.47,15.16 90.33,15.3 90.33,17.18 90.47,17.32 90.6,17.32 v2(90.93,16.99)
DDR_A_DQS#0: length 80.5
  IN3 w0.076: v2(79.14,54.81) 79.11,54.78 78.38,54.78 77.38,53.79 77.04,53.79 77.03,53.8 77.01,53.8
  IN3 w0.089: v2(29.67,19.6) 29.67,19.42 29.84,19.25 30.07,19.25 30.23,19.41 30.23,19.49 30.23,19.49 30.23,20.88 30.14,20.97 29.92,20.97 29.71,21.18 29.71,21.6 29.92,21.81 30.83,21.81 30.93,21.91 30.93,22.15 30.83,22.25 29.92,22.25 29.71,22.46 29.71,22.88 29.92,23.09 30.14,23.09 30.23,23.18 30.23,23.46 45.08,38.31 45.99,38.31 48.54,40.86 49.53,40.86 59.53,50.86 60.56,50.86 66.78,57.08 72.43,57.08 75.71,53.8 77.01,53.8
  BOTTOM w0.076: UC1.BR5 81.25,55.34 81.33,55.42 81.33,55.61 81.26,55.69 80.92,55.69 80.74,55.52 79.73,55.52 79.39,55.18 79,55.18 78.77,54.95 78.77,54.81 78.85,54.73 79.06,54.73 v2(79.14,54.81)
  BOTTOM w0.089: v2(29.67,19.6) 29.67,19.45 29.92,19.2 30.09,19.2 30.36,19.47 30.36,20.63 30.84,21.11 30.84,21.28 30.72,21.4 JDIMM1.11
DDR_A_DQS#1: length 75.2
  IN3 w0.076: v2(80.65,50.57) 80.33,50.57 80.29,50.62 79.92,50.62 79.37,50.06 79.37,49.66 79.37,49.59 78.59,48.81 78.56,48.81
  IN3 w0.089: v2(35.23,18.1) 35.46,17.87 35.69,17.87 35.92,18.1 35.92,19.04 35.58,19.38 35.58,21.85 36.56,22.83 36.56,23.91 49.57,36.92 50.54,36.92 60.98,47.37 77.1,47.37 78.55,48.81 78.56,48.81
  BOTTOM w0.076: UC1.BL3 83.67,54.48 83.92,54.23 83.92,53.64 84.28,53.29 84.28,53.07 83.27,52.06 82.91,52.06 80.98,50.13 80.65,50.13 80.6,50.18 80.6,50.51 v2(80.65,50.57)
  BOTTOM w0.089: JDIMM1.32 35.97,15.56 35.63,15.9 35.05,15.9 34.44,16.51 34.44,17.47 34.74,17.77 34.91,17.77 v2(35.23,18.1)
DDR_A_DQS#2: length 52.9
  IN1 w0.076: 77.85,57.58 77.86,57.59 77.88,57.59 78.79,58.5 78.79,58.95 79.03,59.19 79.71,59.19 80.51,59.99 81.53,59.99 81.86,59.66 81.86,59.35 v2(81.98,59.23)
  IN1 w0.089: v2(75.28,18.75) 75.13,18.9 75.07,18.96 74.28,18.96 73.99,19.25 73.99,19.91 74.23,20.15 74.49,20.15 74.6,20.25 74.6,20.5 74.49,20.6 74.23,20.6 74.03,20.8 74.03,42.46 74.76,43.19 74.76,54.63 77.6,57.47 77.74,57.47 77.85,57.58
  BOTTOM w0.076: v2(81.98,59.23) 82.31,58.91 UC1.BN9
  BOTTOM w0.089: v2(75.28,18.75) 75.05,18.97 74.75,18.97 74.57,19.15 74.57,20.47 74.22,20.82 JDIMM1.177
DDR_A_DQS#3: length 51.2
  IN1 w0.089: 83.54,56.6 83.71,56.77 ; v2(80.53,17.35) 80.69,17.2 81.02,17.2 81.28,17.45 81.28,18.16 80.8,18.64 80.8,26.1 78.38,28.52 78.38,49.87 82.38,53.86 82.38,55.79 83,56.41 83.01,56.4 83.34,56.4 83.39,56.44 83.39,56.45
  IN1 w0.091: 83.39,56.45 83.54,56.6 83.54,56.6 ; v2(84.06,59.36) 83.71,59.02 83.71,56.77
  BOTTOM w0.076: UC1.BL9 83.61,58.91 v2(84.06,59.36)
  BOTTOM w0.089: JDIMM1.198 79.47,15.04 79.6,15.17 79.6,15.82 79.72,15.95 79.72,16.81 80.03,17.12 80.3,17.12 v2(80.53,17.35)
DDR_A_DQS#4: length 72.2
  IN3 w0.076: v2(84.07,49.4) 83.95,49.28 83.77,49.28 83.62,49.43 83.26,49.43 82.88,49.05 82.88,48.04 82.87,48.02 82.87,48.01
  IN3 w0.089: 82.87,48.01 82.87,47.79 78.93,43.85 62.57,43.85 42.98,24.26 42.98,23.05 40.59,20.65 40.59,20.3 41,19.88 41.13,19.88 41.25,19.76 41.25,19.02 41.03,18.8 40.68,18.8 40.54,18.94 40.39,19.09 v2(40.39,19.13)
  BOTTOM w0.076: v2(84.07,49.4) 84.07,49.05 84.16,48.96 84.31,48.96 84.82,49.47 84.82,49.54 84.82,50.03 86.48,51.69 86.48,52.88 86.4,52.96 86.4,54.05 86.47,54.11 86.47,54.37 86.36,54.48 UC1.BG3
  BOTTOM w0.089: v2(40.39,19.13) 40.39,18.88 40.56,18.71 41.06,18.71 41.19,18.85 41.19,20.32 41.38,20.5 41.38,21.12 41.22,21.28 JDIMM1.53
DDR_A_DQS#5: length 71
  IN3 w0.089: v2(88.09,50.14) 88.09,49.83 88.24,49.68 88.24,49.3 87.6,48.67 87.31,48.38 87.31,47.01 80.46,40.16 64.65,40.16 50.58,26.09 50.06,26.09 48.48,24.51 48.48,24.09 48.48,23.26 46.45,21.23 46.45,19.27 46.61,19.12 46.61,17.66 46.13,17.19 46.01,17.19 v2(45.8,16.98)
  BOTTOM w0.076: v2(88.09,50.14) 88.04,50.1 88.04,49.71 88.09,49.67 88.27,49.67 88.92,50.32 88.92,54.31 88.75,54.48 UC1.BD3
  BOTTOM w0.089: JDIMM1.74 46.47,15.13 46.68,15.34 46.68,16.97 46.18,17.47 45.91,17.47 45.8,17.36 v2(45.8,16.98)
DDR_A_DQS#6: length 49.9
  IN1 w0.076: 86.67,53.24 86.67,53.26 86.69,53.27 86.69,56.34 87.15,56.8 87.15,58.21 86.98,58.38 86.98,58.51 v2(86.78,58.71)
  IN1 w0.089: 86.67,53.24 86.67,51.75 85.23,50.3 85.23,49.59 85.06,49.42 85.06,32.16 85.53,31.68 85.53,25.41 85.74,25.21 85.98,25.21 86.07,25.12 86.07,24.85 85.98,24.77 85.74,24.77 85.53,24.56 85.53,24.04 85.74,23.84 85.95,23.84 86.04,23.75 86.04,23.48 85.95,23.4 85.74,23.4 85.53,23.19 85.53,22.65 85.74,22.44 85.95,22.44 86.04,22.35 86.04,22.09 85.95,22 85.74,22 85.53,21.8 85.53,21.37 85.74,21.16 85.95,21.16 86.04,21.07 86.04,20.81 85.95,20.72 85.74,20.72 85.42,20.4 85.42,18.9 85.65,18.66 85.83,18.66 v2(86.07,18.42)
  BOTTOM w0.076: v2(86.78,58.71) 86.45,58.39 UC1.BG9
  BOTTOM w0.089: JDIMM1.219 84.72,21.19 85.04,20.87 85.04,19.09 85.5,18.63 85.86,18.63 v2(86.07,18.42)
DDR_A_DQS#7: length 49.5
  IN1 w0.076: v2(89.52,58.71) 89.59,58.71 89.9,58.41 89.9,57.11 90.56,56.45 90.56,52.01 90.34,51.79 90.34,49.71 89.07,48.44 89.07,48.24 89.06,48.23 89.06,48.21
  IN1 w0.089: v2(90.87,17.76) 91.15,17.48 91.34,17.48 91.42,17.57 91.42,19 91.34,19.09 91.04,19.09 90.84,19.3 90.84,19.73 91.04,19.93 91.34,19.93 91.42,20.02 91.42,22.68 91.16,22.95 91.16,31.17 89.06,33.27 89.06,48.21
  BOTTOM w0.076: v2(89.52,58.71) 89.39,58.71 UC1.BC9
  BOTTOM w0.089: v2(90.87,17.76) 90.87,17.78 90.59,17.5 90.39,17.5 90.14,17.24 90.14,15.32 89.97,15.15 JDIMM1.240
DDR_A_MA0: length 70.1
  IN3 w0.076: 100.57,44.07 100.57,46.67 100.12,47.11 100.1,47.11 99.89,47.32 99.89,48.4 v2(100.31,48.82)
  IN3 w0.152: v2(66.17,17.75) 66.17,17.64 65.27,16.74 64.84,16.74 64.28,17.3 64.28,18.69 65.05,19.46 65.05,21.73 65.6,22.29 65.6,23.83 69.66,27.89 86.06,27.89 100.57,42.4 100.57,44.07
  BOTTOM w0.076: v2(100.31,48.82) 100.68,49.19 100.68,49.96 101.19,50.47 101.19,51.65 101.48,51.94 101.48,54.2 UC1.AH3
  BOTTOM w0.168: v2(66.17,17.75) 66.17,17.66 65.1,16.59 65.1,16.08 63.97,14.95 JDIMM1.144
DDR_A_MA1: length 68.8
  IN3 w0.152: v2(60.86,21.02) 60.86,21.56 61.73,22.43 61.73,24.65 68.29,31.21 83.43,31.21 96.48,44.26 96.48,50.84 96.26,51.05 95.85,51.05 95.7,51.21 95.7,51.51 95.85,51.66 96.26,51.66 96.41,51.82 96.41,52.12 96.26,52.27 95.87,52.27 95.71,52.43 95.71,52.72 95.88,52.88 96.26,52.88 96.41,53.04 96.41,53.34 96.26,53.49 94.81,53.49 94.66,53.34 94.66,52.55 94.51,52.4 94.01,52.4 93.85,52.56 93.85,53.87 94.08,54.1 96.26,54.1 96.41,54.26 96.41,54.71 96.26,54.86 v2(95.78,54.86)
  BOTTOM w0.076: UC1.AP4 96.04,55.13 v2(95.78,54.86)
  BOTTOM w0.168: JDIMM1.133 61.22,21.38 v2(60.86,21.02)
DDR_A_MA2: length 68.5
  IN3 w0.152: v2(97.4,54.8) 97.33,54.73 97.33,51.24 97.39,51.18 97.39,43.88 83.81,30.29 68.67,30.29 63.2,24.83 63.2,23.28 62.65,22.73 62.65,22.05 61.79,21.2 61.79,19.66 61.06,18.92 61.06,15.67 61.21,15.52 61.43,15.52 61.58,15.67 61.58,16.4 61.73,16.55 v2(62.04,16.55)
  BOTTOM w0.076: UC1.AN4 97.08,55.13 v2(97.4,54.8)
  BOTTOM w0.168: JDIMM1.132 60.97,15.48 v2(62.04,16.55)
DDR_A_MA3: length 67.4
  IN3 w0.152: v2(60.77,19.48) 61.34,20.05 61.34,21.39 62.19,22.24 62.19,24.46 68.48,30.75 83.62,30.75 96.94,44.07 96.94,51.01 96.87,51.07 96.87,55.9 96.67,56.11 95.12,56.11 95.01,56 95.01,55.64 95.16,55.5 v2(95.78,55.5)
  BOTTOM w0.076: v2(95.78,55.5) 96.06,55.78 UC1.AP5
  BOTTOM w0.168: JDIMM1.131 60.72,21.53 60.02,20.83 60.02,20.24 v2(60.77,19.48)
DDR_A_MA4: length 68.3
  IN3 w0.152: v2(60.52,16.41) 60.25,16.41 60.04,16.2 60.04,15.62 59.91,15.49 58.97,15.49 58.78,15.68 58.78,16.4 59.46,17.07 59.46,19.64 59.8,19.98 59.8,24.01 67.91,32.12 83.05,32.12 95.56,44.64 95.56,48.28 94.8,49.05 94.8,50.63 95.12,50.95 v2(95.28,50.95)
  BOTTOM w0.076: UC1.AP2 95.89,53.55 95.89,51.56 v2(95.28,50.95)
  BOTTOM w0.168: v2(60.52,16.41) 59.97,15.86 JDIMM1.128
DDR_A_MA5: length 68.7
  IN3 w0.152: v2(95.29,50.31) 95.29,50.32 95.57,50.6 95.87,50.6 96.02,50.44 96.02,49.67 95.54,49.19 95.54,48.96 96.02,48.47 96.02,44.45 83.24,31.66 68.1,31.66 61.28,24.84 61.28,24.28 61.08,24.08 60.52,24.08 60.25,23.82 60.25,23.26 60.41,23.11 61.12,23.11 61.28,22.95 61.28,22.67 61.1,22.5 60.41,22.5 60.25,22.34 60.25,19.79 59.91,19.45 59.91,17.6 59.99,17.53 60.26,17.53 60.5,17.77 v2(60.5,17.96)
  BOTTOM w0.076: UC1.AP1 96.17,51.19 v2(95.29,50.31)
  BOTTOM w0.168: JDIMM1.126 59.47,17.53 59.9,17.96 v2(60.5,17.96)
DDR_A_MA6: length 69.1
  IN3 w0.152: v2(58.06,18.68) 58.47,18.27 58.47,17.42 58.63,17.27 58.85,17.27 59,17.42 59,18.92 58.85,19.07 58.62,19.07 58.47,19.22 58.47,19.53 58.62,19.68 58.85,19.68 59.34,20.17 59.34,24.19 67.72,32.58 82.86,32.58 95.11,44.83 95.11,48.09 v2(94.31,48.89)
  BOTTOM w0.076: UC1.AP3 95.65,53.96 95.65,52.48 94.75,51.57 94.75,49.34 v2(94.31,48.89)
  BOTTOM w0.168: JDIMM1.127 59.72,21.17 59.15,20.6 59.15,19.78 v2(58.06,18.68)
DDR_A_MA7: length 69.2
  IN3 w0.152: v2(58.06,17.12) 58.06,17.01 57.76,16.72 57.57,16.72 57.43,16.86 57.43,17.16 57.25,17.33 56.89,17.33 56.71,17.51 56.71,17.67 57.03,17.98 57.47,17.98 57.62,18.14 57.62,19.27 57.45,19.45 57.45,20.56 57.6,20.71 57.93,20.71 58.09,20.86 58.09,21.17 57.93,21.32 57.6,21.32 57.45,21.47 57.45,21.78 57.6,21.93 57.76,21.93 57.91,22.08 57.91,22.39 57.76,22.54 57.6,22.54 57.45,22.69 57.45,23.07 57.27,23.24 57.27,24.08 66.69,33.49 82.48,33.49 94.19,45.21 94.19,46.21 v2(94.13,46.28)
  BOTTOM w0.076: 97.18,50.98 97.18,52.9 UC1.AN1
  BOTTOM w0.168: JDIMM1.122 58.47,15.09 58.52,15.13 58.52,16.65 v2(58.06,17.12) ; 97.18,50.98 97.18,49.29 94.17,46.28 v2(94.13,46.28)
DDR_A_MA8: length 70.6
  IN3 w0.152: v2(58.02,20.21) 58.54,20.21 58.75,20.41 58.75,20.63 58.54,20.83 58.54,21.23 58.65,21.33 58.76,21.33 58.88,21.45 58.88,21.7 58.73,21.85 58.52,21.85 58.37,22 58.37,22.31 58.52,22.46 58.73,22.46 58.88,22.61 58.88,22.84 58.73,23 58.31,23 58.16,23.15 58.16,23.45 58.31,23.6 58.73,23.6 58.88,23.76 58.88,24.07 58.49,24.46 58.49,24.65 58.69,24.85 58.91,24.85 59.02,24.74 59.23,24.74 59.45,24.96 59.45,25.17 59.34,25.28 59.34,25.5 59.55,25.71 59.77,25.71 59.88,25.6 60.09,25.6 60.31,25.82 60.31,26.04 60.2,26.14 60.2,26.36 60.42,26.58 60.63,26.58 60.74,26.47 60.96,26.47 61.17,26.68 61.17,26.9 61.06,27.01 61.06,27.22 61.28,27.44 61.49,27.44 61.6,27.33 61.82,27.33 62.03,27.55 62.03,27.76 61.93,27.87 61.93,28.08 62.14,28.3 62.36,28.3 62.47,28.19 62.68,28.19 62.9,28.41 62.9,28.62 62.79,28.73 62.79,28.95 63,29.16 63.22,29.16 63.33,29.05 63.54,29.05 63.76,29.27 63.76,29.49 63.65,29.59 63.65,29.81 63.87,30.03 64.08,30.03 64.19,29.92 64.41,29.92 64.62,30.13 64.62,30.35 64.51,30.46 64.51,30.67 64.73,30.89 64.95,30.89 65.05,30.78 65.27,30.78 65.49,31 65.49,31.21 65.38,31.32 65.38,31.54 65.59,31.75 65.81,31.75 65.92,31.64 66.13,31.64 66.35,31.86 66.35,32.07 66.24,32.18 66.24,32.4 66.45,32.61 66.67,32.61 66.78,32.5 66.99,32.5 67.53,33.04 82.67,33.04 94.65,45.02 94.65,47.9 94.45,48.11 v2(94.18,48.11)
  BOTTOM w0.076: 96.14,50.57 96.46,50.89 96.46,54.03 UC1.AN3
  BOTTOM w0.168: JDIMM1.125 59.22,21.41 v2(58.02,20.21) ; v2(94.18,48.11) 94.48,48.41 94.65,48.41 96.14,49.91 96.14,50.57
DDR_A_MA9: length 69.5
  IN3 w0.152: v2(56.04,18.38) 56.53,18.88 56.53,22.69 56.36,22.86 56.36,24.08 56.36,24.08 56.36,24.46 66.31,34.41 82.1,34.41 93.21,45.52 93.21,46.69 93.65,47.13 93.65,50.79 94.04,51.18 94.04,52.03 93.34,52.73 93.34,55.22 93.49,55.37 94.29,55.37 v2(94.86,54.8)
  BOTTOM w0.076: v2(94.86,54.8) 94.54,55.13 UC1.AT4
  BOTTOM w0.168: v2(56.04,18.38) 56.82,19.16 56.82,19.99 58.22,21.39 JDIMM1.121
DDR_A_MA10: length 70.3
  IN3 w0.076: v2(100.31,50.66) 100.31,50.8 100.53,51.02 100.58,51.02
  IN3 w0.152: 100.58,51.02 100.77,51.21 101.13,51.21 101.29,51.04 101.29,50.68 101.14,50.53 100.95,50.53 100.8,50.38 100.8,50.08 100.95,49.92 101.14,49.92 101.29,49.77 101.29,45.09 101.94,44.44 101.94,40.96 87.51,26.52 70.23,26.52 67.66,23.95 67.66,22.41 66.92,21.67 66.92,16.48 67.33,16.07 67.33,15.72 67.08,15.47 66.87,15.47 v2(66.11,16.23)
  BOTTOM w0.076: v2(100.31,50.66) 100.68,51.03 100.68,51.95 100.92,52.18 100.92,53.55 UC1.AH2
  BOTTOM w0.168: JDIMM1.146 66.47,14.89 66.8,15.21 66.8,15.87 66.44,16.23 v2(66.11,16.23)
DDR_A_MA11: length 70.3
  IN3 w0.152: v2(58.08,15.57) 57.93,15.42 57.2,15.42 56.92,15.7 56.92,16.66 56.69,16.89 55.88,16.89 55.55,16.56 55.27,16.56 55.09,16.74 55.09,17.35 55.65,17.91 56.31,17.91 56.99,18.59 56.99,22.88 56.82,23.05 56.82,24.27 66.5,33.95 82.29,33.95 93.67,45.33 93.67,46.51 94.06,46.9 v2(94.11,46.9)
  BOTTOM w0.076: 96.69,50.57 96.69,50.67 96.77,50.75 96.77,52.86 96.63,53 96.63,53.55 UC1.AN2
  BOTTOM w0.168: v2(58.08,15.57) 57.97,15.46 JDIMM1.120 ; v2(94.11,46.9) 94.13,46.9 96.69,49.47 96.69,50.57
DDR_A_MA12: length 70.4
  IN3 w0.076: v2(93.01,52.52) 93.65,51.87 93.65,51.26 93.35,50.95 93.35,47.56 93.13,47.33
  IN3 w0.152: 93.13,47.33 92.76,46.96 92.76,45.71 81.91,34.86 66.12,34.86 55.48,24.22 55.48,23.84 55.48,23.24 55.38,23.14 54.89,23.14 54.77,23.02 54.77,22.57 54.89,22.45 55.95,22.45 56.08,22.32 56.08,21.96 55.95,21.84 54.92,21.84 54.77,21.68 54.77,21.38 54.92,21.23 55.9,21.23 56.05,21.07 56.05,20.77 55.9,20.62 54.92,20.62 54.77,20.47 54.77,20.17 55.28,19.66 55.65,19.66 55.9,19.91 56.02,19.91 v2(56.04,19.93)
  BOTTOM w0.076: UC1.AU4 93.16,54.63 93.16,52.68 v2(93.01,52.52)
  BOTTOM w0.168: JDIMM1.119 57.72,21.43 56.22,19.93 v2(56.04,19.93)
DDR_A_MA13: length 73.6
  IN3 w0.076: v2(102.84,50.75) 103.78,49.81 103.78,47.14 106.73,44.19 106.73,44.07
  IN3 w0.152: v2(71.88,16.61) 71.88,17.22 73.25,18.59 73.5,18.59 73.88,18.97 73.88,20.37 74.62,21.11 93.44,21.11 98.85,26.51 98.85,26.73 98.47,27.11 98.47,27.33 98.69,27.54 98.9,27.54 99.28,27.16 99.5,27.16 99.71,27.38 99.71,27.59 99.33,27.97 99.33,28.19 99.55,28.4 99.76,28.4 100.14,28.02 100.36,28.02 100.58,28.24 100.58,28.45 100.19,28.84 100.19,29.05 100.41,29.27 100.63,29.27 101.01,28.89 101.22,28.89 106.73,34.39 106.73,44.07
  BOTTOM w0.076: v2(102.84,50.75) 104.01,51.92 104.01,54.18 UC1.AE3
  BOTTOM w0.168: JDIMM1.158 69.47,14.84 69.85,15.21 70.48,15.21 v2(71.88,16.61)
DDR_A_MA14: length 70.8
  IN3 w0.076: 102.85,44.41 102.85,44.69 101.73,45.81 101.73,54.69 v2(102.39,55.35)
  IN3 w0.152: v2(67.95,19.88) 67.95,21.4 69.06,22.51 69.06,23.93 70.74,25.61 88.88,25.61 96.48,33.21 96.48,33.42 96.37,33.53 96.37,33.75 96.58,33.96 96.8,33.96 96.91,33.85 97.12,33.85 97.39,34.12 97.39,34.34 97.25,34.48 97.25,34.7 97.47,34.91 97.68,34.91 97.82,34.77 98.04,34.77 98.26,34.99 98.26,35.2 97.99,35.47 97.99,35.68 98.2,35.9 98.42,35.9 98.69,35.63 98.9,35.63 99.12,35.85 99.12,36.06 98.85,36.33 98.85,36.55 99.07,36.76 99.28,36.76 99.55,36.5 99.76,36.5 99.98,36.71 99.98,36.93 99.71,37.19 99.71,37.41 99.93,37.63 100.14,37.63 100.41,37.36 100.63,37.36 100.84,37.57 100.84,37.79 100.58,38.06 100.58,38.27 100.79,38.49 101.01,38.49 101.27,38.22 101.49,38.22 101.71,38.44 101.71,38.65 101.44,38.92 101.44,39.14 101.65,39.35 101.87,39.35 102.14,39.08 102.35,39.08 102.57,39.3 102.57,39.52 102.3,39.78 102.3,40 102.85,40.55 102.85,44.41
  BOTTOM w0.076: v2(102.39,55.35) 102.16,55.13 UC1.AG4
  BOTTOM w0.168: JDIMM1.151 67.72,20.11 v2(67.95,19.88)
DDR_A_MA15: length 72.8
  IN3 w0.076: v2(102.83,48.92) 103.5,48.25 103.5,46.94 106.27,44.17 106.27,44.07
  IN3 w0.152: v2(70.38,16.74) 72.82,19.18 72.82,21.41 72.98,21.56 92.06,21.56 100.57,30.07 100.78,30.07 101.16,29.69 101.38,29.69 101.59,29.9 101.59,30.12 101.21,30.5 101.21,30.71 101.43,30.93 101.64,30.93 102.02,30.55 102.24,30.55 102.45,30.77 102.45,30.98 102.07,31.36 102.07,31.58 102.29,31.79 102.51,31.79 102.89,31.41 103.1,31.41 103.32,31.63 103.32,31.84 102.94,32.22 102.94,32.44 103.14,32.64 103.39,32.64 103.75,32.28 103.97,32.28 106.27,34.58 106.27,44.07
  BOTTOM w0.076: v2(102.83,48.92) 104.48,50.56 104.48,53.15 UC1.AD1
  BOTTOM w0.168: JDIMM1.156 68.97,14.85 69.69,15.57 69.69,16.05 v2(70.38,16.74)
DDR_A_MA16: length 70
  IN3 w0.076: 103.31,44.41 103.31,44.67 101.91,46.06 101.91,54.2 v2(102.38,54.66)
  IN3 w0.152: v2(67.87,18.08) 68.39,17.56 68.6,17.56 68.87,17.83 68.87,18.05 68.4,18.51 68.4,21.21 69.52,22.32 69.52,23.72 70.94,25.15 89.11,25.15 103.31,39.36 103.31,44.41
  BOTTOM w0.076: UC1.AH4 101.55,54.77 102.27,54.77 v2(102.38,54.66)
  BOTTOM w0.168: v2(67.87,18.08) 68.42,17.52 68.42,15.47 67.97,15.01 JDIMM1.152
DDR_A_ODT0: length 80.3
  IN3 w0.076: 104.55,44.41 104.55,44.53 102.89,46.19 102.77,46.19 102.28,46.68 102.28,48.34 102.44,48.5 102.44,49.7 v2(102.86,50.12)
  IN3 w0.152: 104.55,44.41 104.55,38.84 96.04,30.33 96.04,30.11 96.73,29.43 96.73,29.21 96.51,29 96.3,29 95.61,29.68 95.4,29.68 95.15,29.43 95.15,29.22 96.12,28.25 96.12,28.03 95.89,27.8 95.68,27.8 94.71,28.78 94.49,28.78 94.27,28.56 94.27,28.34 95.25,27.37 95.25,27.16 95.03,26.94 94.82,26.94 93.84,27.91 93.63,27.91 93.41,27.7 93.41,27.48 94.38,26.51 94.38,26.29 92.11,24.02 91.28,24.02 91.12,23.87 91.12,23.43 90.96,23.27 90.67,23.27 90.51,23.42 90.51,23.87 90.36,24.02 89.74,24.02 89.62,23.91 89.15,23.91 89,23.75 89,23.52 88.87,23.39 88.54,23.39 88.39,23.55 88.39,23.75 88.24,23.91 87.93,23.91 87.78,23.75 87.78,23.55 87.63,23.39 87.32,23.39 87.17,23.55 87.17,23.75 87.02,23.91 86.72,23.91 86.56,23.75 86.56,23.55 86.41,23.39 72.38,23.39 69.21,20.22 69.21,18.82 v2(69.72,18.31)
  BOTTOM w0.076: UC1.AD3 104.17,54.2 104.17,52.96 104.31,52.82 104.31,51.57 v2(102.86,50.12)
  BOTTOM w0.168: v2(69.72,18.31) 68.72,19.31 JDIMM1.155
DDR_A_ODT1: length 80.4
  IN3 w0.076: 105.48,44.41 105.48,44.55 102.87,47.17 v2(102.84,47.17)
  IN3 w0.152: v2(71.27,19.05) 71.85,19.63 71.85,21.55 72.65,22.35 91.73,22.35 102.86,33.48 102.86,33.69 101.89,34.67 101.89,34.88 102.11,35.1 102.32,35.1 103.88,33.54 104.11,33.54 104.32,33.75 104.32,33.96 102.75,35.53 102.75,35.74 102.97,35.96 103.18,35.96 104.73,34.41 104.99,34.41 105.18,34.61 105.18,34.82 103.62,36.39 103.62,36.61 103.83,36.82 104.05,36.82 105.06,35.81 105.27,35.81 105.48,36.02 105.48,36.25 104.48,37.25 104.48,37.47 105.48,38.47 105.48,44.41
  BOTTOM w0.076: UC1.AE4 103.25,54.66 103.25,52.58 102.21,51.54 102.21,49.66 102.21,47.79 v2(102.84,47.17)
  BOTTOM w0.168: v2(71.27,19.05) 70.22,20.1 JDIMM1.161
DDR_A_PAR: length 69.6
  IN3 w0.076: 101.02,44.07 101.02,44.29 100.79,44.52 100.79,47.71 v2(100.31,48.18)
  IN3 w0.152: v2(66.25,19.45) 66.25,19.19 65.48,18.41 65.48,17.6 65.32,17.45 64.96,17.45 64.8,17.6 64.8,18.53 65.5,19.23 65.5,21.54 66.06,22.1 66.06,23.64 69.85,27.44 86.25,27.44 101.02,42.21 101.02,44.07
  BOTTOM w0.076: v2(100.31,48.18) 100.99,48.86 100.99,49.78 101.46,50.25 101.46,51.6 101.66,51.8 101.66,54.2 UC1.AG3
  BOTTOM w0.168: v2(66.25,19.45) 65.72,19.45 63.72,21.44 JDIMM1.143
DDR_B_ACT#: length 78.1
  IN1 w0.076: 95.02,47.43 95.02,47.8 94.9,47.92 94.9,50.8 94.46,51.24 94.46,55.55 95.38,56.47 95.38,58.34 v2(95.01,58.71)
  IN1 w0.152: v2(136.08,16.57) 135.33,17.32 135.33,19.73 132.37,22.69 113.78,22.69 113.25,23.21 107.01,23.21 95.02,35.21 95.02,47.43
  BOTTOM w0.076: UC1.AT9 94.68,58.39 v2(95.01,58.71)
  BOTTOM w0.168: JDIMM2.114 137.47,15.18 v2(136.08,16.57)
DDR_B_ALERT#: length 88.5
  IN1 w0.076: 91.64,47.75 92.58,48.69 92.58,53.06 92.81,53.29 92.81,58.63 93.95,59.77 94.53,59.77 94.59,59.71 95.13,59.71 95.53,59.32 95.53,58.47 95.92,58.08 v2(95.92,58.06)
  IN1 w0.152: v2(137.59,15.87) 136.6,14.88 132.63,14.88 131.82,14.07 109.61,14.07 105.61,18.06 105.61,18.92 94.19,30.34 94.19,31.87 91.64,34.42 91.64,47.75
  BOTTOM w0.076: UC1.AR8 v2(95.92,58.06)
  BOTTOM w0.168: JDIMM2.116 137.97,15.11 137.59,15.49 v2(137.59,15.87)
DDR_B_BA0: length 79.7
  IN1 w0.076: v2(101.41,58.06) 101.41,57.92 101.76,57.57 101.76,57.19 101.62,57.05 101.62,54.31 101.69,54.25 101.69,54.24 102.44,53.5 102.44,46.41 102.73,46.12 102.83,46.12 104.27,44.67 104.27,44.6
  IN1 w0.152: v2(148.14,15.69) 147.84,15.69 146.79,16.73 146.79,17.8 146.78,17.81 146.78,18.28 146.94,18.43 147.01,18.43 147.16,18.59 147.16,18.89 147.01,19.04 146.94,19.04 146.78,19.2 146.78,19.5 146.94,19.65 147.01,19.65 147.16,19.8 147.16,20.11 147.01,20.26 146.94,20.26 146.78,20.41 146.78,24.72 138.7,32.8 113.91,32.8 104.27,42.44 104.27,44.6
  BOTTOM w0.076: UC1.AH8 v2(101.41,58.06)
  BOTTOM w0.168: v2(148.14,15.69) 148.47,15.36 JDIMM2.150
DDR_B_BA1: length 81.8
  IN1 w0.076: 103.36,44.6 103.36,44.77 102.03,46.1 102.03,53.33 101.27,54.09 101.27,56.64 101.04,56.87 101.04,57.31 100.86,57.49 100.86,57.75 101.04,57.92 101.04,58.42 100.96,58.5 100.78,58.5 100.49,58.21 v2(100.49,58.03)
  IN1 w0.152: 103.36,44.6 103.36,42.06 103.74,41.68 103.74,41.46 103.52,41.25 103.52,41.03 103.73,40.81 103.95,40.81 104.17,41.03 104.38,41.03 104.6,40.82 104.6,40.6 104.38,40.38 104.38,40.17 104.6,39.95 104.81,39.95 105.03,40.17 105.25,40.17 105.46,39.95 105.46,39.74 105.24,39.52 105.24,39.3 105.46,39.09 105.67,39.09 105.89,39.31 106.11,39.31 106.32,39.09 106.32,38.88 106.1,38.66 106.1,38.44 106.32,38.23 106.54,38.23 106.76,38.45 106.97,38.45 107.19,38.23 107.19,38.01 106.97,37.79 106.97,37.58 107.18,37.36 107.4,37.36 107.62,37.58 107.83,37.58 108.07,37.34 108.07,37.13 107.85,36.91 107.85,36.69 108.07,36.48 108.28,36.48 108.5,36.7 108.72,36.7 108.94,36.48 108.94,36.27 108.72,36.05 108.72,35.83 108.93,35.62 109.15,35.62 109.37,35.83 109.58,35.83 113.53,31.89 138.32,31.89 145.67,24.54 145.67,21.15 145.83,20.99 v2(145.89,20.99)
  BOTTOM w0.076: UC1.AH9 100.85,58.39 v2(100.49,58.03)
  BOTTOM w0.168: JDIMM2.145 147.22,20.6 147.05,20.43 146.66,20.43 146.5,20.59 146.5,20.8 146.31,20.99 v2(145.89,20.99)
DDR_B_BG0: length 79.2
  IN1 w0.076: 93.67,47.24 93.67,48.13 93.93,48.39 93.93,56.34 95.02,57.43 v2(95.02,58.07)
  IN1 w0.152: 93.67,47.24 93.67,35.26 106.63,22.3 112.87,22.3 113.4,21.77 131.3,21.77 132.26,20.81 132.26,18.76 132.56,18.47 133.32,18.47 134.07,17.72 v2(134.51,17.72)
  BOTTOM w0.076: v2(95.02,58.07) 95.34,58.39 UC1.AR9
  BOTTOM w0.168: JDIMM2.115 137.72,21.45 135.48,19.21 135.48,18.69 v2(134.51,17.72)
DDR_B_BG1: length 79.1
  IN1 w0.076: v2(95.01,56.85) 94.2,56.05 94.2,51.03 94.66,50.57 94.66,47.62 94.56,47.52 94.56,47.43
  IN1 w0.152: v2(134.68,19.25) 134.4,19.25 134.25,19.1 134.25,19.01 134.13,18.9 133.9,18.9 133.75,19.05 133.75,19.32 133.55,19.52 132.87,19.52 132.72,19.67 132.72,20.01 132.87,20.16 133.34,20.16 133.49,20.31 133.49,20.62 133.34,20.77 132.87,20.77 132.72,20.92 132.72,21.2 132.86,21.34 132.86,21.56 132.69,21.73 132.47,21.73 132.35,21.61 132.11,21.61 131.91,21.81 131.91,22.03 131.71,22.23 113.59,22.23 113.06,22.76 106.82,22.76 94.56,35.02 94.56,35.66 94.41,35.82 94.28,35.82 94.13,35.97 94.13,36.27 94.28,36.43 94.41,36.43 94.56,36.58 94.56,36.88 94.41,37.03 94.28,37.03 94.13,37.19 94.13,37.49 94.28,37.64 94.41,37.64 94.56,37.8 94.56,38.1 94.41,38.25 94.28,38.25 94.13,38.41 94.13,38.71 94.28,38.86 94.41,38.86 94.56,39.02 94.56,39.32 94.41,39.47 94.28,39.47 94.13,39.63 94.13,39.93 94.28,40.08 94.41,40.08 94.56,40.24 94.56,47.43
  BOTTOM w0.076: UC1.AR7 95.24,57.09 v2(95.01,56.85)
  BOTTOM w0.168: v2(134.68,19.25) 136.3,20.88 136.6,20.88 137.22,21.5 JDIMM2.113
DDR_B_CKE0: length 90.7
  IN1 w0.076: v2(94.14,57.34) 93.42,56.62 93.42,48.72 92.88,48.18 92.69,48.18 92.43,47.92 92.43,47.73
  IN1 w0.152: v2(132.84,17.22) 131.7,17.22 131.54,17.07 131.54,16.79 131.7,16.64 132.66,16.64 132.81,16.48 132.81,16.19 132.65,16.03 131.7,16.03 131.54,15.87 131.54,15.05 131.39,14.9 109.89,14.9 106.4,18.39 106.4,19.24 98.3,27.34 98.3,27.56 98.85,28.1 98.85,28.32 98.63,28.54 98.42,28.54 97.87,27.99 97.65,27.99 96.7,28.94 96.7,29.16 97.25,29.7 97.25,29.92 97.03,30.14 96.82,30.14 96.27,29.59 96.05,29.59 95.84,29.8 95.84,30.02 96.39,30.57 96.39,30.78 96.17,31 95.96,31 95.41,30.45 95.19,30.45 94.97,30.67 94.97,30.93 95.5,31.46 95.5,31.67 92.43,34.74 92.43,47.73
  BOTTOM w0.076: v2(94.14,57.34) 94.15,57.34 UC1.AT8
  BOTTOM w0.168: v2(132.84,17.22) 132.84,18.16 136.22,21.54 JDIMM2.109
DDR_B_CKE1: length 89.2
  IN1 w0.076: v2(95.03,59.31) 94.64,59.31 94.56,59.24 94.56,57.25 93.7,56.39 93.7,48.54 92.88,47.73
  IN1 w0.152: 92.88,47.73 92.88,34.93 99.63,28.19 99.63,27.97 99.08,27.42 99.08,27.21 99.3,26.99 99.51,26.99 100.06,27.54 100.28,27.54 100.49,27.32 100.49,27.11 99.94,26.56 99.94,26.34 100.16,26.13 100.37,26.13 100.92,26.68 101.14,26.68 101.35,26.46 101.35,26.25 100.81,25.7 100.81,25.48 101.02,25.27 101.24,25.27 101.79,25.82 102,25.82 102.22,25.6 102.22,25.38 101.67,24.84 101.67,24.62 101.88,24.4 102.1,24.4 102.65,24.95 102.86,24.95 103.17,24.65 103.17,24.17 103.44,23.9 103.92,23.9 106.31,21.51 112.55,21.51 113.07,20.99 130.98,20.99 131.47,20.49 131.47,17.83 131.63,17.68 132.99,17.68 133.27,17.4 133.27,15.94 133.42,15.79 133.84,15.79 133.97,15.91 133.97,16.18 134.12,16.33 134.34,16.33 v2(134.49,16.18)
  BOTTOM w0.076: v2(95.03,59.31) 94.64,59.04 UC1.AT10
  BOTTOM w0.168: JDIMM2.110 136.47,14.86 136.11,15.21 135.99,15.21 135.02,16.18 v2(134.49,16.18)
DDR_B_CLK0: length 85.3
  IN1 w0.076: 100.8,44.98 100.8,45.19 100.76,45.24 100.76,52.78 100.17,53.36 100.17,55.74 99.4,56.52 98.71,56.52 98.14,57.09 98.14,58.21 98.08,58.27 97.93,58.27 v2(97.74,58.08)
  IN1 w0.089: 100.8,44.98 100.8,40.03 111.83,29 112.34,29 112.54,29.2 112.54,29.24 112.63,29.33 112.9,29.33 112.99,29.24 112.99,29.2 113.19,29 113.62,29 113.82,29.2 113.82,29.24 113.91,29.33 114.18,29.33 114.27,29.24 114.27,29.2 114.47,29 114.9,29 115.1,29.2 115.1,29.24 115.19,29.33 115.46,29.33 115.55,29.24 115.55,29.2 115.75,29 116.18,29 116.38,29.2 116.38,29.24 116.47,29.33 116.74,29.33 116.83,29.24 116.83,29.2 117.03,29 117.46,29 117.66,29.2 117.66,29.24 117.75,29.33 118.02,29.33 118.11,29.24 118.11,29.2 118.31,29 118.74,29 118.94,29.2 118.94,29.24 119.03,29.33 119.3,29.33 119.39,29.24 119.39,29.2 119.59,29 120.02,29 120.22,29.2 120.22,29.24 120.31,29.33 120.58,29.33 120.67,29.24 120.67,29.2 120.87,29 121.3,29 121.5,29.2 121.5,29.24 121.59,29.33 121.86,29.33 121.95,29.24 121.95,29.2 122.15,29 122.58,29 122.78,29.2 122.78,29.24 122.87,29.33 123.14,29.33 123.23,29.24 123.23,29.2 123.43,29 123.86,29 124.07,29.2 124.07,29.24 124.15,29.33 124.42,29.33 124.51,29.24 124.51,29.2 124.71,29 125.14,29 125.35,29.2 125.35,29.24 125.43,29.33 125.7,29.33 125.79,29.24 125.79,29.2 125.99,29 126.42,29 126.63,29.2 126.63,29.24 126.71,29.33 126.98,29.33 127.07,29.24 127.07,29.2 127.27,29 127.7,29 127.91,29.2 127.91,29.24 127.99,29.33 128.26,29.33 128.35,29.24 128.35,29.2 128.55,29 128.98,29 129.19,29.2 129.19,29.24 129.27,29.33 129.54,29.33 129.63,29.24 129.63,29.2 129.83,29 130.26,29 130.47,29.2 130.47,29.24 130.55,29.33 130.82,29.33 130.91,29.24 130.91,29.2 131.11,29 131.49,29 131.7,29.2 131.7,29.24 131.78,29.33 132.05,29.33 132.14,29.24 132.14,29.2 132.34,29 132.83,29 133.03,29.2 133.03,29.24 133.12,29.33 133.38,29.33 133.47,29.24 133.47,29.2 133.68,29 137.6,29 142.51,24.09 142.51,22.63 142.71,22.43 143.04,22.43 143.12,22.35 143.12,22.04 143.03,21.95 142.71,21.95 142.51,21.75 142.51,19.47 142.53,19.45 142.53,19.41 142.76,19.19 143.04,19.19 143.14,19.08 v2(143.14,18.9)
  BOTTOM w0.076: UC1.AM9 98.04,58.39 v2(97.74,58.08)
  BOTTOM w0.089: v2(143.14,18.9) 142.96,19.09 142.72,19.09 142.37,19.44 142.37,20.49 143.22,21.34 JDIMM2.137
