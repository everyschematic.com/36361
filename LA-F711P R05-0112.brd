# Allegro board LA-F711P R05-0112.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
MEM_INTERLEAVED: length 15.4
  TOP w0.089: 221.72,36.41 220.81,35.5 v1(220.81,35.32) 220.61,35.11 214.59,35.11 213.77,34.3 212.6,34.3 212.24,34.66 v2(212.24,34.73)
  TOP w0.102: 221.72,36.41 221.78,36.46 223.33,36.46 223.5,36.63 223.81,36.63 RH371.1 223.78,36.32 223.58,36.32 223.48,36.22 RH372.1
  BOTTOM w0.089: UH1.BA20 v2(212.24,34.73)
MEM_SMBCLK: length 45
  TOP w0.107: QH4.6 216.47,9.31 216.98,9.66 217.03,9.93 216.86,10.18 216.86,10.69 218.08,11.9 220.14,11.9 220.3,12.06 220.3,14.07 v1(221.01,14.78) 224.69,18.46 224.69,19.23 228.15,22.68 228.15,22.98 229.54,24.37 229.54,27.82 227.36,30.01 225.66,30.01 225.32,30.35 225.07,30.35 225.07,30.35 v2(225.07,30.34)
  BOTTOM w0.089: 221.6,31.27 221.56,31.22 221.56,31.21 221.39,31.04 218.51,31.04 218.35,31.2 215.02,31.2 214.86,31.03 214.52,31.03 214.46,31.09 UH1.BE26
  BOTTOM w0.102: 223.61,31.39 223.44,31.56 221.9,31.56 221.6,31.27
  BOTTOM w0.107: 223.61,31.39 223.81,31.39 224.74,30.46 224.95,30.46 v2(225.07,30.34) 225.16,30.44 226.1,30.44 RH56.2 226.31,30.23 CC320.1
MEM_SMBDATA: length 44
  TOP w0.107: v2(225.07,31.05) 225.28,30.84 225.52,30.84 225.86,30.49 227.56,30.49 230.03,28.03 230.03,24.17 228.63,22.78 228.63,22.48 225.18,19.02 225.18,18.26 v1(223.97,17.05) 220.79,13.86 220.79,11.86 220.34,11.42 218.28,11.42 217.35,10.48 217.35,10.33 217.43,10.21 217.58,10.18 QH4.3
  BOTTOM w0.089: UH1.BF26 214.81,31.25 214.81,31.25 214.93,31.38 218.44,31.38 218.6,31.22 221.29,31.22 221.47,31.4
  BOTTOM w0.102: 221.47,31.4 221.79,31.72
  BOTTOM w0.107: RH57.2 226.04,30.92 225.19,30.92 v2(225.07,31.05) 224.97,30.95 224.94,30.95 224.01,31.87 221.94,31.87 221.79,31.72
MSCLK: length 29.9
  TOP w0.104: UE1.H10 v2(321.32,34.35)
  IN1 w0.099: v2(321.32,34.35) 321.7,34.73 322.28,34.73 322.5,34.51 322.5,28.73 v2(321.81,28.04)
  BOTTOM w0.102: RE30.1 332.6,12.71 RE72.2 332.61,13.28 332.4,13.49 JDEG1.6 332.4,14.96 329.91,17.46 329.91,17.9 327,20.8 327,22.81 325.14,24.66 324.48,24.66 322.72,26.42 v1(322.72,27.09) 321.81,27.99 v2(321.81,28.04)
MSDATA: length 53.3
  TOP w0.104: UE1.G9 319.81,35.86 v2(319.72,35.86)
  IN1 w0.099: v2(318.97,22.24) 319.62,22.24 320.69,23.31 320.69,24.18 322.19,25.68 322.19,27.47 322.7,27.98 322.7,35.63 322.5,35.83 322.5,36.11 322.28,36.33 320.1,36.33 319.72,35.95 v2(319.72,35.86)
  BOTTOM w0.102: v2(318.97,22.24) 319.18,22.45 320.59,22.45 323.31,19.73 323.31,17.93 322.96,17.58 v1(322.96,13.19) 322.96,12.51 323.77,11.71 324.32,11.71 324.93,11.1 RE86.1 326.25,11.07 RE75.2 329.34,10.15 333.45,10.15 334.96,11.66 334.96,15.14 334.63,15.46 333.38,15.46 332.9,14.99 JDEG1.7
MUX1_DP_SEL: length 20.2
  TOP w0.102: v2(30.78,100.55) 30.78,101.18 30.02,101.94 v1(29.83,101.94) 29.49,101.94 27.96,103.47 27.29,103.47 25.9,104.86 25.64,104.86 25.45,104.67 24.43,104.67 23.58,105.52 23.57,105.52 23.55,105.55 23.54,105.55 21.43,107.66 20.56,107.66 20.43,107.53 v2(20.43,107.5)
  BOTTOM w0.102: RT89.1 27.8,98.51 27.99,98.7 29.64,98.7 30.15,99.21 30.15,99.91 v2(30.78,100.55) ; UT9.35 21.35,107.56 21.26,107.47 20.46,107.47 v2(20.43,107.5)
MUX1_FLIP_SEL: length 48.5
  TOP w0.102: v2(19.54,108.42) 19.73,108.42 20.02,108.13 20.02,108.12 20.24,107.91 21.51,107.91 23.64,105.78 23.64,105.78 23.67,105.75 26.34,105.75 27.03,105.05 27.03,104.36 27.54,103.85 27.99,103.85 29.54,102.29 30.18,102.29 31.23,101.24 v1(31.23,100.29) 31.23,100.16 31.54,99.85 32.62,99.85 33,99.47 v2(33,98.13)
  IN1 w0.099: v2(33,98.13) 33,98.01 32.37,97.37 29.07,97.37 28.05,98.39 25.76,98.39 v2(25.57,98.2)
  IN3 w0.102: v2(26.27,83.65) 26.34,83.72 26.4,83.72 26.59,83.91 26.59,84.68 25.14,86.13 25.14,88.62 22.88,90.88 22.88,95.17 23.52,95.81 24.96,95.81 25.7,96.54 25.7,98.13 25.64,98.2 v2(25.57,98.2)
  BOTTOM w0.102: RT69.2 27.1,84.48 v2(26.27,83.65) ; v2(19.54,108.42) 19.54,108.48 19.86,108.8 UT9.37
MUX1_FLIP_SEL_R: length 3.6
  BOTTOM w0.076: 29.61,84.78 29.82,84.78 30.48,85.45 30.48,85.45 30.62,85.59 30.62,85.59 30.63,85.6 30.63,85.92 30.88,86.18 UT5.B2
  BOTTOM w0.104: 29.61,84.78 29.43,84.78 v1(29.13,84.48) RT69.1
MUX1_USB_SEL: length 21
  TOP w0.102: v2(31.67,100.55) 31.67,101.24 30.65,102.26 30.65,103.47 30.21,103.91 v1(28.69,103.91) 28.2,104.39 28.2,104.39 27.96,104.63 27.96,105.14 27.3,105.8 RT308.1 27.02,106.01 23.73,106.01 21.45,108.29 20.45,108.29 v2(20.43,108.31)
  BOTTOM w0.102: RT90.1 28.69,98.2 28.94,98.45 29.83,98.45 30.46,99.08 30.46,99.66 30.97,100.16 31.16,100.16 31.54,100.55 v2(31.67,100.55) ; UT9.36 20.54,108.12 20.43,108.23 v2(20.43,108.31)
NB_MUTE#: length 39.9
  TOP w0.102: RA48.1 335.89,28.92 DA8.1 336.38,28.34 335.89,27.84 335.89,25.48 336.59,24.78 v2(336.7,24.78)
  TOP w0.104: UE1.A4 v2(316.12,41.05)
  IN2 w0.102: v2(336.7,24.78) 336.58,24.9 336.16,24.9 331.8,29.26 331.8,31.05 330.15,32.7 330.15,33.75 331.06,34.66 331.06,38.98 329.73,40.31 316.86,40.31 v2(316.12,41.05)
NB_PSID: length 11.4
  TOP w0.102: PD4.2 v1(61.15,124.12)
  TOP w0.508: PL3.2 65.35,124.72 PD4.3 ; v2(64.31,122.83) 64.75,123.27 PD4.3 ; PD4.3 PD4.2
  BOTTOM w0.508: PJPDC1.1 63.69,121.2 64.31,121.82 v2(64.31,122.83)
NGFF_CONFIG_0: length 53.9
  TOP w0.102: v2(321.02,25.16) 320.9,25.16 320.47,24.73 RPE9.3
  TOP w0.104: UE1.N9 319.96,30.59 319.96,29.53 319.24,28.8 v1(319.24,28.56) 319.32,28.47 319.32,26.58 319.37,26.53 319.37,26.5 319.71,26.16 320.26,26.16 320.57,25.85 320.78,25.85 320.91,25.72 320.91,25.26 v2(321.02,25.16)
  IN3 w0.102: v2(335.2,56.03) 335.61,55.63 335.61,54.97 335.23,54.59 335.23,53.67 334.87,53.32 334.87,49.69 330.9,45.72 330.9,39.4 328.89,37.39 328.89,35.09 328.42,34.62 328.42,33.88 327.79,33.25 326.86,33.25 324.25,30.63 324.25,29.07 321.28,26.09 321.28,25.54 321.02,25.28 v2(321.02,25.16)
  BOTTOM w0.102: v2(335.2,56.03) 335.05,55.88 330.2,55.88 329.65,55.33 JNGFF2.21
NGFF_CONFIG_1: length 76.9
  TOP w0.102: 321.47,24.54 321.47,24.71 321.66,24.9
  TOP w0.104: RPE9.1 321.47,24.54 ; 321.66,24.9 322.12,25.36 322.12,26.02 321.82,26.31 320.69,26.31 320.38,26.62 319.97,26.62 319.86,26.73 319.86,28.46 320.41,29.01 320.41,29.78 321.32,30.69 v2(321.32,31.15) UE1.M10
  TOP w0.254: v2(334.31,56.29) 334.46,56.13 334.46,55.45 334.97,54.94 334.97,53.83 335.67,53.14 343.68,53.14 344.59,54.05 v2(345.24,54.05) 346.15,53.14 346.45,53.14 348.09,51.5 351.24,51.5 351.56,51.18 354.73,51.18 355.74,50.16 358.41,50.16 UZ29.9
  IN3 w0.102: v2(334.31,56.29) 334.31,55.4 334.77,54.94 334.77,54.52 334.41,54.16 334.41,50.96 331.6,48.15 331.6,47.65 331.17,47.23 331.04,47.23 329.84,46.02 329.84,44.97 330.44,44.37 330.44,41.46 325.74,36.76 325.74,35.27 324.68,34.21 324.53,34.21 322.83,32.52 322.83,31.8 322.18,31.15 v2(321.32,31.15)
  BOTTOM w0.102: JNGFF2.69 341.65,52.41 341.92,52.15 345,52.15 345.24,52.38 v2(345.24,54.05)
NGFF_CONFIG_2: length 57.8
  TOP w0.102: RPE9.2 320.97,24.53 321.71,25.28 321.71,25.88
  TOP w0.104: 321.71,25.88 v2(321.71,25.88) 321.51,26.08 320.63,26.08 320.32,26.39 319.81,26.39 319.6,26.6 319.6,26.63 319.6,26.63 319.6,28.49 320.21,29.11 320.21,30.04 UE1.N10
  IN3 w0.102: v2(321.71,25.88) 324.91,29.08 324.91,30.9 327,32.98 327.97,32.98 328.66,33.66 328.66,34.54 329.12,35 329.12,37.3 331.71,39.89 331.71,41.22 331.13,41.81 331.13,45.63 335.1,49.6 335.1,52.41 336.98,54.29 336.98,57.12 v2(336.95,57.15)
  BOTTOM w0.102: JNGFF2.75 343.15,55.88 341.46,57.57 338.66,57.57 337.78,56.69 337.39,56.69 336.95,57.13 v2(336.95,57.15)
NGFF_CONFIG_3: length 38.8
  TOP w0.102: RPE9.4 319.97,24.74 319.93,24.77 319.43,24.77 319.22,24.98 319.22,25.64 v2(319.05,25.81)
  TOP w0.104: UE1.F4 v2(315.72,36.75)
  IN3 w0.102: v2(323.14,51.82) 323.14,51.57 319.08,47.51 319.08,43.25 317.89,42.07 317.89,41.8 316.14,40.05 316.14,37.26 315.95,37.07 315.95,36.98 v2(315.72,36.75) 315.46,36.75 315.08,36.37 314.8,36.37 313.34,34.9 313.34,31.66 317.14,27.86 317.14,26.72 317.67,26.19 317.67,25.96 317.9,25.74 318.97,25.74 v2(319.05,25.81)
  BOTTOM w0.102: JNGFF2.1 324.65,52.34 324.21,51.9 323.22,51.9 323.13,51.82 v2(323.14,51.82)
NRB_BIT: length 11.5
  BOTTOM w0.089: UH1.BE30 214.39,29.42 214.46,29.49 219.14,29.49 219.34,29.69 220.75,29.69 221.47,28.98 223.14,28.98 223.61,29.46
  BOTTOM w0.102: 223.61,29.46 223.77,29.62 RH331.2 224.06,30.45 v1(223.95,30.56)
NVME_LED#: length 15.5
  IN1 w0.099: v2(360.23,13.85) 360.24,13.85 360.24,13.84 359.51,13.1 359.51,4.52 358.69,3.71 358.69,3.43 358.3,3.04 v2(358.3,3.02)
  BOTTOM w0.102: v2(360.23,13.85) 360.24,13.85 360.24,13.33 v1(360.7,12.88) 361.18,12.39 RN100.1 ; v2(358.3,3.02) JNGFF3.10
ONE_DIMM#: length 10.8
  TOP w0.089: v2(222.42,29.56) 222.03,29.17 221.19,29.17 RH268.1 220.14,29.65 RH267.1
  BOTTOM w0.089: v2(222.42,29.56) 222.03,29.17 221.52,29.17 220.83,29.87 219.27,29.87 219.06,29.66 215.45,29.66 215.2,29.91 UH1.BF29
OTG_ID: length 8.1
  BOTTOM w0.076: 36.6,87.93 35.23,87.93 34.98,87.69 UT5.E10
  BOTTOM w0.102: v1(42.11,87.55) 41.84,87.29 40.79,87.29 40.23,87.85 RT74.1
  BOTTOM w0.104: RT74.1 39.54,87.85 39.06,87.37 37.36,87.37 36.79,87.93 36.6,87.93
OTGEN/CMIN: length 4.4
  TOP w0.203: PU901.20 10.01,36.42
  TOP w0.254: v2(9.74,37.41) 10.01,37.15 10.01,36.42
  BOTTOM w0.102: PR960.2 9.72,37.44 v2(9.74,37.41) 10.08,37.75 v1(10.08,38.04) 10.08,38.25 9.78,38.56 PR919.2
PANEL_BKEN_EC: length 266.6
  TOP w0.104: UE1.J9 v2(320.52,33.55)
  IN3 w0.102: v2(320.52,33.55) 320.52,33.6 320.94,34.02 320.94,34.51 321.37,34.93 323.13,34.93 324.82,36.62 324.82,37.13 328.8,41.11 328.8,48.14 329.15,48.5 329.15,55.72 327.78,57.09 327.78,57.76 v2(328.18,58.17)
  BOTTOM w0.102: DV2.2 135.35,92.87 137.9,90.31 145.08,90.31 145.76,89.64 156,89.64 163.97,81.66 172.65,81.66 172.86,81.86 174.53,81.86 179.49,76.91 v1(187.08,76.91) 198.98,76.91 206.66,69.23 206.66,66.51 206.03,65.88 205.76,65.88 205.39,65.51 205.39,64.23 213.31,56.31 221.2,56.31 236.07,41.44 238.19,41.44 242.47,37.16 248.2,37.16 250.07,35.29 280.73,35.29 284.57,39.14 284.57,44.93 290.71,51.07 302.71,51.07 303.59,50.2 311.75,50.2 313.62,52.07 314.38,52.07 318.72,56.41 320.26,56.41 320.59,56.08 324.17,56.08 324.48,56.39 326.41,56.39 v2(328.18,58.17)
PANEL_BKEN_PCH: length 131.5
  IN2 w0.102: v2(210.77,22.16) 210.68,22.25 210.68,23.34 209.38,24.64 209.38,27.17 209.26,27.3 207.5,27.3 207.31,27.11 206.36,27.11 206.19,27.28 200.46,27.28 200.43,27.32 200.34,27.32 200.13,27.53 197.06,27.53 196.19,26.66 195.02,26.66 194.41,27.27 191.77,27.27 189.78,29.26 185.85,29.26 185.44,29.67 182.94,29.67 173.27,39.33 173.27,58.43 172.07,59.64 v2(172.07,80.96)
  BOTTOM w0.089: UH1.AV46 210.75,22.06
  BOTTOM w0.102: 210.75,22.06 210.77,22.08 v2(210.77,22.16) ; DV2.3 137.29,90.08 144.99,90.08 145.66,89.41 155.44,89.41 v1(161.54,83.31) 163.54,81.3 171.73,81.3 v2(172.07,80.96)
PANEL_MONITOR: length 235.4
  TOP w0.104: v2(319.38,29.66) 319.74,30.02 319.74,31.13 UE1.M8
  IN2 w0.102: v2(178.11,81.07) 178.11,80.05 180.22,77.93 180.22,74.03 179.12,72.93 179.12,57.03 181.05,55.1 184.78,55.1 188.59,58.91 192.51,58.91 196.99,54.43 197.38,54.43 198.41,55.46 208.3,55.46 213.18,50.57 213.18,46.96 215.21,44.94 215.21,43.71 215.83,43.09 216.92,43.09 217.17,42.84 217.49,42.84 218.14,42.19 218.14,39.13 218.61,38.66 219.97,38.66 221.74,40.43 222.1,40.43 222.76,39.78 225.12,39.78 226.12,38.77 235.63,38.77 237.32,37.08 241.83,37.08 243.98,34.94 251.99,34.94 252.13,34.8 267.84,34.8 269.86,32.78 276.02,32.78 278,34.76 278,37.84 278.83,38.67 281.98,38.67 282.47,39.15 289.02,39.15 289.47,38.71 297.58,38.71 298.67,37.63 298.67,35.93 298.98,35.62 300.91,35.62 301.08,35.79 301.57,36.28 306.61,36.28 308.63,38.3 311.38,38.3 313.34,36.35 320.67,36.35 320.92,36.09 320.92,30.74 319.84,29.66 v2(319.38,29.66)
  BOTTOM w0.102: v2(178.11,81.07) v1(177.01,82.17) 176.1,83.08 170.12,83.08 156.62,96.58 RV628.2
PANEL_PWRGD: length 6.8
  BOTTOM w0.102: QV21.1 158.29,93.05 158.48,93.24 158.48,94.07 158.03,94.51 156.73,94.51 v1(155.92,95.32) 155.46,95.78 154.31,95.78 CV632.1
PBAT_CHARGER_SMBCLK: length 386.5
  TOP w0.107: v2(3.84,11.58) 3.84,11.46 4.24,11.07 PD2.3 4.94,11.5 5.03,11.59 6.51,11.59 6.51,11.59 PRP1.3 ; UE1.N2 314.46,30.69 314.46,30.33 313.45,29.32 313.45,29.22 311.52,27.3 311.45,27.3 311.17,27.3 310.98,27.08 310.98,27.08 RE43.1 310.64,27.03 310.41,26.8 310.41,26.79 310.12,26.5 307.4,26.5 306.54,27.36 306.54,28.24 306.22,28.57 306.22,28.84 v1(304.02,31.03) 303.03,32.03 302.35,32.03 v2(302.32,32.05)
  IN1 w0.099: v2(302.32,32.05) 302.28,32.05 302.27,32.04 301.89,32.04 301.64,31.79 298.72,31.79 297.36,30.43 296.04,30.43 295.45,31.02 288,31.02 287.43,30.46 279.98,30.46 278.87,31.57 278.87,34.97 278.07,35.77 269.53,35.77 268.23,37.07 262.82,37.07 262.42,36.67 254.92,36.67 247.05,38.96 244.78,38.96 242.92,40.81 242.8,40.81 233.28,47.21 223.45,57.05 216.6,57.05 211.61,62.04 188.94,62.04 187.77,60.87 186.42,60.87 184.64,59.09 v2(184.34,59.09) ; v2(3.84,11.58) 3.84,11.68 4.41,12.24 4.44,12.24 4.72,12.53 4.72,13.5 2.2,16.02 2.2,21.1 2.2,21.49 5.54,24.83 5.54,36.98 v2(8.77,40.21)
  BOTTOM w0.107: v2(184.34,59.09) 184.34,58.91 182.06,56.63 177.95,56.63 168.88,47.56 165.32,47.56 156.47,38.7 37.72,38.7 35.91,40.51 35.91,42.03 34.84,43.1 29.51,43.1 22.8,49.82 16.67,49.82 15.11,48.26 15.11,46.49 14.54,45.92 10.63,45.92 10.01,45.29 10.01,43.64 9.44,43.08 9.44,40.89 v2(8.77,40.21) 8.42,40.21 8.17,39.96 PR922.1
PBAT_CHARGER_SMBDAT: length 386.8
  TOP w0.107: v2(302.32,31.47) 302.32,31.51 302.35,31.54 302.82,31.54 305.73,28.63 305.73,28.37 306.05,28.04 306.05,27.15 307.2,26.01 310.18,26.01 RE37.1 310.64,25.95 311.37,26.79 311.39,26.81 311.65,26.81 311.73,26.81 313.94,29.02 313.94,29.12 314.95,30.13 314.95,31.18 UE1.M3 ; PRP1.2 6.51,12.09 6.51,12.08 5.42,12.08 5.4,12.1 PD1.2 4.81,12.1 4.43,11.72 v2(4.43,11.58) ; v2(9.48,40.18) 9.06,39.77 PR920.1
  IN1 w0.099: v2(4.43,11.58) 4.61,11.76 4.64,11.76 5.2,12.33 5.2,13.69 2.68,16.22 2.68,16.22 2.68,21.29 6.02,24.63 6.02,36.78 6.16,36.92 9.42,40.18 v2(9.48,40.18) ; v2(184.88,58.5) 184.88,58.65 186.62,60.39 187.97,60.39 189.14,61.56 211.41,61.56 216.4,56.57 223.25,56.57 232.97,46.84 242.86,40.2 244.58,38.48 246.98,38.48 254.85,36.19 262.62,36.19 263.02,36.59 268.03,36.59 269.33,35.29 277.87,35.29 278.39,34.77 278.39,31.37 279.78,29.98 287.63,29.98 288.19,30.54 295.25,30.54 295.84,29.95 297.56,29.95 298.91,31.3 301.84,31.3 302.09,31.56 302.29,31.56 302.32,31.52 v2(302.32,31.47)
  BOTTOM w0.107: v2(184.88,58.5) 184.62,58.5 182.26,56.14 178.15,56.14 169.08,47.07 165.52,47.07 156.67,38.22 37.52,38.22 35.42,40.31 35.42,41.83 34.64,42.62 29.31,42.62 22.59,49.33 16.87,49.33 15.6,48.06 15.6,46.28 14.75,45.43 10.83,45.43 10.49,45.09 10.49,43.44 9.93,42.88 9.93,40.68 9.48,40.23 v2(9.48,40.18)
PBAT_PRES#: length 402.5
  TOP w0.102: v2(6.65,42.32) 7.16,41.81 PR931.1 ; PD1.3 4.61,13.1 v2(4.24,12.72)
  TOP w0.104: UE1.F9 v2(320.52,36.75)
  TOP w0.254: PRP1.1 v1(5.77,12.59) 5.48,12.59 4.96,13.1 PD1.3
  IN1 w0.099: v2(6.65,42.32) 6.84,42.13 6.84,38.96 5.06,37.18 5.06,25.03 1.72,21.69 1.72,15.82 4.24,13.3 v2(4.24,12.72)
  IN2 w0.102: v2(181.05,57.52) 181.05,57.27 182.03,56.29 184.68,56.29 188.71,60.32 213.59,60.32 218.3,55.62 222.87,55.62 235.06,43.42 236.38,43.42 240.84,38.96 244.3,38.96 244.76,38.51 249.06,38.51 250.35,37.22 265.33,37.22 266.26,38.15 268.4,38.15 269.12,38.87 271.67,38.87 272.22,39.42 273.53,39.42 274.83,40.72 279.06,40.72 280.13,41.79 281.67,41.79 283.24,43.36 289.71,43.36 292.82,46.47 298.38,46.47 304.77,52.86 307.89,52.86 308.65,52.1 316.52,52.1 v2(318.17,50.45)
  BOTTOM w0.102: v2(318.17,50.45) 318.31,50.45 319.9,48.87 319.9,45.46 319.27,44.83 319.27,44.07 319.27,41.75 318.99,41.47 318.99,39.64 319.32,39.3 319.32,37.36 319.56,37.13 320.14,37.13 v2(320.52,36.75) ; v2(181.05,57.52) 181.05,57.52 177.66,57.52 168.41,48.27 164.56,48.27 155.71,39.42 48.73,39.42 43.84,44.31 32.81,44.31 28.73,48.39 25.24,48.39 23.09,50.53 16.14,50.53 14.43,48.83 14.2,48.83 13.86,48.49 13.86,47.55 12.95,46.63 8.78,46.63 7,44.86 7,42.67 v2(6.65,42.32) 6.24,42.72 5.89,42.72
PBAT_PRES#_C: length 9.6
  TOP w0.254: v2(15.57,13.46) v1(15.57,12.88) 15.29,12.6 8.94,12.6 8.92,12.59 PRP1.8
  BOTTOM w0.254: PBATT1.6 15.75,13.28 v2(15.57,13.46)
PBAT_SMBCLK_C: length 13
  TOP w0.107: PRP1.6 8.82,11.59 8.83,11.59 11.89,11.59 v1(11.93,11.55) 12.16,11.32 16.51,11.32 18.64,13.45 v2(18.64,13.51)
  BOTTOM w0.107: v2(18.64,13.51) 18.75,13.41 PBATT1.4
PBAT_SMBDAT_C: length 11.9
  TOP w0.107: v2(17.55,13.45) 17.55,13.05 16.31,11.81 12.37,11.81 12.1,12.08 8.83,12.08 8.82,12.09 PRP1.7
  BOTTOM w0.107: PBATT1.5 17.25,13.15 v2(17.55,13.45)
PBATT+_C:
  vias: v2(13.17,8.36) v2(13.52,8.9) v2(13.88,9.42) v2(13.9,8.36) v2(14.26,8.9) v2(14.61,9.42) v2(14.64,8.36) v2(14.99,8.9) v2(15.35,9.42) v2(15.38,8.36) v2(15.73,8.9) v2(16.02,9.42) v2(16.09,8.36) v2(16.32,8.91) v2(16.85,8.36) v2(16.93,8.93) v2(17.59,8.91) v2(17.61,8.34) v2(18.22,8.04) v2(18.2,7.45) v3(12.02,6.33) v3(12.22,8.29) v3(18.21,8.66)
PCH_2_CPU_TRIGGER: length 107
  TOP w0.102: v2(205.46,56.5) 204.92,57.04 191.1,57.04 189.75,55.68 187.12,55.68 v1(186.06,56.74) 182.99,59.82 v2(173.8,59.82)
  IN1 w0.099: v2(116.76,68.91) 117.14,68.52 117.65,68.52 118.57,67.61 118.57,66.14 119.33,65.38 120.37,65.38 120.62,65.63 122.3,65.63 122.6,65.33 148.41,65.33 152.27,69.19 158.87,69.19 169.04,59.02 173,59.02 v2(173.8,59.82)
  BOTTOM w0.076: UC1.H23 116.38,69.28 v2(116.76,68.91)
  BOTTOM w0.102: v2(205.46,56.5) 205.53,56.5 208.68,53.35 RH42.2
PCH_2_CPU_TRIGGER_R: length 8.8
  BOTTOM w0.089: UH1.AK3 206.96,42.69 207.03,42.76 207.03,44.1 207.2,44.26 207.2,45.89 208.12,46.81 208.12,48.1 208.43,48.42 208.43,49.32 v1(208.58,49.47)
  BOTTOM w0.102: v1(208.58,49.47) 208.58,50.33 RH42.1
PCH_3.3V_TS_EN: length 164.9
  TOP w0.089: RH375.2 221.46,28.45 v2(222.13,28.45)
  TOP w0.102: v2(142.39,97.98) 142.39,97.04 140.89,95.54 v1(133.83,95.54) RV324.1
  IN2 w0.122: v2(222.13,28.45) 219.88,30.7 218.1,30.7 217.12,31.69 208.54,31.69 207.92,32.3 206.78,32.3 205.89,33.19 205.89,34.91 203.64,37.16 203.64,40.87 203.39,41.12 203.39,41.63 202.49,42.53 195.56,42.53 194.89,43.2 193.08,43.2 192.08,42.2 180.43,42.2 179.89,41.67 177.23,41.67 174.44,44.46 174.44,50.51 174.7,50.76 174.7,60.13 174.45,60.38 174.45,86.07 157.18,103.34 153.13,103.34 147.58,97.8 142.56,97.8 v2(142.39,97.98)
  BOTTOM w0.089: v2(222.13,28.45) 221.75,28.45 220.68,29.52 219.42,29.52 219.21,29.31 214.55,29.31 214.42,29.18 214.01,29.18 UH1.BD30
PCH_BATLOW#: length 8.2
  TOP w0.102: v2(217.65,21.88) 217.65,20.96 218.91,19.7 219.3,19.7 v1(219.56,19.43) 219.78,19.21 RH94.1
  BOTTOM w0.089: UH1.BF44 214.99,22.39 215.27,22.11 215.51,22.11 215.69,21.93 215.69,21.7 216.02,21.37 217.47,21.37 217.65,21.56 v2(217.65,21.88)
PCH_CL_CLK1: length 117.1
  IN3 w0.102: v2(299.68,36.63) 299.6,36.7 297.22,36.7 295.89,35.38 284.76,35.38 283.23,33.84 281.5,33.84 280.61,32.96 277.91,32.96 277.37,32.41 272.1,32.41 270.47,30.78 268.36,30.78 267.9,30.33 252.49,30.33 252.04,30.78 250.3,30.78 249.9,31.18 245.62,31.18 244.76,32.05 240.14,32.05 239.89,32.3 238.28,32.3 237.19,33.39 237.19,33.47 228.72,41.93 228.48,41.93 224.24,46.17 220.56,46.17 219.76,46.97 219.76,47.74 219.07,48.42 218.16,48.42 218.1,48.48 213.59,48.48 212.54,47.43 212.54,46.07 212.14,45.67 210.86,45.67 v2(210.53,45.88)
  BOTTOM w0.089: UH1.AR2 209.76,43.07 209.76,45.45 210.06,45.75 210.4,45.75 v2(210.53,45.88)
  BOTTOM w0.107: JNGFF1.42 301.44,28.36 301.43,28.37 299.7,28.37 298.92,29.16 298.92,30.81 298.62,31.12 298.62,35.74 299.5,36.63 v2(299.68,36.63)
PCH_CL_DATA1: length 116.1
  IN3 w0.102: v2(299.59,36.03) 299.4,36.22 297.42,36.22 296.09,34.9 284.96,34.9 283.43,33.36 281.7,33.36 280.81,32.47 278.11,32.47 277.57,31.93 272.3,31.93 270.67,30.3 268.56,30.3 268.1,29.84 252.29,29.84 251.84,30.3 250.1,30.3 249.7,30.7 245.42,30.7 244.56,31.56 239.94,31.56 239.69,31.82 238.08,31.82 236.71,33.19 236.71,33.27 228.52,41.45 228.28,41.45 224.04,45.69 220.36,45.69 219.27,46.77 219.27,47.54 218.87,47.94 217.96,47.94 217.9,48 213.79,48 213.03,47.23 213.03,45.87 212.34,45.19 210.39,45.19 v2(210.21,45.37)
  BOTTOM w0.089: v2(210.21,45.37) 209.94,45.1 209.94,43.46 210.05,43.35 210.05,41.97 210.08,41.94 UH1.AT5
  BOTTOM w0.107: v2(299.59,36.03) 299.1,35.54 299.1,31.32 299.41,31.02 299.41,29.36 299.9,28.86 JNGFF1.40
PCH_CL_RST1#: length 117.4
  IN3 w0.089: v2(211.55,40.79) 211.92,40.42 216.72,40.42 217.96,41.66 221.72,41.66
  IN3 w0.102: v2(299.98,29.36) 299.79,29.36 297.81,31.34 293.68,31.34 293.27,31.75 290.99,31.75 290.97,31.73 290.97,31.28 290.87,31.18 290.74,31.18 290.64,31.28 290.64,31.7 290.58,31.75 290.32,31.75 290.23,31.66 290.23,31.28 290.13,31.18 289.93,31.18 289.83,31.28 289.83,31.65 289.72,31.75 289.49,31.75 289.42,31.68 289.42,31.28 289.32,31.18 289.11,31.18 289.01,31.28 289.01,31.52 288.78,31.75 286.17,31.75 286.06,31.65 286.06,28.57 285.96,28.47 285.77,28.47 285.67,28.57 285.67,30.82 285.57,30.92 285.38,30.92 285.26,30.81 285.26,28.57 285.16,28.47 285.01,28.47 284.88,28.6 284.88,30.09 284.78,30.19 284.6,30.19 284.48,30.06 284.48,28.6 284.36,28.48 284.21,28.48 284.1,28.6 284.1,29.29 283.99,29.39 283.8,29.39 283.69,29.27 283.69,28.84 283.56,28.72 280.88,28.72 279.18,27.01 271.72,27.01 271.3,26.59 269.41,26.59 268.8,25.98 242.74,25.98 242.58,26.15 239.88,26.15 237.28,28.74 235.47,28.74 231.18,33.03 231.18,33.38 227.15,37.42 226.89,37.42 222.64,41.66 221.72,41.66
  BOTTOM w0.089: UH1.AU4 210.29,41.97 210.41,41.85 210.41,41.6 210.84,41.17 210.84,40.96 211,40.79 v2(211.55,40.79)
  BOTTOM w0.107: JNGFF1.38 300.19,29.36 300.19,29.36 v2(299.98,29.36)
PCH_CPU_BCLK_D: length 5.2
  BOTTOM w0.089: UH1.B8 192.99,40.25 192.85,40.39 192.29,40.39 191.7,40.98 190.07,40.98 189.48,40.4 189.1,40.4 RH161.2
PCH_CPU_BCLK_D#: length 5.8
  BOTTOM w0.089: RH166.2 189.1,40.57 189.41,40.57 190,41.16 191.78,41.16 192.37,40.57 192.92,40.57 193.01,40.48 193.44,40.48 193.64,40.28 UH1.C8
PCH_CPU_BCLK_R_D: length 99.3
  IN1 w0.099: v2(122.08,75.07) 122.39,74.76 122.39,73.54 121.22,72.36 121.22,71.11 122.28,70.05 125.76,70.05 126.42,70.72 130.22,70.72 130.7,71.19 133.17,71.19 135.32,73.35 159.89,73.35 163.39,69.85 173.15,69.85 176.09,66.92 176.09,56.63 180.72,52 181.61,52 182.53,51.08 182.53,50.28 v2(182.33,50.08)
  BOTTOM w0.076: v2(122.08,75.07) 122.24,75.07 122.35,75.18 122.35,75.4 122.17,75.58 120.77,75.58 120.61,75.74 120.47,75.74 UC1.B31
  BOTTOM w0.097: v2(182.33,50.08) 182.51,49.89 182.51,48.08 183.12,47.47 183.12,44.36 187.04,40.44 187.43,40.44 RH161.1
PCH_CPU_BCLK_R_D#: length 99
  IN1 w0.099: v2(182.91,50.08) 182.74,50.25 182.74,51.17 181.69,52.21 180.81,52.21 176.3,56.72 176.3,67 173.24,70.06 163.48,70.06 159.98,73.56 135.23,73.56 133.08,71.4 130.61,71.4 130.13,70.93 126.33,70.93 125.67,70.26 122.37,70.26 121.43,71.2 121.43,72.28 122.6,73.45 122.6,74.82 v2(122.89,75.1)
  BOTTOM w0.076: UC1.A32 120.89,76.05 120.77,75.92 120.77,75.82 120.84,75.75 122.24,75.75 v2(122.89,75.1)
  BOTTOM w0.097: v2(182.91,50.08) 182.7,49.87 182.7,48.16 183.31,47.55 183.31,44.43 187.11,40.63 187.53,40.63 RH166.1
PCH_CPU_NSSC_CLK_D: length 6.3
  BOTTOM w0.089: RH169.2 189.09,42.16 191.02,42.16 192.44,40.74 193.03,40.74 193.07,40.7 193.49,40.7 193.6,40.59 193.84,40.59 193.95,40.7 UH1.D7
PCH_CPU_NSSC_CLK_D#: length 5.7
  BOTTOM w0.089: RH170.2 189.11,42.34 191.09,42.34 192.51,40.92 193.12,40.92 193.12,40.92 193.15,40.9 193.7,40.9 UH1.C6
PCH_CPU_PCIBCLK_D: length 5.8
  BOTTOM w0.089: UH1.A6 192.66,41.18 192.4,41.45 192.39,41.45 192.2,41.64 192.2,42.45 190.69,43.95 189.1,43.95 RH167.1
PCH_CPU_PCIBCLK_D#: length 6.4
  BOTTOM w0.089: RH168.1 189.09,44.13 190.76,44.13 192.38,42.52 192.38,41.71 192.46,41.63 192.48,41.63 192.66,41.44 192.9,41.44 193.17,41.18 UH1.B6
PCH_CPU_PCIBCLK_R_D: length 102.3
  IN1 w0.076: v2(118.89,78.28) 119.05,78.13 119.05,77.9 118.4,77.26 117.82,77.26 117.77,77.2 117.53,76.97 117.53,76.41 118.41,75.53 119.85,75.53 119.89,75.56 120.18,75.56 120.54,75.2 120.54,74.97 120.52,74.95 120.52,74.93
  IN1 w0.099: v2(181.71,50.66) 181.56,50.82 179.94,50.82 175.4,55.36 175.4,66.63 172.87,69.16 163.02,69.16 159.88,72.31 147.73,72.31 147.33,71.91 135.53,71.91 133.27,69.65 126.35,69.65 126.02,69.32 121.23,69.32 120.52,70.03 120.52,74.93
  BOTTOM w0.076: UC1.D35 119.12,78.05 v2(118.89,78.28)
  BOTTOM w0.097: RH167.2 187.53,43.9 186.08,43.9 184.48,45.5 184.48,49.94 183.56,50.86 181.91,50.86 v2(181.71,50.66)
PCH_CPU_PCIBCLK_R_D#: length 101.9
  IN1 w0.076: 120.73,74.93 120.73,74.95 120.7,74.97 120.7,75.27 120.25,75.73 119.82,75.73 119.78,75.69 118.48,75.69 117.7,76.48 117.7,76.9 117.89,77.09 117.89,77.09 118.47,77.09 119.21,77.83 v2(119.69,77.83)
  IN1 w0.099: 120.73,74.93 120.73,70.12 121.32,69.53 125.93,69.53 126.26,69.86 133.18,69.86 135.44,72.12 147.24,72.12 147.64,72.52 159.96,72.52 163.11,69.37 172.95,69.37 175.61,66.72 175.61,55.45 180.03,51.03 181.5,51.03 v2(181.71,51.25)
  BOTTOM w0.076: v2(119.69,77.83) 119.6,77.92 UC1.C36
  BOTTOM w0.097: RH168.2 187.43,44.08 186.16,44.08 184.67,45.58 184.67,50.02 183.64,51.05 181.92,51.05 v2(181.71,51.25)
PCH_DP1_CTRL_CLK: length 164
  TOP w0.089: v2(208.09,39.33) 208.6,39.33 209.61,40.35 209.61,42.57 RH222.1 ; 213.64,50.17 213.64,50.07 v2(213.59,50.02)
  TOP w0.107: v2(115.05,125.42) QV3.1 ; v2(170.46,93.09) 170.46,92.86 170.47,92.84 170.47,91.36 172.54,89.29 172.54,79.03 177.21,74.36 v1(177.21,73.28) 177.21,72.12 185.97,63.36 189.7,63.36 192.88,60.17 207.47,60.17 213.64,54.01 213.64,50.17
  IN3 w0.102: v2(213.59,50.02) 213.59,49.85 212.71,48.97 210.94,48.97 208.01,46.04 208.01,44.68 209.36,43.34 209.36,40.58 208.11,39.33 v2(208.09,39.33) ; v2(115.05,125.42) 115.05,125.57 115.92,126.44 117.93,126.44 118.23,126.75 124.39,126.75 131.1,120.04 137.79,120.04 153.8,104.03 157.02,104.03 166.56,94.49 169.06,94.49 v2(170.46,93.09)
  BOTTOM w0.089: v2(208.09,39.33) 208.09,39.03 207.94,38.89 207.94,38.04 UH1.AL13
PCH_DP1_CTRL_DATA: length 160.8
  TOP w0.089: RH223.1 209.84,41.78 209.84,40.55 v2(210.09,40.29) ; v2(214.17,50.02) 214.13,50.07 214.13,50.17
  TOP w0.107: 214.13,50.17 214.13,54.21 207.68,60.66 193.09,60.66 189.9,63.85 186.17,63.85 v1(180.22,69.8) 177.7,72.33 177.7,74.56 173.03,79.23 173.03,89.5 170.96,91.56 170.96,92.96 v2(171.12,93.12) ; v2(116,125.37) 116,123.85 116.39,123.45 QV3.4
  IN3 w0.102: v2(171.12,93.12) 171.12,92.86 170.84,92.58 170.28,92.58 168.86,94 166.36,94 156.82,103.54 153.6,103.54 137.59,119.56 130.9,119.56 124.19,126.26 118.43,126.26 118.13,125.96 116.23,125.96 116,125.73 v2(116,125.37) ; v2(210.09,40.29) 209.84,40.55 209.84,43.54 208.49,44.88 208.49,45.84 211.14,48.49 212.91,48.49 214.07,49.65 214.07,49.92 v2(214.17,50.02)
  BOTTOM w0.089: UH1.AR8 v2(210.09,40.29)
PCH_DP1_HPD: length 157.9
  TOP w0.089: v2(210.47,40.8) 210.67,40.8 211.23,41.35 211.23,42.29 211.4,42.47 211.4,42.91 212.2,43.71 212.2,46.09 212.62,46.51 212.62,47.89 211.77,48.74 211.77,50.17
  TOP w0.102: v2(172.18,99.71) 172.17,99.71 172.17,94.73 171.03,93.6 170.39,93.6 169.66,92.87 169.66,87.73 170.65,86.75 170.65,80.24 176.42,74.46 176.42,72.19 185.73,62.88 189.5,62.88 192.75,59.62 206.37,59.62 211.77,54.22 211.77,50.17 ; v1(121.24,123.49) 121.16,123.41 QV5.3 120.01,123.34 RV20.1 120.44,122.2 v2(120.77,122.53)
  BOTTOM w0.089: UH1.AT6 210.18,41.08 v2(210.47,40.8)
  BOTTOM w0.102: v2(172.18,99.71) 172.18,101.2 150.06,123.32 126.13,123.32 123.57,120.75 121.55,120.75 120.77,121.53 v2(120.77,122.53)
PCH_DP2_CTRL_DATA: length 7.5
  TOP w0.089: RH221.1 208.83,42.41 209.29,41.95 v1(209.29,41.1) 209.29,40.41 208.61,39.73 207.73,39.73 v2(206.59,38.59)
  BOTTOM w0.089: UH1.AL10 206.96,38.59 v2(206.59,38.59)
PCH_DP2_HPD: length 285.2
  TOP w0.102: RT380.1 18.59,108.74 20.68,106.64 22.13,106.64 23.45,105.32 23.45,105.32 23.48,105.3 23.49,105.3 24.43,104.36 25.75,104.36 25.76,104.34 25.76,104.32 v2(25.78,104.32) ; v2(171.24,94.74) 171.03,94.74 168.07,91.78 168.07,79.04 v1(188.05,59.06) 189.02,58.08 v2(189.02,57.44)
  IN1 w0.099: v2(51.49,101.36) 50.57,102.29 40.46,102.29 39.42,101.24 32.81,101.24 32.37,101.69 28.24,101.69 v2(28.05,101.88)
  IN2 w0.102: v2(209.21,38.97) 209.21,39.04 209.05,39.2 209.05,40.68 209.46,41.09 209.46,46.09 208.78,46.77 208.78,51.35 206.25,53.89 200.44,53.89 199.69,53.13 196.66,53.13 192.36,57.44 v2(189.02,57.44)
  IN3 w0.102: v2(25.78,104.32) 25.8,104.32 26.46,103.66 26.46,103.47 v2(28.05,101.88)
  BOTTOM w0.089: UH1.AN10 v2(209.21,38.97)
  BOTTOM w0.102: 38.97,85.82 39.37,85.42 42.42,85.42 42.62,85.62 42.62,88.24 42.35,88.51 42.35,91.34 47.35,96.34 49.96,96.34 50.52,96.9 50.52,99.52 51.25,100.25 51.25,101.12 v2(51.49,101.36) 51.84,101.02 54.53,101.02 55.14,101.62 57.7,101.62 58.41,100.91 62.76,100.91 65.75,103.9 69.18,103.9 69.39,104.11 70.8,104.11 73.47,106.78 76.79,106.78 78.77,108.76 87.11,108.76 92.56,114.21 107.32,114.21 107.72,114.6 110.64,114.6 113.91,117.88 124.65,117.88 127.02,120.25 145.19,120.25 156.84,108.6 157.41,108.6 171.24,94.77 v2(171.24,94.74)
  BOTTOM w0.104: 38.97,85.82 RT73.2
PCH_DP2_HPD_R: length 3.4
  BOTTOM w0.076: 36.55,86.15 35.77,86.93 35.12,86.93 UT5.C10
  BOTTOM w0.104: 36.55,86.15 v1(36.79,85.91) 36.88,85.82 RT73.1
PCH_DP3_CTRL_CLK: length 90.7
  TOP w0.089: RH224.1 207.67,42.37 207.96,42.07 v4(207.96,41.49) 207.96,40.8 207.86,40.71 v2(207.3,40.71)
  TOP w0.107: UV9.33 270.9,34.99 270.54,35.35 270.13,35.35 v2(269.67,34.89)
  IN3 w0.102: v2(269.67,34.89) 269.74,34.81 269.74,34.52 269.51,34.28 262.84,34.28 262.26,33.71 255.61,33.71 255.27,33.36 254.61,33.36 253.69,34.28 251.92,34.28 251.6,34.6 247.82,34.6 247.14,35.28 245.3,35.28 244.97,35.62 242.96,35.62 242.22,36.36 237.31,36.36 229.98,43.69 228.97,43.69 224.9,47.76 223.83,47.76 221.25,50.34 217.54,50.34 216.35,51.54 209.22,51.54 208.28,50.6 206.88,50.6 206.27,49.99 206.27,46.43 206.78,45.92 206.78,43.9 207.81,42.87 207.81,40.81 207.71,40.71 v2(207.3,40.71)
  BOTTOM w0.089: v2(207.3,40.71) 207.59,41 207.59,41.12 207.39,41.33 207.26,41.33 206.78,40.84 206.78,40.49 207.57,39.7 UH1.AL9
PCH_DP3_CTRL_DATA: length 91.8
  TOP w0.089: RH225.1 207.64,43.66 208.05,43.25 208.05,42.23 208.14,42.15 208.14,41.82 208.17,41.78 208.17,41.2 208.14,41.16 208.14,40.35 v2(208.32,40.17)
  TOP w0.107: UV9.34 270.85,34.49 270.62,34.27 270.17,34.27 270.06,34.37 270.06,34.59 270.33,34.86 v2(270.34,34.86)
  IN3 w0.102: v2(208.32,40.17) 208.29,40.19 208.29,43.07 207.26,44.1 207.26,46.12 206.75,46.63 206.75,49.79 207.08,50.11 208.48,50.11 209.42,51.06 216.15,51.06 217.34,49.86 221.05,49.86 223.63,47.28 224.7,47.28 228.77,43.2 229.78,43.2 237.11,35.88 242.02,35.88 242.76,35.14 244.77,35.14 245.1,34.8 246.94,34.8 247.62,34.12 251.4,34.12 251.72,33.8 253.49,33.8 254.41,32.88 255.47,32.88 255.81,33.22 262.46,33.22 263.04,33.8 269.71,33.8 270.23,34.31 270.23,34.75 v2(270.34,34.86)
  BOTTOM w0.089: UH1.AR3 209.77,42.37 209.77,41.93 209.27,41.43 209.27,40.94 208.9,40.57 208.64,40.57 208.32,40.25 v2(208.32,40.17)
PCH_DP3_HPD: length 81.1
  TOP w0.102: v2(279.69,37.74) 279.44,37.49 UV9.9
  IN2 w0.102: v2(279.69,37.74) 279.12,37.74 279.01,37.63 279.01,34.39 276.54,31.91 269.75,31.91 267.87,33.8 252.06,33.8 251.61,34.25 243.7,34.25 241.55,36.4 236.59,36.4 235.11,37.87 225.73,37.87 224.58,39.02 221.88,39.02 220.83,37.97 218.31,37.97 216.37,39.91 211.95,39.91 211.27,39.24 210.68,39.24 210.22,39.7 v2(209.97,39.7)
  BOTTOM w0.089: UH1.AP9 v2(209.97,39.7)
PCH_DP3_RD_HPD: length 72.9
  TOP w0.102: v2(305.33,66.73) 305.33,67.82 307.98,70.47 307.98,74.89 309.75,76.66 316.76,76.66 317.57,75.84 323.64,75.84 324.66,74.83 RV102.1 325.93,74.58 UV6.32 ; UV9.11 278.79,38.49 280.72,40.42 v1(280.72,42.84) 280.72,44.63 v2(280.76,44.67)
  IN3 w0.102: v2(280.76,44.67) 280.76,44.72 291.11,55.07 291.11,56.9 296.85,62.64 296.85,62.89 300.68,66.73 v2(305.33,66.73)
PCH_DPWROK: length 156.7
  TOP w0.102: v2(212.17,23.7) 212.2,23.7 212.3,23.61 212.68,23.61 213.15,23.13 213.7,23.13 213.99,22.84 v3(214.36,22.84) 214.59,22.84 216.16,21.27 216.16,21.02 CH266.1 217.29,20.29 RH215.1 217.55,19.25 RH308.1 ; RE536.1 316.72,52.36 315.74,51.38 315.74,50.78 v2(315.66,50.7)
  IN1 w0.122: v2(311.17,18.03) 311.17,18.2 310.58,18.79 310.58,19.93 308.7,21.8 303.34,21.8 302.89,22.25 298.01,22.25 296.57,20.82 295.69,20.82 294.89,20.02 294.3,20.02 293.97,19.69 289.68,19.69 289.55,19.83 253.5,19.83 252.37,18.7 242.48,18.7 241.29,19.89 240.4,19.89 239.48,20.81 237.41,20.81 237.23,20.63 229.91,20.63 228.8,21.74 227.18,21.74 226.68,22.24 221.54,22.24 219.91,23.87 214.06,23.87 213.87,23.68 212.66,23.68 212.62,23.73 212.19,23.73 212.17,23.7 v2(212.17,23.7)
  IN3 w0.102: v2(315.66,50.7) 313.55,50.7 310.57,47.73 310.57,40.96 310.43,40.82 310.43,39.2 311.58,38.06 311.58,33.55 310.92,32.89 310.92,31.67 311.08,31.52 311.08,29.01 310.71,28.64 v2(310.71,27.75)
  BOTTOM w0.089: UH1.AW41 211.94,23.96 212.17,23.74 v2(212.17,23.7)
  BOTTOM w0.102: v2(310.71,27.75) 310.71,27.69 309.28,26.26 309.28,24.59 310.98,22.89 310.98,18.67 311.17,18.48 v2(311.17,18.03)
PCH_DPWROK_EC: length 17.9
  TOP w0.102: RE536.2 316.64,51.44 316.43,51.23 v2(316.43,50.7)
  TOP w0.104: UE1.F8 v2(319.72,36.75)
  BOTTOM w0.102: 319.12,39.22 319.12,37.14 319.51,36.75 v2(319.72,36.75)
  BOTTOM w0.104: 319.12,39.22 318.78,39.56 318.78,40.51 318.76,40.53 318.76,42.29 318.78,42.32 v1(318.78,43.69) 318.78,44.28 318.78,48.7 316.78,50.7 v2(316.43,50.7)
PCH_INTRUDER_HDR#: length 6.7
  TOP w0.102: RH198.2 213.53,17.34 213.17,17.69 213.17,18.61 213.67,19.11 213.67,19.41 214.21,19.95 214.21,21.03 214,21.24 v1(213.93,21.24) 213.92,21.24 213,22.15 v2(212.79,22.15)
  BOTTOM w0.089: UH1.BB44 v2(212.79,22.15)
PCH_JTAG_TCK: length 196
  TOP w0.089: v2(207.16,47.34) 206.6,46.77 RH313.1
  TOP w0.102: v2(49.5,43.43) 47.49,41.43 46.54,41.43 46.17,41.06 JXDP1.55 46.17,36.88 T188.1
  BOTTOM w0.089: 207.2,50.17 206.78,49.75 206.78,47.96 207.16,47.58 v2(207.16,47.34) 207.16,46.71 206.66,46.22 206.66,44.48 206.5,44.32 206.5,43.27 206.41,43.19 206.41,42.84 206.36,42.78 206.36,42.49 UH1.AJ3
  BOTTOM w0.102: 207.2,50.17 207.53,50.5 207.53,52.64 201.76,58.41 194.77,58.41 188.12,65.06 174.27,65.06 163.91,54.7 163.91,53.11 151.59,40.79 52.14,40.79 v2(49.5,43.43)
PCH_JTAG_TDI: length 203.4
  TOP w0.102: v2(49.58,53.62) T187.1 RC229.2
  BOTTOM w0.089: 203.6,52.44 203.6,51.8 204.06,51.35 RH314.1 ; UH1.AH2 205.95,43.33 206.15,43.53 206.15,44.5 206.31,44.66 206.31,49.68 205.82,50.17
  BOTTOM w0.102: 203.6,52.44 203.6,52.58 203.43,52.74 203.43,53.85 199.35,57.94 194.59,57.94 187.93,64.6 174.46,64.6 164.37,54.51 164.37,52.92 151.78,40.33 51.15,40.33 46.72,44.77 46.72,53.81 47.04,54.13 49.07,54.13 v2(49.58,53.62) ; 205.82,50.17 204.96,51.03 CC304.1 RH314.1
PCH_JTAG_TDO: length 201.8
  TOP w0.102: RC230.2 47.4,50.46 T186.1 47.13,50.73 47.13,53.46 v2(47.29,53.62)
  BOTTOM w0.089: UH1.AH3 205.98,42.65 206.23,42.9 206.23,43.26 206.32,43.35 206.32,44.39 206.49,44.56 206.49,49.81 206.85,50.17
  BOTTOM w0.102: v2(47.29,53.62) 47.84,53.07 47.84,43.97 51.25,40.56 151.69,40.56 164.14,53.01 164.14,54.61 174.37,64.83 188.02,64.83 194.68,58.18 200.35,58.18 205.41,53.12 205.41,51.3 205.56,51.16 CC303.1 206.02,51.15 206.89,51.15 RH315.1 206.9,50.23 206.85,50.17
PCH_JTAG_TMS: length 199.5
  TOP w0.102: v2(207.75,48.58) 207.81,48.53 RH312.1 207.81,46.57 T183.1 ; RC228.2 50.59,53.54 v2(50.67,53.62)
  BOTTOM w0.089: 207.75,50.17 v2(207.75,48.58) 207.64,48.46 207.64,46.89 206.84,46.08 206.84,44.41 206.68,44.25 206.68,43.16 206.59,43.07 206.59,42.7 206.67,42.62 206.67,42.2 UH1.AJ4
  BOTTOM w0.102: 207.75,50.17 207.75,53 202.12,58.64 194.86,58.64 188.21,65.29 174.18,65.29 163.68,54.8 163.68,53.2 151.5,41.02 58.61,41.02 50.64,48.98 50.64,53.59 v2(50.67,53.62)
PCH_JTAGX: length 183.4
  TOP w0.102: T182.1 166.16,55.32 v2(166.14,55.3)
  IN3 w0.102: v2(77.36,73.66) 77.36,76.63 76.88,77.11 76.88,81.11 78.48,82.7 80.77,82.7 81.43,83.36 82.67,83.36 83.21,82.83 99.7,82.83 101.08,81.46 116.41,81.46 118.09,83.13 119.3,83.13 120.32,84.15 120.32,84.65 122.21,86.54 132.13,86.54 137.21,81.46 142.22,81.46 146.74,76.94 147.75,76.94 165.71,58.98 165.71,56.01 166.14,55.57 v2(166.14,55.3)
  BOTTOM w0.076: v2(77.36,73.66) 77.36,73.46 77.14,73.23 77.14,72.87 74.95,70.69 73.78,70.69 73.55,70.46 72.51,70.46 72.11,70.05 RC143.2 71.55,69.87
  BOTTOM w0.089: UH1.AH4 205.9,42.21 205.73,42.38 205.73,43.24 205.73,43.24 205.46,43.51 205.46,46.56 CC305.1 205.88,47.36 206.07,47.55 206.07,49.51 204.99,50.58 203.91,50.58 203.65,50.85 203.65,51.5 203.43,51.72 203.43,52.39 202.75,53.07
  BOTTOM w0.102: RC166.2 71.09,69.87 71.55,69.87 ; v2(166.14,55.3) 166.14,55.42 174.72,63.99 187.67,63.99 194.34,57.33 198.85,57.33 202.75,53.43 202.75,53.07
PCH_PCIE_WAKE#: length 121.6
  TOP w0.102: v2(309.08,31.08) 309.46,31.08 309.68,30.86 310.03,30.86 RE274.2 311.12,30.99 v1(311.6,30.99) 312.06,30.99 312.13,31.06
  TOP w0.104: UE1.L1 313.42,32.35 312.13,31.06
  IN2 w0.102: v2(309.08,31.08) 309.08,31.55 308.65,31.98 307.72,31.98 307.39,31.65 306.24,31.65 305.67,31.08 305.67,30.62 302.36,27.3 295.09,27.3 294.14,26.35 286.09,26.35 285.43,25.69 285.43,22.74 281.88,19.2 263.39,19.2 260.34,22.24 239.32,22.24 237.52,20.45 232.95,20.45 232.2,21.19 227.62,21.19 226.83,20.4 222.09,20.4 221.69,20.4 220.8,19.51 216.83,19.51 215.76,20.58 213.86,20.58 v2(213.84,20.6)
  BOTTOM w0.089: 217.41,17.6 214.56,17.6 213.5,18.65 213.5,19.46 213.23,19.72 213.23,20.15 213.39,20.31 UH1.BB47 213.53,20.6 v2(213.84,20.6)
  BOTTOM w0.102: 217.41,17.6 219.69,17.6 RH92.1
PCH_PECI: length 10
  TOP w0.089: v2(205.3,49.52) 205.3,49.67 204.96,50.01 v1(204.96,50.15) 204.96,50.17
  TOP w0.102: RH74.1 205.99,51.17 RH73.1 204.96,50.17
  BOTTOM w0.089: v2(205.3,49.52) 205.46,49.52 205.72,49.25 205.72,47.85 205.11,47.24 205.11,43.32 205.27,43.16 UH1.AF2
PCH_PLTRST#: length 34.3
  IN1 w0.122: v2(211.11,29.13) 211.39,29.41 212.77,29.41 212.86,29.31 217.8,29.31 219.58,27.53 221.1,27.53 221.28,27.71 222.04,27.71 222.78,28.45 222.78,28.66 223.24,29.11 223.61,29.48 227.22,29.48 227.36,29.34 229,29.34 232.26,26.08 v2(232.34,26.08)
  BOTTOM w0.089: v2(211.11,29.13) 211.11,29.42 UH1.AV29
  BOTTOM w0.102: RH244.2 RH62.2 234.38,25.95 235.05,26.62 UH7.2 UH7.1 235.88,25.97 236.07,26.16 236.07,26.49 236.4,26.81 237.29,26.81 238.31,25.79 RH60.1 ; RH244.2 233.09,25.95 233.03,25.9 232.52,25.9 v2(232.34,26.08) ; RH244.2 233.41,25.96 RH635.1
PCH_PLTRST#_5105: length 77.5
  TOP w0.104: v2(306.82,32.05) 307.11,32.35 308.6,32.35 v1(308.9,32.05) 309.34,32.05 310.05,31.34 312.09,31.34 313.34,32.59 313.34,32.77 UE1.K1
  IN1 w0.099: v2(306.82,32.05) 305.23,30.46 305.23,29.69 301.44,25.91 299.45,25.91 v2(298.56,25.02)
  IN3 w0.102: v2(298.56,25.02) 296.76,25.02 293.38,21.64 292.72,21.64 291.93,22.43 276.72,22.43 275.89,21.6 272.97,21.6 272.58,22 v2(272.58,22.16)
  BOTTOM w0.102: UE6.4 258.86,23.05 258.75,23.16 258.75,23.44 258.92,23.62 260.09,23.62 260.57,24.1 260.57,24.19 260.58,24.2 260.58,24.5 260.57,24.51 260.57,24.99 260.85,25.27 263.34,25.27 263.59,25.03 264.4,25.03 264.78,25.42 265.02,25.65 268.02,25.65 269.49,24.18 270.84,24.18 272.58,22.44 v2(272.58,22.16) ; RE340.1 314.04,27.58 314.04,28.36 313.47,28.93 311.08,28.93 310.96,28.81 308.74,28.81 307.13,30.42 307.13,31.75 v2(306.82,32.05)
PCH_PLTRST#_AND: length 549.4
  TOP w0.102: UR1.1 15.38,69.34 15.21,69.5 15.21,70.19 v2(12.28,73.12) ; v2(299.87,25.5) 300.23,25.14 300.23,22.16 302.19,20.19 302.19,18.38 300.31,16.5 v2(300.31,11.89) 300.26,11.84 CZ61.1 ; v2(239.45,29.52) 239.45,30.87 239.44,30.89 239.44,35.81 v1(241.93,38.3) 241.93,38.94 v2(241.5,39.37)
  IN3 w0.102: v2(348.33,7.21) 335.39,7.21 332.8,9.8 331.37,9.8 330.35,8.78 324.27,8.78 323.5,8.01 316.23,8.01 313.74,10.5 306.59,10.5 306.22,10.13 305.1,10.13 304.61,10.62 301.49,10.62 300.31,11.8 v2(300.31,11.89) ; v2(329.02,63.35) 328.86,63.35 328.58,63.63 323.73,63.63 322.6,62.5 320.77,62.5 319.56,61.28 319.56,58.63 318.7,57.77 318.7,54.43 317.12,52.84 311.05,52.84 306.31,48.11 301.57,48.11 300.57,47.1 300.57,43.75 v2(298.07,41.26) ; v2(12.28,73.12) 12.26,73.14 12.26,73.68 17.97,79.39 19.82,79.39 22.04,81.61 22.04,84.56 21.1,85.5 21.1,100.2 20.52,100.79 20.52,103.5 20.52,104.01 20.52,104.01 20.52,104.27 20.3,104.48 20.3,106.55 21,107.25 21,108.61 20.76,108.86 20.76,113.82 21.89,114.96 22.46,114.96 22.68,115.18 22.68,115.67 22.46,115.89 22.46,116.63 22.9,117.06 24.3,118.47 24.64,118.47 30.2,118.47 40.02,108.65 57.52,108.65 59.16,110.29 67.58,110.29 75.66,118.37 75.66,121.17 77.2,122.71 80.6,122.71 82.02,121.28 86.3,121.28 86.93,121.91 102.03,121.91 102.68,121.26 102.68,121.26 103.01,120.93 125.9,120.93 130.19,116.64 136.22,116.64 140.77,112.1 140.77,110.42 195.94,55.25 197.32,55.25 197.87,54.7 217.3,54.7 218.15,53.84 221.88,53.84 225.06,50.67 227.18,50.67 233.59,44.26 234.52,44.26 239.4,39.37 v2(241.5,39.37) 243.32,39.37 244.09,38.6 249.23,38.6 250.1,37.73 252.67,37.73 253.21,37.19 263.65,37.19 264.04,37.58 265.53,37.58 265.96,38.01 266.94,38.01 267.41,38.48 268.62,38.48 269.41,39.27 269.85,39.27 269.98,39.41 270.8,39.41 270.84,39.45 271.83,39.45 272.38,39.99 276.5,39.99 277.69,41.18 279.19,41.18 280.37,42.35 291.16,42.35 292.1,41.41 v2(292.1,40.81)
  BOTTOM w0.102: RZ114.1 300.31,11.45 v2(300.31,11.89) ; JNGFF3.50 348.3,3.83 348.33,3.86 v2(348.33,7.21) ; v2(239.45,29.52) 239.45,28.55 RH65.1 238.58,27.67 RH187.2 238.04,26.68 237.46,27.27 UH7.4 ; JNGFF1.52 300.23,25.86 v2(299.87,25.5) 299.41,25.96 299.41,27.34 298.43,28.31 298.43,30.61 298.13,30.91 298.13,39.06 298.45,39.37 298.45,40.88 v2(298.07,41.26) 297.3,40.48 292.43,40.48 v2(292.1,40.81) ; v2(329.02,63.35) 331.37,63.35 332.98,61.75 336.6,61.75 336.9,61.44 JNGFF2.50
PCH_PLTRST#_EC: length 45.2
  BOTTOM w0.102: RE375.2 270.41,20.81 271.19,21.59 271.19,23.18 270.47,23.9 269.2,23.9 267.85,25.25 265.19,25.25 264.55,24.61 262.91,24.61 262.61,24.31 262.61,24.03 262.28,23.7 UE6.2 260.98,23.7 260.63,23.34 260.63,22.94 260.33,22.64 257.76,22.64 v1(256.95,23.45) 256.28,24.12 246.21,24.12 245.36,23.27 235.18,23.27 RH244.1
PCH_PRIM_EN: length 269.1
  TOP w0.102: v2(182.64,73.49) 182.64,74.42 181.91,75.15 181.91,80.29 179.43,82.77 179.43,86.96 175.24,91.15 175.24,100.42 172,103.66 172,115.96 161.45,126.52 PR511.1 ; v2(162.67,9.3) 162.67,9.56 163.34,10.23 164.83,10.23 165.62,11.02 167,11.02 167.59,10.44 PR312.1 168,10.35 168.68,11.02 170.08,11.02 170.71,11.65 172.77,11.65 173.39,11.03 178.39,11.03 179.12,10.3 180.01,10.3 180.89,9.41 182.66,9.41 183.02,9.77 v1(183.87,9.77) 187.75,9.77 190.58,6.94 190.58,6.32 192.19,4.71 v2(192.19,4.23) ; v2(126.44,9.55) 125.75,8.86 PR504.1
  IN1 w0.099: v2(183.27,26.35) 183.4,26.48 183.4,35.78 178.2,40.97 175.83,40.97 174.89,41.91 174.89,43.19 173.88,44.2 170.15,44.2 169.45,44.89 164.92,44.89 162.33,47.48 155.72,47.48 152.98,50.23 v2(152.68,50.23) ; v2(162.67,9.3) 162.39,9.58 161.12,9.58 161.07,9.63 148.5,9.63 146.44,7.57 131.77,7.57 130.27,9.07 129.46,9.07 128.98,9.55 v2(126.44,9.55)
  BOTTOM w0.102: v2(192.19,4.23) 192.23,4.23 192.53,4.52 193.53,4.52 193.76,4.29 RZ64.1 193.85,4.84 RH441.2 193.46,5.89 RH442.2 192.67,6.84 192.52,6.84 191.79,7.57 191.79,11.39 182.2,20.98 182.2,25.82 181.35,26.67 181.35,26.99 181.73,27.37 182.5,27.37 183.27,26.59 v2(183.27,26.35) ; v2(152.68,50.23) UZ34.1 152.68,51.62 152.89,51.84 154.03,51.84 155.05,50.82 155.94,50.82 158.35,53.24 158.35,55.14 162.54,59.33 162.54,61.11 169.46,68.03 169.46,68.8 171.18,70.51 181.97,70.51 182.64,71.18 v2(182.64,73.49)
PCH_PWROK: length 252.3
  TOP w0.102: v2(185.63,45.19) v3(185.63,48.04) 185.63,50.41 v2(185.31,50.72) ; RH424.1 212.43,21.75 212.33,21.85 212.33,23.06 212.51,23.23 212.52,23.23 v2(212.52,23.24)
  TOP w0.203: v2(61.84,81.7) 61.55,81.99 PU1700.45
  IN1 w0.122: v2(185.63,45.19) 185.63,45.3 186.44,46.11 188.29,46.11 188.95,45.44 196,45.44 197.39,44.06 198.82,44.06 203.56,39.32 203.56,38.17 205.87,35.87 205.87,26.59 206.58,25.87 206.69,25.87 207.3,25.26 207.3,25.21 207.75,24.75 209.14,24.75 210.75,23.14 210.75,22.85 211.56,22.04 211.9,22.04 212.52,22.66 v2(212.52,23.24)
  IN2 w0.102: 65.27,94.25 73.34,94.25 73.81,94.72 83.03,94.72 83.5,94.25 83.95,94.25 84.24,93.95 88.04,93.95 88.87,94.78 95.8,94.78 96.02,94.56 96.02,94.54 106.27,94.54 107.68,95.95 107.68,97.59 108.24,98.15 118.26,98.15 120.92,95.49 121.76,95.49 122.16,95.89 122.16,97.43 121.15,98.44 121.15,99.3 121.6,99.75 124.55,99.75 127.29,97 135.53,97 137.36,95.17 141.02,95.17 141.74,95.9 141.74,98.6 142.03,98.89 v2(142.54,98.89) ; v2(147.8,99.72) 148.8,99.72 152.92,103.84 158.45,103.84 175.79,86.5 175.79,84.86 176.26,84.39 176.26,52.9 177.52,51.65 180.31,51.65 180.56,51.9 184.13,51.9 v2(185.31,50.72)
  IN2 w0.122: v2(61.84,81.7) 61.1,81.7 58.2,84.6 58.2,88.47 62.49,92.76 63.78,92.76 65.27,94.25
  IN3 w0.102: v2(147.8,99.72) 143.37,99.72 v2(142.54,98.89)
  BOTTOM w0.089: UH1.AY42 212.51,23.25 212.52,23.24 v2(212.52,23.24)
  BOTTOM w0.203: v2(61.84,81.7) 62.35,81.7 62.56,81.91 PR1716.2
PCH_RSMRST#: length 25.6
  TOP w0.102: UZ6.1 313.8,23.52 314.04,23.77 v2(314.04,25.76) 314.71,26.43 314.71,27.89 315.67,28.84 315.67,29.15 316.52,30 316.52,31.03 316.92,31.43 UE1.M5 ; v2(307.13,34.76) 307.13,34.95 v1(307.39,35.2) RE342.1
  IN3 w0.102: v2(314.04,25.76) 314.04,26.35 313.05,27.34 310.3,27.34 309.99,27.65 309.99,32.09 307.32,34.76 v2(307.13,34.76)
PCH_RSMRST#_AND: length 431.5
  TOP w0.102: v2(230.2,4.84) 230.21,4.84 230.36,4.99 230.36,8.31 229.54,9.13 229.54,12.72 231.76,14.95 v2(231.76,15.9) 231.81,15.95 231.81,17.78 232.73,18.7 232.73,21.18 233.45,21.9 233.45,25.1 233.79,25.44 233.79,29.55 232.93,30.41 232.93,40.58 229.09,44.42 v2(228.85,44.42) ; RC124.1 38.25,36.17 38.25,36.99 38.04,37.2 37.38,37.2 37.09,36.91 37.09,34.28 37.55,33.82 T191.1 51.93,33.82 60.12,42.01 60.12,54.71 59.31,55.52 v2(57.18,55.52) ; RH215.2 218.86,18.99 219.55,18.3 RC75.1 219.7,17.28 220.94,16.04 v2(221.56,16.04) ; UZ6.4 312.5,20.07 312.25,19.82 312.25,16.81 314.74,14.33 314.74,10.24 314.23,9.73 312.99,9.73 312.09,8.83 312.09,7.95 v2(309.2,5.07)
  IN1 w0.099: v2(309.2,5.07) 308.92,5.35 304.53,5.35 303.2,6.68 298.75,6.68 298.27,6.2 295.32,6.2 294.43,7.09 292.2,7.09 291.51,7.78 278.44,7.78 277.15,9.07 268.33,9.07 265.8,6.53 259.66,6.53 258.26,5.12 250.89,5.12 250.21,4.45 236.61,4.45 235.87,5.18 233.76,5.18 233.35,4.76 230.28,4.76 v2(230.2,4.84)
  IN2 w0.102: v2(221.56,16.04) 221.7,15.9 v2(231.76,15.9)
  BOTTOM w0.089: 217.41,17.11 217.16,17.36 214.52,17.36 212.71,19.16 212.71,19.64 212.84,19.76 212.84,20.3 212.89,20.35 212.89,20.76 UH1.BA47
  BOTTOM w0.102: v2(228.85,44.42) 228.85,44.55 219.28,54.12 212.27,54.12 209.19,57.2 209.19,57.76 204.78,62.16 198.38,62.16 197.43,63.12 197.43,65.09 193.74,68.77 172.4,68.77 171.33,67.7 171.33,64.81 162.01,55.49 162.01,53.9 150.8,42.69 60.55,42.69 56,47.24 56,54.94 56.59,55.52 v2(57.18,55.52) ; 217.41,17.11 218.85,17.11 219.43,16.53 220.44,16.53 220.94,16.04 v2(221.56,16.04)
PCH_RTCRST#: length 272.8
  TOP w0.102: v2(213.18,21.44) 213.03,21.28 213.03,20.12 212.17,19.26 212.17,15.5 212.33,15.33 212.33,14.43 212.58,14.19 v2(212.58,14.06)
  TOP w0.107: v2(212.58,14.06) 212.58,12.2 214.65,10.13 214.65,7.18 213.89,6.41 213.89,4.46 215.87,2.47 229.9,2.47 230.93,3.5 230.93,8.93 230.92,8.93 230.92,12.61 232.78,14.46 232.78,17.38 233.7,18.3 233.7,20.77 234.91,21.98 234.91,24.49 235.25,24.83 235.25,30.15 234.91,30.49 234.91,35.76 v2(235.71,36.56) ; v2(177.97,45.94) 176.82,44.78 JAPS1.9 ; v2(288.34,28.27) 289.09,28.27 290.49,29.66 290.49,33.42 292.4,35.34 292.4,36.24 296.08,39.91 296.08,45.81 296.34,46.06 296.34,52.77 297.98,54.41 v3(300.68,54.41) 301.1,54.83 301.1,57.04 302.23,58.17 309.89,58.17 310.93,57.12 317.4,57.12 319.22,55.3 319.22,53.36 319.2,53.34 319.2,51.25 RE94.2
  IN1 w0.099: v2(177.97,45.94) 182.81,45.94 188.57,51.69 194.97,51.69 196.83,53.55 198.01,53.55 198.22,53.75 210.51,53.75 212.9,51.36 216.99,51.36 217.27,51.08 221.36,51.08 230.71,41.73 231.19,41.73 232.96,39.95 232.96,39.3 v2(235.71,36.56) 236.47,36.56 236.74,36.83 237.65,36.83 242.19,32.29 244.17,32.29 244.28,32.18 248.88,32.18 250.17,30.89 269.9,30.89 272.18,28.6 273.8,28.6 273.92,28.48 287.72,28.48 287.93,28.27 v2(288.34,28.27)
  BOTTOM w0.089: 212.58,13.88 v2(212.58,14.06) ; UH1.BE47 214.05,20.92 213.57,21.4 213.22,21.4 v2(213.18,21.44)
  BOTTOM w0.107: RH200.2 213.64,12.48 213.49,12.48 212.81,13.16 CH40.2 212.58,13.36 212.58,13.88 ; v2(235.71,36.56) 235.69,36.54 229.93,36.54 229.5,36.11 228.35,36.11 CMOS1.2
PCH_RTCX1: length 8.8
  BOTTOM w0.089: UH1.BA49 212.33,19.9 212.33,18.86 214.36,16.83 215.4,16.83 216.07,16.15 v1(216.07,15.85) 216.38,15.85 216.84,15.39 RH44.1 216.02,14.79 RH43.2
PCH_RTCX1_R: length 2
  BOTTOM w0.089: RH43.1 215.93,13.88
  BOTTOM w0.107: 215.93,13.88 215.93,13.13 CH4.2 216.93,13.12 YH1.1
PCH_RTCX2: length 12.2
  BOTTOM w0.089: 217.41,15.9 216.21,17.09 214.46,17.09 212.52,19.03 212.52,19.72 212.65,19.84 212.65,20.12 212.61,20.16 UH1.BA48
  BOTTOM w0.107: 217.41,15.9 v1(217.47,15.84) 217.47,15.07 RH44.2 218.68,14.79 CH5.2 218.7,13.43 218.88,13.25 YH1.2
PCH_SMB_ALERT#: length 12.2
  BOTTOM w0.089: 221.6,32.41 221.23,32.78 220.71,32.78 220.15,32.22 218.87,32.22 218.68,32.03 215.29,32.03 215.27,32.01 214.6,32.01 UH1.BE25
  BOTTOM w0.102: 221.6,32.41 221.9,32.11 224.11,32.11 224.25,31.97 v1(224.9,31.97) RH61.2
PCH_SPI_CLK: length 27.8
  IN3 w0.102: v2(226.25,12.86) 226.65,13.26 226.65,13.84 226.37,14.13 221.64,14.13 220.66,15.11 216.48,15.11 216.19,15.4 214.9,15.4 214.37,15.93 v2(212.97,15.93)
  BOTTOM w0.089: RH634.1 212.97,14.96 v2(212.97,15.93) ; UH1.AW47 211.36,20.94 211.44,20.86 211.44,20.49 211.39,20.45 211.39,20.45 211.34,20.39 211.34,17.8 212.73,16.41
  BOTTOM w0.102: 212.73,16.41 212.97,16.17 v2(212.97,15.93)
  BOTTOM w0.107: v2(226.25,12.86) 227.07,12.05 227.07,11.55 227.08,11.54 RH181.2 227.21,11.13 227.21,10.06 227.14,9.98 JSPI1.8
PCH_SPI_CLK_0_R: length 14.2
  BOTTOM w0.107: RPC1.6 232.21,14.83 232.11,14.93 232.11,15.08 232.43,15.4 232.43,15.55 232.27,15.7 232.12,15.7 231.89,15.47 230.34,15.47 229.81,14.95 v3(229.66,14.95) 229.55,14.95 227.86,16.64 227.56,16.64 227.45,16.74 227.45,16.99 227.56,17.09 228.08,17.09 228.18,17.2 228.18,17.42 228.08,17.52 227.52,17.52 227.41,17.63 227.41,17.86 227.52,17.97 228.07,17.97 228.18,18.09 228.18,18.29 228.08,18.4 227.52,18.4 227.41,18.5 227.41,18.64 227.3,18.74 226.87,18.74 226.74,18.61 UC5.6 225.59,18.1 RH29.1
PCH_SPI_CLK_1_R: length 14.3
  BOTTOM w0.107: UC6.6 240.95,4.88 RH28.1 240.79,4.12 240.64,3.97 237.02,3.97 v1(235.94,5.05) 235,5.99 235,6.57 235.1,6.68 236.14,6.68 236.24,6.77 236.24,7.01 236.14,7.1 235.1,7.1 235,7.21 235,7.77 234.75,8.02 RPC2.7
PCH_SPI_CLK_2_R: length 3.4
  TOP w0.107: UZ12.19 246.44,26.85 v1(246.12,26.54) 245.41,25.83 RZ60.2 RZ63.2
