# Allegro board LA-F711P R05-0112.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on BOTTOM (solid shape): 52.26,111 54.58,111 54.77,110.82 54.77,109.23 54.68,109.14 50.06,109.14 49.86,109.35 49.86,111.05 50.03,111.23 52.04,111.23
GND on BOTTOM (solid shape): 73,54.38 73,51.13 71.57,49.71 68.58,49.71 64.92,53.36 61.39,53.36 60.98,53.77 60.98,55.92 61.59,56.53 70.85,56.53
GND on BOTTOM (solid shape): 107.05,105.22 107.05,105 106.53,104.47 106.53,104.22 106.42,104.12 106.25,104.12 106.17,104.2 106.17,104.53 106.91,105.27 107,105.27
GND on BOTTOM (solid shape): 150.1,54.06 150.1,51.02 149.65,50.57 143.68,50.57 143.05,51.21 143.05,52.68 143.44,53.07 146.54,53.07 147.8,54.33 149.83,54.33
GND on BOTTOM (solid shape): 351.67,64.23 351.67,59.11 351.42,58.85 349.25,58.85 349.07,59.03 349.07,64.39 349.23,64.55 349.62,64.55 349.63,64.55 351.35,64.55
GND on BOTTOM (solid shape): 19.86,99.32 19.86,97.54 19.94,97.46 20.75,97.46 20.85,97.36 20.85,97 20.75,96.9 18.13,96.9 17.45,97.58 17.45,99.45 17.64,99.64 19.54,99.64
GND on BOTTOM (solid shape): 21.92,95.1 21.92,92.86 21.61,92.56 19.02,92.56 18.92,92.66 18.92,93.09 19,93.17 19,94.74 19.12,94.87 20.87,94.87 21.15,95.15 21.87,95.15
GND on BOTTOM (solid shape): 77.83,6.51 77.83,3.45 77.69,3.31 75.21,3.31 75.04,3.48 75.04,5.19 75.15,5.31 76.98,5.31 77.16,5.49 77.16,6.46 77.3,6.6 77.75,6.6
GND on BOTTOM (solid shape): 112.42,127.79 112.42,123.82 112.09,123.49 110.89,123.49 110.88,123.51 109.99,123.51 109.7,123.8 109.7,127.61 110.21,128.12 112.09,128.12
GND on BOTTOM (solid shape): 149.83,65.81 149.83,64.62 149.73,64.52 149.48,64.52 149.27,64.31 149.27,62.99 149.07,62.79 148.33,62.79 148.18,62.94 148.18,65.89 148.23,65.94 149.7,65.94
GND on BOTTOM (solid shape): 36.08,60.38 36.08,55.45 36,55.37 34.98,55.37 34.76,55.59 34.76,60.26 34.94,60.44 36.02,60.44
GND on BOTTOM (solid shape): 55.72,124.74 55.72,123.88 55.59,123.75 54.85,123.75 54.62,123.52 54.62,123.52 52.22,123.52 52.22,124.56 52.23,124.68 52.24,124.8 52.24,124.98 55.48,124.98
GND on BOTTOM (solid shape): 73.58,10.11 73.58,5.56 73.5,5.49 72.06,5.49 71.9,5.64 71.9,8.46 71.65,8.71 71.24,8.71 70.98,8.98 70.98,10 71.22,10.24 73.45,10.24
GND on BOTTOM (solid shape): 223.88,25.36 223.88,24.22 223.76,24.09 223.31,24.09 223.06,24.35 221.15,24.35 220.96,24.54 220.96,24.85 221.09,24.98 222.17,24.98 222.49,25.3 222.49,25.55 222.55,25.62 223.63,25.62
GND on BOTTOM (solid shape): 9.19,110.39 10.57,110.39 10.74,110.21 10.74,109.82 10.28,109.36 9.98,109.36 9.28,110.06 9.14,110.06 8.71,110.49 8.56,110.49 8.44,110.61 8.44,110.72 8.51,110.78 8.79,110.78
GND on BOTTOM (solid shape): 73.68,113.97 73.68,112.22 73.53,112.06 72.64,112.06 72.49,112.22 72.49,113.89 71.92,114.46 70.42,114.46 70,114.88 70,115.8 70.09,115.89 71.76,115.89
GND on BOTTOM (solid shape): 312.82,34.47 312.82,33.1 312.97,32.94 312.97,32.49 312.92,32.44 311.2,32.44 311.12,32.51 311.12,32.87 311.18,32.93 311.81,32.93 311.93,33.06 311.93,33.38 312.11,33.55 312.11,34.58 312.15,34.62 312.67,34.62
GND on BOTTOM (solid shape): 9.54,36.7 9.54,36.18 9.98,35.74 11.92,35.74 11.98,35.68 11.98,32.74 10.95,31.7 6.99,31.7 6.94,31.75 6.94,32.27 6.98,32.31 7.58,32.31 7.8,32.53 7.8,36.08 8.53,36.81 9.43,36.81
GND on BOTTOM (solid shape): 14.7,14.81 14.7,11.07 14.4,10.77 13.97,10.77 11.88,8.69 9.32,8.69 8.81,9.19 8.81,13.31 9.22,13.72 9.42,13.72 9.72,14.02 10.33,14.02 11.62,15.32 14.19,15.32
GND on BOTTOM (solid shape): 33.97,4.6 33.97,4.08 34.11,3.94 35.72,3.94 35.8,3.86 35.8,1.9 35.48,1.59 28.69,1.59 28.68,1.59 27.76,1.59 27.35,2.01 27.35,4.37 27.83,4.85 33.71,4.85
GND on BOTTOM (solid shape): 104.69,96.53 104.69,94.81 104.61,94.72 104.3,94.72 104.14,94.57 104.14,93.99 104.02,93.88 103.06,93.88 102.93,94.01 102.93,95.59 103.99,96.66 104.57,96.66
GND on BOTTOM (solid shape): 33.94,86.24 33.94,84.47 33.8,84.33 32.97,84.33 32.81,84.48 32.81,84.68 32.81,84.68 32.81,85.29 32.75,85.36 32.75,85.78 32.85,85.88 33.07,85.88 33.23,86.03 33.23,86.18 33.33,86.28 33.53,86.28 33.56,86.31 33.87,86.31
GND on BOTTOM (solid shape): 44.4,8.81 44.4,8.37 44.56,8.21 46.2,8.21 46.22,8.19 46.22,7.26 46.14,7.18 43.54,7.18 42.39,8.33 40.92,8.33 40.74,8.51 40.08,8.51 40.05,8.53 40.05,9.52 40.59,10.06 43.15,10.06
GND on BOTTOM (solid shape): 104.63,6.44 104.63,6.05 104.76,5.92 105.5,5.92 105.55,5.87 105.55,4.98 105.26,4.7 97.71,4.7 97.48,4.93 97.48,6.35 97.74,6.6 104.47,6.6
GND on BOTTOM (solid shape): 139.21,131.77 139.21,130.45 139.65,130.02 139.65,128.4 139.56,128.31 139.05,128.31 139.04,128.3 137.46,128.3 137.26,128.5 137.26,131.65 136.9,132 136.17,132 136.14,132.03 136.14,133.45 136.22,133.53 137.46,133.53
GND on BOTTOM (solid shape): 103.91,12.19 104.06,12.19 104.34,11.91 104.5,11.91 104.56,11.86 104.56,11.12 104.43,11 100.69,11 100.5,11.05 100.32,11 98.83,11 98.75,11.07 98.75,12.22 99.08,12.55 103.55,12.55
GND on BOTTOM (solid shape): 123.06,5.69 123.06,5.38 122.88,5.21 122.07,5.21 121.84,4.98 121.84,3.43 121.61,3.2 116.99,3.2 116,4.19 116,5.51 116.1,5.61 116.99,5.61 117.31,5.29 117.31,4.55 117.83,4.04 120.54,4.04 120.87,4.37 120.87,5.41 121.33,5.87 122.88,5.87
GND on BOTTOM (solid shape): 139.62,108.33 140.64,108.33 140.86,108.1 140.86,107.85 140.67,107.66 137.88,107.66 137.61,107.92 134.9,107.92 134.84,107.98 134.83,108.8 134.64,109.6 134.64,109.65 135.17,110.18 137.77,110.18
GND on BOTTOM (solid shape): 12.7,125.88 13.3,125.69 13.93,125.63 14.28,125.63 14.38,125.54 14.38,124.08 14.02,123.72 13.51,123.72 12.97,124.26 11.38,124.26 11.04,124.59 11.04,125.64 11.29,125.88 12.69,125.88
GND on BOTTOM (solid shape): 85.1,98.43 85.55,98.43 85.62,98.36 87.78,98.36 87.96,98.18 87.96,96.73 87.88,96.66 86.84,96.66 86.77,96.72 86.77,97.83 86.61,97.99 85.46,97.99 85.28,97.81 84.12,97.81 84.07,97.85 84.07,98.47 84.13,98.53 85,98.53
GND on BOTTOM (solid shape): 152.37,60.6 152.37,58.93 152.29,58.85 151.58,58.85 151.38,58.65 151.38,57.33 151.71,57 156.16,57 156.46,57.3 157.67,57.3 157.97,57.01 157.97,55.6 157.75,55.38 156.03,55.38 156.03,55.37 149.83,55.37 149.73,55.47 149.73,57.78 150.57,58.62 150.57,60.6 150.64,60.68 152.29,60.68
GND on BOTTOM (solid shape): 64.18,114.96 65.71,114.96 65.83,115.09 66.5,115.09 66.59,115.07 66.69,115.09 66.87,115.09 67.1,114.86 67.1,113.32 67.47,112.95 71.69,112.95 72.08,112.56 72.08,111.57 71.64,111.12 62.81,111.12 62.33,111.61 61.57,111.61 61.13,112.04 61.13,115.59 61.39,115.85 63.29,115.85
GND on BOTTOM (solid shape): 46.17,11.63 46.17,10.59 46.38,10.39 46.38,9.35 46.22,9.19 46.22,8.48 46.17,8.43 45.94,8.43 45.87,8.51 45.87,8.56 45.87,8.91 45.87,8.93 45.87,9.69 45.54,10.02 45.54,10.41 45.18,10.77 44.7,10.77 44.52,10.95 44.52,11.71 44.62,11.81 46,11.81
GND on BOTTOM (solid shape): 61.01,85.65 61.01,85.18 60.49,84.66 60.49,80.01 59.74,79.25 57.39,79.25 56.88,79.76 55.74,79.76 55.24,79.26 54.85,79.26 54.78,79.33 54.78,80.01 54.91,80.14 54.91,81.67 54.69,81.88 54.39,81.88 54.25,82.02 54.25,85.15 54.39,85.29 54.97,85.29 55.41,84.86 59.18,84.86 59.49,85.17 59.49,85.76 59.66,85.93 60.73,85.93
GND on BOTTOM (solid shape): 33.63,110.97 33.63,109.83 33.91,109.55 33.91,106.45 33.74,106.29 32.17,106.29 31.54,105.66 30.87,105.66 30.73,105.52 30.73,104.85 30.73,104.85 30.73,102.49 30.58,102.34 29.76,102.34 29.38,102.72 29.38,103.56 29.82,103.99 29.82,108.25 30.81,109.24 31.97,109.24 32.33,109.6 32.33,110.92 32.56,111.15 33.45,111.15
GND on BOTTOM (solid shape): 94.43,98.73 94.43,98.67 94.59,98.5 94.95,98.5 94.99,98.46 97.47,98.46 97.52,98.41 97.52,96.76 97.5,96.74 97.28,96.74 97.28,96.74 96.37,96.74 96.31,96.81 96.31,97.97 96.15,98.12 94.97,98.12 94.89,98.04 93.44,98.04 93.44,98.69 93.51,98.76 94.4,98.76
GND on BOTTOM (solid shape): 24.19,39.73 24.19,36.54 23.86,36.2 23.86,33.01 22.49,31.64 22.49,26.9 21.55,25.96 21.55,25.95 21.21,25.6 21.21,23.79 20.8,23.38 19.64,23.38 19.43,23.6 19.43,25.27 20.46,26.3 20.46,32.3 20.66,32.5 20.66,35.85 20.71,35.9 20.71,39.84 20.91,40.04 23.87,40.04
GND on BOTTOM (solid shape): 68.5,67.28 68.5,64.72 67.92,64.13 67.18,64.13 66.11,63.07 66.1,63.07 65.69,62.66 65.69,61.47 62.89,58.66 59.8,58.66 59.46,59 59.46,60.93 60.09,61.57 62.58,61.57 64.69,63.68 64.69,64.9 64.92,65.13 66.23,65.13 67.1,66 67.1,66.26 67.1,66.27 67.1,67.39 67.26,67.54 68.25,67.54
GND on BOTTOM (solid shape): 343.21,11.51 343.21,7.43 342.99,7.2 340.4,7.2 340.24,7.35 340.24,8.8 342.4,8.8 342.4,8.81 342.9,8.81 342.9,10.07 342.71,10.07 342.71,8.81 342.4,8.81 342.4,10.05 342.2,10.05 342.2,8.8 340.24,8.8 340.24,8.81 341.9,8.81 341.9,10.03 341.55,10.03 341.55,8.81 340.24,8.81 340.24,11.63 340.51,11.9 342.82,11.9
GND on BOTTOM (solid shape): 125.95,9.75 125.95,9.6 125.96,9.52 125.98,9.44 125.98,9.37 125.85,9.25 125.48,9.25 125.42,9.22 125.04,9.22 124.99,9.22 124.79,9.02 124.76,8.99 124.35,8.99 122.2,8.99 121.84,9.35 121.36,9.35 121.26,9.45 121.26,9.75 121.31,9.8 125.9,9.8
GND on BOTTOM (solid shape): 91.56,104.16 91.56,102.16 91.56,102.16 91.77,101.96 94.26,101.96 94.61,101.62 94.61,99.4 94.47,99.27 91.88,99.27 91.68,99.47 91.68,100.42 91.43,100.67 90.58,100.67 90.42,100.51 90.42,96.79 90.28,96.66 89.26,96.66 89.12,96.8 89.12,97.33 89.12,97.33 89.12,97.43 89.04,97.52 88.31,97.52 88.25,97.57 88.25,100.84 88.73,101.32 88.73,103.98 89.25,104.5 91.22,104.5
GND on BOTTOM (solid shape): 131.44,136.36 131.44,134.31 131.02,133.9 128.9,133.9 128.65,134.15 128.65,135.37 128.47,135.55 127.2,135.55 127.12,135.47 127.12,134.89 127.02,134.78 126.22,134.78 126.11,134.67 125.03,134.67 124.84,134.48 124.84,130.92 124.15,130.22 124.15,129.49 124.12,129.36 124.14,129.23 124.14,129.21 124.15,129.2 124.15,129.03 124.03,128.9 123.74,128.9 123.7,128.94 123.7,128.95 123.57,129.08 123.57,129.46 123.32,129.72 122.63,129.72 122.58,129.77 122.58,130.53 123.54,131.5 123.54,136.46 123.83,136.75 131.05,136.75
GND on BOTTOM (solid shape): 110.27,105.91 110.28,105.91 110.28,105.86 110.52,105.86 110.52,106.02 110.52,106.02 110.52,106.56 110.71,106.56 110.78,106.49 110.78,105.7 110.82,105.66 110.82,103.61 111.04,103.38 111.04,101.62 110.87,101.45 110.87,100.61 110.69,100.43 108.35,100.43 108.09,100.69 108.09,101.64 108.29,101.64 108.38,101.73 108.55,101.76 108.64,101.62 108.64,101.28 108.79,101.13 109.5,101.13 109.52,101.14 109.62,101.14 109.75,101.27 109.75,104.88 109.67,104.95 109.67,105.46 110.02,105.8 110.02,106.5 110.07,106.56 110.27,106.56
GND on BOTTOM (solid shape): 98.29,103.56 98.29,102.48 98.3,102.48 98.46,102.31 98.93,102.31 99.14,102.1 99.14,101.71 99.25,101.6 100.02,101.6 100.67,102.24 102.32,102.24 102.43,102.14 102.43,100.82 102.2,100.58 100.07,100.58 99.9,100.41 99.9,96.88 99.75,96.73 98.77,96.73 98.73,96.77 98.73,97.25 98.68,97.31 98.15,97.31 98.06,97.21 98.06,95.79 97.99,95.72 97.85,95.72 97.72,95.85 97.72,96.53 97.75,96.55 97.75,97.72 97.75,97.72 97.75,98.33 97.75,101.34 97.36,101.73 97.23,101.73 97.13,101.82 97.13,103.5 97.24,103.61 98.24,103.61
GND on BOTTOM (solid shape): 81.81,8.1 81.81,7.87 82.02,7.66 83.42,7.66 83.42,7.67 83.59,7.67 83.59,7.66 83.9,7.66 83.99,7.57 85.7,7.57 85.95,7.31 87.04,7.31 87.42,7.7 88.49,7.7 88.82,7.37 89.17,7.37 89.21,7.36 89.25,7.36 89.88,7.36 89.92,7.36 90.08,7.36 90.09,7.35 90.18,7.35 90.29,7.47 90.83,7.47 90.88,7.52 91.73,7.52 91.84,7.4 91.84,7.11 91.73,7 89.98,7 89.96,7.01 89.02,7.01 88.64,6.63 86.99,6.63 86.89,6.53 85.47,6.53 85.31,6.37 82.8,6.37 82.74,6.44 81.87,6.44 81.86,6.45 80.01,6.45 79.78,6.68 79.78,8.12 79.99,8.33 81.58,8.33
GND on BOTTOM (solid shape): 149.74,20.45 149.9,20.37 150.08,20.39 150.17,20.38 150.22,20.3 150.22,16.72 150.24,16.7 150.26,16.59 150.17,16.53 150.06,16.53 149.84,16.67 149.59,16.61 149.49,16.6 149.43,16.69 149.43,18.1 149.04,18.5 149.02,18.61 149.11,18.67 149.32,18.67 149.55,18.9 149.55,20.32 149.71,20.48
GND on BOTTOM (solid shape): 142.97,21.45 143.01,21.43 143.05,21.38 142.22,20.55 142.22,19.37 142.23,19.27 142.14,19.21 141.8,19.21 141.59,19.01 141.52,18.98 141.44,19.01 141.32,19.09 141.16,19.11 141.14,19.11 140.9,19.35 140.9,20.04 140.94,20.13 141.04,20.13 141.37,20.17 141.51,20.47 141.5,20.5 142.4,21.39 142.47,21.42 142.54,21.39 142.74,21.32 142.93,21.43
GND on BOTTOM (solid shape): 359.38,63.42 359.33,63.41 358.89,62.62 359.58,62.05 370.4,62.05 370.83,61.92 371.12,61.59 371.18,61.42 371.2,61.25 371.2,54.74 371.17,54.62 371.11,54.53 370.7,54.12 370.55,53.89 370.5,53.62 370.5,52.35 369.24,52.35 368.98,52.6 368.98,54.89 368.09,55.78 365.3,55.78 364.92,55.4 359.71,55.4 357.12,57.99 357.12,61.42 358.42,62.72 358.54,63.27 358.92,63.7 358.92,63.71 359.38,63.71
GND on BOTTOM (solid shape): outline of 86 points within 66.32,95.56 85.72,105.84
GND on BOTTOM (solid shape): 122.01,115.37 122.01,113.28 117.52,108.79 108.47,108.79 108.47,108.79 105.43,108.79 105.41,108.76 104.92,108.76 103.58,107.42 103.58,105.89 103.91,105.56 104.42,105.56 104.52,105.66 104.52,107.34 105.48,108.31 107.64,108.31 107.94,108 107.94,107.23 107.86,107.17 107.76,107.18 107.62,107.2 107.49,107.15 107.4,107.11 107.15,107.2 106.9,107.11 106.65,107.2 106.4,107.11 106.15,107.2 105.9,107.11 105.65,107.2 105.4,107.11 105.31,107.15 105.23,107.19 105.14,107.2 104.95,107.2 104.77,107.02 104.77,105.27 104.59,105.09 101.99,105.09 101.16,105.92 101.16,110.39 102.08,111.3 112.19,111.3 116.62,115.73 118.63,115.73 118.63,115.66 118.99,115.31 119.34,115.67 119.34,115.75 121.63,115.75
GND on BOTTOM (solid shape): 141.46,16.89 141.52,16.82 141.8,16.53 142.54,16.53 142.8,16.28 142.8,15.99 143.32,15.47 143.32,15.03 143.29,15 143.22,14.98 142.97,15.08 142.72,14.98 142.65,15 142.59,15.05 142.52,15.07 142.51,15.08 142.46,15.12 142.55,15.22 142.58,15.22 142.85,15.78 142.29,15.51 142.29,15.48 141.87,15.06 141.82,15.03 141.79,15 141.72,14.98 141.65,15 141.45,15.08 141.26,14.97 141.22,14.95 141.18,14.97 141.16,15 141.16,15.24 141.25,15.68 140.81,15.8 140.71,15.8 140.66,15.89 140.66,16.37 141.13,16.84 141.15,16.84 141.26,16.85 141.36,16.89
GND on BOTTOM (solid shape): 365.45,90.62 364.95,89.85 365.65,89.25 366.75,89.25 366.96,89.16 367.05,88.95 367.05,84.9 366.96,84.69 366.75,84.6 362.6,84.6 361.2,83.2 362.6,81.8 366.75,81.8 366.96,81.71 367.05,81.5 367.05,80.64 367.14,80.18 367.4,79.79 368.29,78.9 368.47,78.64 368.53,78.34 368.53,77.15 368.29,76.59 367.73,76.35 359.58,76.35 359.37,76.32 359.17,76.22 358.57,76.22 355.77,76.22 353.87,78.13 353.87,82.07 354.76,82.96 359.08,82.96 362.25,86.13 362.25,90.83 362.89,91.46 364.54,91.46 364.99,91.92 364.99,92.48 365.45,92.48
GND on BOTTOM (solid shape): 321.2,137.85 321.41,137.76 321.5,137.55 321.5,131.72 321.05,131.72 320.91,131.58 320.06,131.58 319.56,131.08 319.56,130.3 319.2,128.96 318.22,127.99 318.22,121.06 310.05,112.9 296.34,112.9 293.82,110.39 293.82,102.81 296.5,88.03 296.85,85.81 297.06,83.57 296.61,83.57 296.39,85.77 296.06,87.94 291.55,112.8 292.15,115.09 294.3,116.1 299.6,116.1 300.45,116.45 300.8,117.3 300.8,127.3 301.04,127.86 301.6,128.1 316.9,128.1 318.46,128.74 319.1,130.3 319.1,137.55 319.19,137.76 319.4,137.85
GND on BOTTOM (solid shape): 343.96,128.12 344.13,128.1 344.3,128.1 353.6,128.1 354.87,127.57 355.4,126.3 355.4,116.3 356.33,114.03 358.6,113.1 365.25,113.1 366.52,112.57 367.05,111.3 367.05,106.95 366.96,106.74 366.75,106.65 365.65,106.65 364.96,106.08 365.4,105.29 365.45,105.27 365.45,103.33 364.97,103.33 361.47,106.83 355.67,106.83 355.14,107.37 355.14,113.28 355.65,113.79 355.65,114.14 355.12,115.16 354.94,116.3 354.94,126.3 354.55,127.25 353.6,127.64 344.3,127.64 344.13,127.65 343.96,127.66
GND on BOTTOM (solid shape): outline of 88 points within 31.12,86.61 34.76,89.95
GND on BOTTOM (solid shape): outline of 337 points within 0.25,96.3 16.59,110.95
GND on BOTTOM (solid shape): 211.1,140.1 211.66,139.86 211.9,139.3 211.9,120.06 211.92,119.55 211.98,119.04 219.36,74.98 225.67,58.9 237.94,46.73 247.53,42.09 257.95,39.91 287.88,55.29 296.06,87.93 295.32,92.03 295.78,92.03 296.51,88.01 288.22,55 257.94,39.45 247.4,41.65 237.7,46.35 225.29,58.65 218.91,74.91 211.53,118.96 211.46,119.51 211.44,120.06 211.44,139.3 211.34,139.54 211.1,139.64 209.45,139.64 209.45,140.1
GND on BOTTOM (solid shape): outline of 119 points within 91.48,127.13 210.66,140.3
GND on BOTTOM (solid shape): outline of 154 points within 0.25,116.23 80.6,139
GND on BOTTOM (solid shape): outline of 191 points within 0,0.2 370.4,85.72
GND on BOTTOM (solid shape): outline of 20009 points within 25.94,10.77 180.94,32.79
GND on IN1 (solid shape): 91.85,7.99 91.85,7.5 91.84,7.5 91.86,7.48 91.86,7.1 91.75,6.99 90.14,6.99 89.94,6.79 87.69,6.79 87.49,6.99 87.49,7.88 87.79,8.18 91.65,8.18
GND on IN1 (solid shape): 24.23,39.28 24.23,28.69 21.84,26.3 21.84,23.71 21.13,23 21.13,22.27 20.04,21.18 20.04,17.53 19.49,16.98 15.97,16.98 15.42,17.53 13.08,17.53 12.3,18.3 12.3,21.68 12.7,22.07 18.63,22.07 19.07,22.52 19.07,27.95 20.3,29.18 20.3,30.44 20.16,30.59 20.16,35.35 20.71,35.9 20.71,39.81 20.82,39.93 23.58,39.93
GND on IN1 (solid shape): 359.38,63.42 359.33,63.41 358.89,62.62 359.58,62.05 370.4,62.05 370.83,61.92 371.12,61.59 371.18,61.42 371.2,61.25 371.2,54.74 371.17,54.62 371.11,54.53 370.7,54.12 370.55,53.89 370.5,53.62 370.5,52.35 370.04,52.35 370.04,53.62 370.13,54.07 370.38,54.44 370.74,54.8 370.74,57.88 370.12,58.5 357.86,58.5 357.12,59.23 357.12,61.42 358.42,62.72 358.54,63.27 358.92,63.7 358.92,63.71 359.38,63.71
GND on IN1 (solid shape): 365.45,90.62 364.95,89.85 365.65,89.25 366.75,89.25 366.96,89.16 367.05,88.95 367.05,84.9 366.96,84.69 366.75,84.6 362.6,84.6 361.2,83.2 362.6,81.8 366.75,81.8 366.96,81.71 367.05,81.5 367.05,80.64 367.14,80.18 367.4,79.79 368.29,78.9 368.47,78.64 368.53,78.34 368.53,77.15 368.29,76.59 367.73,76.35 359.58,76.35 359.37,76.32 359.17,76.22 358.57,76.22 355.77,76.22 353.87,78.13 353.87,86.89 355.33,88.35 356.6,88.35 359.71,91.46 364.54,91.46 364.99,91.92 364.99,92.48 365.45,92.48
GND on IN1 (solid shape): 321.2,137.85 321.41,137.76 321.5,137.55 321.5,131.72 321.05,131.72 320.91,131.58 320.06,131.58 319.56,131.08 319.56,130.3 319.2,128.96 318.22,127.99 318.22,121.06 310.05,112.9 296.34,112.9 293.82,110.39 293.82,102.81 296.5,88.03 296.85,85.81 297.06,83.57 296.61,83.57 296.39,85.77 296.06,87.94 291.55,112.8 292.15,115.09 294.3,116.1 299.6,116.1 300.45,116.45 300.8,117.3 300.8,127.3 301.04,127.86 301.6,128.1 316.9,128.1 318.46,128.74 319.1,130.3 319.1,137.55 319.19,137.76 319.4,137.85
GND on IN1 (solid shape): 343.96,128.12 344.13,128.1 344.3,128.1 353.6,128.1 354.87,127.57 355.4,126.3 355.4,116.3 356.33,114.03 358.6,113.1 365.25,113.1 366.52,112.57 367.05,111.3 367.05,106.95 366.96,106.74 366.75,106.65 365.65,106.65 364.96,106.08 365.4,105.29 365.45,105.27 365.45,103.33 364.97,103.33 361.47,106.83 355.67,106.83 355.14,107.37 355.14,113.28 355.65,113.79 355.65,114.14 355.12,115.16 354.94,116.3 354.94,126.3 354.55,127.25 353.6,127.64 344.3,127.64 344.13,127.65 343.96,127.66
GND on IN1 (solid shape): outline of 242 points within 162.78,5.59 176.23,9.45
GND on IN1 (solid shape): 124.06,56.87 124.14,56.83 124.16,56.73 124.29,56.31 124.74,56.35 124.81,56.38 124.88,56.35 125.32,56.31 125.46,56.73 125.47,56.83 125.55,56.87 134.21,56.87 138.53,52.55 138.53,52.25 138.48,52.17 138.38,52.16 138.17,52.19 137.98,52.1 137.91,52.07 137.84,52.1 137.81,52.12 137.79,52.16 137.81,52.2 137.86,52.71 137.34,52.73 137.27,52.7 137.2,52.73 137.19,52.74 137.16,52.83 137.22,52.91 137.14,53.59 136.84,52.97 136.87,52.88 136.81,52.8 136.6,52.55 136.7,52.23 136.72,52.16 136.7,52.09 136.6,51.78 136.8,51.52 128.68,51.52 126.78,53.41 126.8,53.93 126.28,53.92 125.83,54.37 124.84,54.37 124.25,54.96 123.94,54.96 123.94,55 123.91,55.03 123.91,55.04 123.42,55.58 122.69,55.51 122.68,55.5 122.37,55.5 122.07,55.8 122.07,56.41 122.53,56.87
GND on IN1 (solid shape): 211.1,140.1 211.66,139.86 211.9,139.3 211.9,120.06 211.92,119.55 211.98,119.04 219.36,74.98 225.67,58.9 237.94,46.73 247.53,42.09 257.95,39.91 287.88,55.29 296.06,87.93 295.32,92.03 295.78,92.03 296.51,88.01 288.22,55 257.94,39.45 247.4,41.65 237.7,46.35 225.29,58.65 218.91,74.91 211.53,118.96 211.46,119.51 211.44,120.06 211.44,139.3 211.34,139.54 211.1,139.64 209.45,139.64 209.45,140.1
GND on IN1 (solid shape): outline of 566 points within 27.25,11.81 40.21,35.64
GND on IN1 (solid shape): outline of 137 points within 91.48,127.13 210.64,140.1
GND on IN1 (solid shape): outline of 178 points within 0.25,96.67 80.6,139
GND on IN1 (solid shape): outline of 173 points within 0.2,0.2 370.2,85.72
GND on IN1 (solid shape): outline of 1451 points within 112.67,11.94 179.75,59.99
GND on IN1 (solid shape): outline of 1654 points within 32.46,13.99 57.2,45.77
GND on IN1 (solid shape): outline of 2104 points within 52.43,13.51 104.38,50.25
GND on IN2 (solid shape): 50.49,74.98 50.49,63.67 49.03,62.21 43.84,62.21 43.68,62.37 43.68,63.67 43.87,63.86 45.22,63.86 45.57,64.21 45.57,70.34 46.3,71.07 46.3,73.79 47.74,75.23 50.24,75.23
GND on IN2 (solid shape): 92.22,103.09 92.22,97.14 91.81,96.73 88.88,96.73 88.13,97.48 88.13,101.99 87.81,102.31 85.44,102.31 82.97,104.78 82.97,106.44 83.36,106.83 88.48,106.83
GND on IN2 (solid shape): 24.37,39.19 24.37,30.18 24.33,30.15 24.33,28.44 22.64,26.75 22.64,22.01 20.04,19.41 20.04,17.44 19.52,16.92 15.94,16.92 15.31,17.55 13.27,17.55 12.62,18.2 12.62,21.79 12.79,21.96 18.35,21.96 18.93,22.54 18.93,27.52 20.35,28.94 20.35,35.54 20.67,35.87 20.67,39.73 20.93,39.98 23.58,39.98
GND on IN2 (solid shape): 359.38,63.43 359.33,63.41 358.89,62.62 359.58,62.05 370.4,62.05 370.96,61.81 371.2,61.25 371.2,55.52 370.74,55.52 370.74,57.88 370.12,58.5 357.86,58.5 357.12,59.23 357.12,61.42 358.42,62.72 358.54,63.27 358.92,63.7 358.92,63.71 359.38,63.71
GND on IN2 (solid shape): 81.73,8.58 81.85,8.53 81.88,8.41 82.13,8.01 82.56,8.21 82.58,8.25 85.4,8.25 85.62,8.18 85.84,8.25 91.68,8.25 91.97,7.96 91.97,6.74 91.42,6.19 91.02,6.34 90.76,6.09 90.75,6.04 86.48,6.04 86.25,6.12 86.03,6.04 85.87,6.04 85.64,6.12 85.42,6.04 80.39,6.04 80.34,6.11 80.27,6.16 79.77,6.65 79.77,7.63 80.73,8.58
GND on IN2 (solid shape): 359.38,63.42 359.33,63.41 358.89,62.62 359.58,62.05 370.4,62.05 370.83,61.92 371.12,61.59 371.18,61.42 371.2,61.25 371.2,54.74 371.17,54.62 371.11,54.53 370.7,54.12 370.55,53.89 370.5,53.62 370.5,52.35 370.04,52.35 370.04,53.62 370.13,54.07 370.38,54.44 370.74,54.8 370.74,57.88 370.12,58.5 357.86,58.5 357.12,59.23 357.12,61.42 358.42,62.72 358.54,63.27 358.92,63.7 358.92,63.71 359.38,63.71
GND on IN2 (solid shape): 365.45,90.62 364.95,89.85 365.65,89.25 366.75,89.25 366.96,89.16 367.05,88.95 367.05,84.9 366.96,84.69 366.75,84.6 362.6,84.6 361.2,83.2 362.6,81.8 366.75,81.8 366.96,81.71 367.05,81.5 367.05,80.64 367.14,80.18 367.4,79.79 368.29,78.9 368.47,78.64 368.53,78.34 368.53,77.15 368.29,76.59 367.73,76.35 359.58,76.35 359.37,76.32 359.17,76.22 358.57,76.22 355.77,76.22 353.87,78.13 353.87,86.89 355.33,88.35 356.6,88.35 359.71,91.46 364.54,91.46 364.99,91.92 364.99,92.48 365.45,92.48
GND on IN2 (solid shape): 321.2,137.85 321.41,137.76 321.5,137.55 321.5,131.72 321.05,131.72 320.91,131.58 320.06,131.58 319.56,131.08 319.56,130.3 319.2,128.96 318.22,127.99 318.22,121.06 310.05,112.9 296.34,112.9 293.82,110.39 293.82,102.81 296.5,88.03 296.85,85.81 297.06,83.57 296.61,83.57 296.39,85.77 296.06,87.94 291.55,112.8 292.15,115.09 294.3,116.1 299.6,116.1 300.45,116.45 300.8,117.3 300.8,127.3 301.04,127.86 301.6,128.1 316.9,128.1 318.46,128.74 319.1,130.3 319.1,137.55 319.19,137.76 319.4,137.85
GND on IN2 (solid shape): 343.96,128.12 344.13,128.1 344.3,128.1 353.6,128.1 354.87,127.57 355.4,126.3 355.4,116.3 356.33,114.03 358.6,113.1 365.25,113.1 366.52,112.57 367.05,111.3 367.05,106.95 366.96,106.74 366.75,106.65 365.65,106.65 364.96,106.08 365.4,105.29 365.45,105.27 365.45,103.33 364.97,103.33 361.47,106.83 355.67,106.83 355.14,107.37 355.14,113.28 355.65,113.79 355.65,114.14 355.12,115.16 354.94,116.3 354.94,126.3 354.55,127.25 353.6,127.64 344.3,127.64 344.13,127.65 343.96,127.66
GND on IN2 (solid shape): outline of 242 points within 162.78,5.59 176.23,9.45
GND on IN2 (solid shape): 211.1,140.1 211.66,139.86 211.9,139.3 211.9,120.06 211.92,119.55 211.98,119.04 219.36,74.98 225.67,58.9 237.94,46.73 247.53,42.09 257.95,39.91 287.88,55.29 296.06,87.93 295.32,92.03 295.78,92.03 296.51,88.01 288.22,55 257.94,39.45 247.4,41.65 237.7,46.35 225.29,58.65 218.91,74.91 211.53,118.96 211.46,119.51 211.44,120.06 211.44,139.3 211.34,139.54 211.1,139.64 209.45,139.64 209.45,140.1
GND on IN2 (solid shape): outline of 133 points within 91.48,127.13 210.66,140.1
GND on IN2 (solid shape): outline of 178 points within 0.25,96.67 80.6,139
GND on IN2 (solid shape): outline of 179 points within 0.2,0.2 370.2,85.72
GND on IN3 (solid shape): 50.47,74.95 50.47,73.07 50.49,73.05 50.49,63.67 49.03,62.21 43.84,62.21 43.68,62.37 43.68,63.67 43.87,63.86 45.22,63.86 45.57,64.21 45.57,70.34 46.3,71.07 46.3,73.48 48.03,75.21 50.22,75.21
GND on IN3 (solid shape): 81.88,8.32 82.23,7.99 82.59,8.32 82.77,8.32 83.06,8.03 87.44,8.03 87.45,8.04 91.45,8.04 91.89,7.59 91.89,6.62 91.6,6.32 91.5,6.25 91.42,6.16 91.09,6.35 90.77,6.13 80.32,6.13 80.18,6.2 80.03,6.21 79.56,6.68 79.56,7.43 80.45,8.32
GND on IN3 (solid shape): 33.49,31.17 33.49,31.15 32.95,30.61 32.95,29.88 27.15,24.08 27.15,23.96 26.69,23.5 26.69,19.33 26.69,19.13 26.65,19.1 26.57,19.05 26.5,18.99 26.43,18.93 26.37,18.86 26.31,18.79 26.28,18.78 26.26,18.78 26.23,18.78 26.2,18.8 26.18,18.81 26.17,18.84 26.16,18.88 26.16,26.97 30.7,31.52 30.7,31.53 30.85,31.67 33.52,31.67 36.14,34.29 36.14,36.02 36.82,36.7 37.33,36.7 37.34,36.65 37.35,36.6 37.37,36.55 37.4,36.5 37.43,36.46 37.47,36.42 37.51,36.39 37.56,36.37 37.61,36.35 37.66,36.35 37.72,36.35 37.77,36.35 37.82,36.37 37.87,36.39 37.91,36.42 37.95,36.46 37.98,36.5 38.01,36.55 38.03,36.6 38.04,36.65 38.05,36.7 38.04,36.76 38.03,36.81 38.01,36.86 37.98,36.9 37.95,36.95 37.91,36.98 37.87,37.01 37.82,37.03 37.77,37.05 37.72,37.06 37.66,37.06 37.61,37.05 37.56,37.03 37.51,37.01 37.47,36.98 37.43,36.95 37.4,36.9 37.37,36.86 37.35,36.81 37.34,36.76 37.33,36.7 36.82,36.7 37.79,37.67 39.52,37.67 43.33,41.48 43.8,41.48
GND on IN3 (solid shape): 359.38,63.42 359.33,63.41 358.89,62.62 359.58,62.05 370.4,62.05 370.83,61.92 371.12,61.59 371.18,61.42 371.2,61.25 371.2,54.74 371.17,54.62 371.11,54.53 370.7,54.12 370.55,53.89 370.5,53.62 370.5,52.35 370.04,52.35 370.04,53.62 370.13,54.07 370.38,54.44 370.74,54.8 370.74,57.88 370.12,58.5 357.86,58.5 357.12,59.23 357.12,61.42 358.42,62.72 358.54,63.27 358.92,63.7 358.92,63.71 359.38,63.71
GND on IN3 (solid shape): 365.45,90.62 364.95,89.85 365.65,89.25 366.75,89.25 366.96,89.16 367.05,88.95 367.05,84.9 366.96,84.69 366.75,84.6 362.6,84.6 361.2,83.2 362.6,81.8 366.75,81.8 366.96,81.71 367.05,81.5 367.05,80.64 367.14,80.18 367.4,79.79 368.29,78.9 368.47,78.64 368.53,78.34 368.53,77.15 368.29,76.59 367.73,76.35 359.58,76.35 359.37,76.32 359.17,76.22 358.57,76.22 355.77,76.22 353.87,78.13 353.87,86.89 355.33,88.35 356.6,88.35 359.71,91.46 364.54,91.46 364.99,91.92 364.99,92.48 365.45,92.48
GND on IN3 (solid shape): 321.2,137.85 321.41,137.76 321.5,137.55 321.5,131.72 321.05,131.72 320.91,131.58 320.06,131.58 319.56,131.08 319.56,130.3 319.2,128.96 318.22,127.99 318.22,121.06 310.05,112.9 296.34,112.9 293.82,110.39 293.82,102.81 296.5,88.03 296.85,85.81 297.06,83.57 296.61,83.57 296.39,85.77 296.06,87.94 291.55,112.8 292.15,115.09 294.3,116.1 299.6,116.1 300.45,116.45 300.8,117.3 300.8,127.3 301.04,127.86 301.6,128.1 316.9,128.1 318.46,128.74 319.1,130.3 319.1,137.55 319.19,137.76 319.4,137.85
GND on IN3 (solid shape): 343.96,128.12 344.13,128.1 344.3,128.1 353.6,128.1 354.87,127.57 355.4,126.3 355.4,116.3 356.33,114.03 358.6,113.1 365.25,113.1 366.52,112.57 367.05,111.3 367.05,106.95 366.96,106.74 366.75,106.65 365.65,106.65 364.96,106.08 365.4,105.29 365.45,105.27 365.45,103.33 364.97,103.33 361.47,106.83 355.67,106.83 355.14,107.37 355.14,113.28 355.65,113.79 355.65,114.14 355.12,115.16 354.94,116.3 354.94,126.3 354.55,127.25 353.6,127.64 344.3,127.64 344.13,127.65 343.96,127.66
GND on IN3 (solid shape): outline of 242 points within 162.78,5.59 176.23,9.45
GND on IN3 (solid shape): 211.1,140.1 211.66,139.86 211.9,139.3 211.9,120.06 211.92,119.55 211.98,119.04 219.36,74.98 225.67,58.9 237.94,46.73 247.53,42.09 257.95,39.91 287.88,55.29 296.06,87.93 295.32,92.03 295.78,92.03 296.51,88.01 288.22,55 257.94,39.45 247.4,41.65 237.7,46.35 225.29,58.65 218.91,74.91 211.53,118.96 211.46,119.51 211.44,120.06 211.44,139.3 211.34,139.54 211.1,139.64 209.45,139.64 209.45,140.1
GND on IN3 (solid shape): outline of 138 points within 91.48,127.13 210.67,140.1
GND on IN3 (solid shape): outline of 178 points within 0.25,96.67 80.6,139
GND on IN3 (solid shape): outline of 185 points within 0.2,0.2 370.2,85.72
GND on IN3 (solid shape): outline of 1114 points within 30.53,32.51 65.42,59.54
GND on IN3 (solid shape): outline of 4559 points within 75.46,54.87 117.67,62.53
GND on IN3 (solid shape): outline of 6398 points within 26.16,13.89 179.55,54.86
GND on TOP: 289.21,10.17 288.92,9.88 288.01,9.88 287.85,10.03 286.3,10.03 286.15,9.88 285.62,9.88 285.06,10.44 284.56,10.44 284.28,10.72 284.28,11.3 289.53,16.55 291.45,16.55 291.58,16.42 291.58,15.75 291.58,15.74 291.58,13.05 291.25,12.72 290.24,12.72 289.21,11.69
GND on TOP: outline of 136 points within 14.52,91.53 32.86,114.39
GND on TOP: 242.08,29.85 240.52,29.85 240.42,29.75 240.42,28.08 240.95,27.54 241.83,27.54 241.93,27.64 241.93,29.21 242.16,29.44 242.16,29.77
GND on TOP: 61.87,122.88 63.37,122.88 63.86,122.39 63.86,120.98 63.64,120.75 62.09,120.75 61.73,121.11 61.73,122.74
GND on TOP: 244.65,35.3 244.65,36.3 244.95,36.6 246.64,36.6 246.86,36.38 246.86,35.5 246.53,35.17 244.78,35.17
GND on TOP: 11.64,118.14 11.92,118.59 12.41,118.8 12.57,118.81 12.61,118.86 12.65,118.86 12.82,119.02 13.67,119.02 14.27,119.63 14.27,123.25 12.9,124.61 12.03,124.61 11.38,125.27 11.38,125.47 11.64,125.73 12.78,125.73 13.3,125.22 16.88,125.22 16.88,121.7 15.48,120.29 15.48,118.77 16.68,117.56 16.68,117.13 17.7,116.11 17.7,115.39 17.49,115.18 17.27,115.18 17.27,115.18 15.65,115.18 15.56,115.09 15.11,115.09 15.08,115.12 13.08,115.12 12.9,115.3 12.9,115.65 12.6,115.94 12.14,115.94 11.73,115.53 11.73,115.09 11.67,115.02 11.03,115.02 10.84,115.21 10.84,115.4 11.33,115.89 11.33,117.83
GND on TOP: 176.49,10.63 176.72,10.4 176.72,6.5 176.13,5.91 170.2,5.91 169.76,5.47 169.76,1.3 169.68,1.22 167.59,1.22 167.41,1.4 167.41,4.9 166.02,6.29 163.03,6.29 162.63,6.68 162.63,8.49 162.85,8.71 163.51,8.71 163.69,8.89 163.69,9.42 163.85,9.58 164.4,9.58 165.24,8.73 165.81,8.73 165.94,8.61 165.94,8.32 166.48,7.77 168.83,7.77 169.12,8.07 170.77,8.07 171.1,8.4 172.39,8.4 173.03,9.04 173.03,9.18 173.08,9.24 174.09,9.24 174.34,9.49 174.34,10.17 174.8,10.63
GND on TOP: outline of 166 points within 65.88,88.76 105.21,106.22 ; 1 cut-out
GND on TOP: 103.81,89.66 105.6,87.87 105.6,87.26 108.13,84.73 109.12,84.73 109.37,84.48 109.37,84.07 109.59,83.86 110.68,83.86 110.79,83.96 110.79,86.72 110.09,87.42 110.09,89.2 112.31,91.42 112.31,98.03 111.64,98.7 109.33,98.7 108.52,97.89 108.43,97.89 107.8,97.26 107.8,92.26 107.29,91.75 104.11,91.75 103.81,91.45
GND on TOP: 97.56,62.07 97.17,62.07 96.34,61.24 96.01,61.24 95.71,60.94 95.71,59.87 95.86,59.72 97.1,59.72 97.61,60.23 97.61,62.02
GND on TOP: 22.59,115.47 22.59,114.96 22.84,114.71 24.68,114.71 24.94,114.96 24.94,116.17 24.68,116.42 24.43,116.42 24.3,116.55 24.3,118.77 24.37,118.83 24.94,118.83 25.19,118.58 25.19,118.2 25.89,117.5 25.89,116.86 26.21,116.55 26.21,115.21 25.76,114.77 25.76,114.2 25.57,114.01 25.38,114.01 24.43,113.05 24.43,111.47 24.18,111.21 23.73,111.21 23.67,111.28 23.67,112.04 23.54,112.17 23.03,112.17 22.84,112.36 20.75,112.36 20.56,112.55 20.56,113.37 21.13,113.94 21.13,113.94 21.13,115.34 21.38,115.59 22.46,115.59
GND on TOP: 313.1,54.74 314.58,54.74 314.69,54.62 314.69,53.11 314.47,52.89 313.84,52.89 312.99,53.75 312.99,54.62
GND on TOP: 111.93,61.56 112.06,61.43 112.06,60.67 111.93,60.54 111.3,60.54 110.85,60.1 110.85,58.64 110.73,58.51 110.41,58.51 110.28,58.64 110.28,60.03 109.97,60.35 109.58,60.35 109.39,60.54 109.39,61.43 109.52,61.56
GND on TOP: 105.48,61.83 104.38,61.83 104.36,61.81 104.36,60.86 104.36,60.86 104.36,59.45 104.58,59.23 104.83,59.23 104.89,59.17 105.2,59.17 105.56,59.53 105.56,61.76
GND on TOP: 45.89,70.76 45.89,67.35 45.67,67.13 45.67,64.39 45.06,63.78 43.89,63.78 43.71,63.6 43.71,62.81 43.93,62.59 47.27,62.59 50.36,65.69 50.36,75.1 50.12,75.34 47.19,75.34 46.13,74.28 46.13,71.79 46.13,71.79 46.13,71
GND on BOTTOM: 65.53,86.17 62.74,86.17 62.48,86.42 62.48,89.34 62.74,89.6 65.53,89.6 65.78,89.34 65.78,86.42
GND on BOTTOM: 169.22,6.59 171.34,6.59 171.94,7.19 171.94,9.35 172.05,9.45 173.21,9.45 173.53,9.13 174.41,9.13 174.57,9.3 174.57,10.13 174.95,10.52 176.55,10.52 176.62,10.45 176.62,7.28 175.66,6.32 172.72,6.32 172.22,5.83 170.9,5.83 170.4,6.32 169.24,6.32 168.78,5.87 166.28,5.87 166.06,6.08 162.87,6.08 162.72,6.24 162.72,8.65 162.77,8.7 165.81,8.7 166.02,8.49 166.02,6.91 166.31,6.62 167.26,6.62 167.65,7.01 168.8,7.01
GND on BOTTOM: 23.22,119.06 23.22,116.67 23.35,116.55 23.86,116.55 23.99,116.67 25.45,116.67 25.64,116.86 25.64,118.9 25.29,119.25 23.41,119.25
GND on BOTTOM: 118.33,87.17 117.85,86.69 117.85,83.62 117.95,83.51 119.35,83.51 119.53,83.69 119.53,85.68 120.45,86.6 120.45,87.52 120.06,87.91 120.06,89.1 119.85,89.31 118.61,89.31 118.33,89.03
GND on BOTTOM: 12.4,118.76 12.35,118.81 9.53,118.81 9.41,118.93 9.41,119.1 9.62,119.32 10.84,119.32 10.85,119.31 14.31,119.31 14.32,119.32 18.4,119.32 18.69,119.02 19.41,119.02 19.67,118.77 19.67,117.18 19.16,116.67 17.16,116.67 16.62,117.21 16.62,117.76 15.86,118.52 15.86,118.52 15.73,118.64 14.02,118.64 13.89,118.52 13.35,118.52 13.11,118.76
GND on BOTTOM: 45.32,62.75 45.27,62.7 44.23,62.7 44.07,62.86 44.07,63.86 43.89,64.04 42.94,64.04 42.84,63.94 42.63,63.94 42.55,63.94 42.3,63.68 41.38,63.68 41.35,63.72 41.35,64.33 41.43,64.41 42.81,64.41 42.87,64.35 45.15,64.35 45.32,64.18
GND on BOTTOM: 107.74,89.24 107.74,89.23 107.74,86.89 107.44,86.59 102.59,86.59 102.54,86.54 102.54,85.65 102.59,85.6 107.49,85.6 108.3,84.79 108.3,84.79 109.11,83.98 110.07,83.98 110.22,84.14 110.22,84.73 110.33,84.85 110.75,84.85 110.83,84.92 110.83,86.57 110.64,86.75 110.19,86.75 110.03,86.92 110.03,87.78 109.77,88.04 109.25,88.04 109.25,88.03 108.61,88.03 108.07,88.57 108.07,89.92 108.1,89.94 108.71,89.94 108.73,89.92 108.73,89.41 108.76,89.38 109.9,89.38 110.08,89.56 110.08,93.54 110.32,93.79 111.6,93.79 113.15,95.33 113.65,95.33 113.91,95.59 113.91,97.39 113.7,97.59 109.35,97.59 108.87,97.11 108.87,96.27 108.88,96.27 108.88,94.91 108.53,94.56 107.65,94.56 107.6,94.51 107.87,94.24 107.87,91.19 107.74,91.05
GND on BOTTOM: 16.18,40.69 16.75,40.69 17.24,40.19 17.24,36.82 17.14,36.72 16.48,36.72 15.73,37.46 15.73,38.91 16.05,39.23 16.05,40.56
GND on BOTTOM: 46.14,71.01 45.89,70.76 45.89,67.3 45.63,67.03 45.63,64.41 45.47,64.25 45.47,62.49 45.51,62.45 45.51,59.21 46.53,58.19 47.93,58.19 48.05,58.32 48.05,59.66 46.33,61.39 46.02,61.39 45.87,61.54 45.87,63.21 45.92,63.26 46.44,63.26 46.51,63.19 46.51,62.72 46.55,62.68 47.67,62.68 47.88,62.89 47.88,66.57 48.18,66.87 48.18,69.49 49.32,70.64 51.61,70.64 53.01,72.03 53.01,74.83 52.88,74.95 51.1,74.95 50.77,75.29 49.78,75.29 47.72,73.23 47.72,72.21 47.04,71.53 46.66,71.53 46.4,71.27 46.4,71.27 46.15,71.01
GND on BOTTOM: 77.7,98.88 77.67,98.91 77.67,100.02 77.81,100.17 78.94,100.17 79.02,100.25 79.02,101.28 79.06,101.32 79.06,101.6 78.87,101.8 77.89,101.8 77.76,101.92 76.98,101.92 76.61,102.3 72.98,102.3 72.98,102.29 72.28,102.29 72.23,102.34 72.23,104.1 73.8,105.68 77.09,105.68 77.1,105.67 79.16,105.67 79.66,105.16 79.66,102.04 79.32,101.7 79.32,99.02 79.18,98.88
GND on BOTTOM: outline of 133 points within 197.79,27.35 208.3,36.87
GND on BOTTOM: 103.73,91.19 105,91.19 105.06,91.12 105.99,91.12 105.99,91.12 107.38,91.12 107.53,90.96 107.53,89.47 107.5,89.43 106.49,89.43 106.39,89.53 106.39,90.53 106.1,90.82 105.15,90.82 105.01,90.68 104.86,90.68 104.64,90.46 103.7,90.46 103.65,90.51 103.65,91.11
GND on BOTTOM: 69.9,98.73 69.83,98.66 68.38,98.66 68.33,98.71 68.33,99.79 68.36,99.82 69.41,99.82 69.46,99.87 69.47,99.87 69.54,99.94 69.54,100.89 68.79,101.64 68.79,102.85 68.86,102.92 69.61,102.92 69.68,102.85 69.69,102.85 69.71,102.83 69.71,101.22 69.9,101.02
GND on GND1: outline of 436 points within 0.2,0.2 371.2,140.1
GND on IN1: 109.42,15.93 109.35,15.89 109.27,15.92 108.22,16.98 108.19,17.08 108.28,17.15 109.24,18.03 108.6,19.17 108.55,19.24 108.56,19.33 108.62,19.69 108.33,19.91 107.99,19.75 107.98,19.37 107.99,19.28 107.93,19.22 107.39,18.87 107.14,18.28 107.08,18.2 106.97,18.22 106.73,18.47 106.73,20.65 107.13,21.06 107.77,21.06 107.85,21.02 107.87,20.94 108.23,20.52 108.58,20.94 108.6,21.02 108.68,21.06 114.17,21.06 114.31,20.96 114.29,20.8 114.54,20.2 114.8,20.8 114.77,20.96 114.91,21.06 130.53,21.06 131.24,20.34 131.24,15.39 130.92,15.07 110.27,15.07
GND on IN1: 46.25,9.85 46.41,9.68 46.41,7.28 46.01,6.87 37.26,6.87 36.79,7.34 36.79,10.78 37.42,11.42 39.89,11.42 41.66,13.19 44.92,13.19 45.17,12.94 45.17,12.62 46.25,11.54
GND on IN1: 46.3,71.07 45.57,70.34 45.57,64.21 45.22,63.86 43.87,63.86 43.68,63.67 43.68,62.37 43.84,62.21 47.14,62.21 48.17,63.24 48.17,67.37 50.46,69.66 50.49,69.66 50.49,73.05 50.48,73.07 50.48,74.99 50.29,75.17 49.11,75.17 46.3,72.37
GND on VCC: outline of 184 points within 1.17,1.17 220.42,139.13
GND on VCC: outline of 105 points within 292.5,35.97 370.23,136.88 ; 1 cut-out
GND on VCC: 81.71,1.17 81.71,5.46 80.54,6.63 78.68,6.63 75.89,3.83 43.84,3.83 42.82,4.85 38.51,4.85 36.56,6.8 36.56,10.29 35.65,11.2 26.44,11.2 24.11,13.53 24.11,28.56 40.5,44.94 40.5,57.81 42.36,57.81 42.61,57.56 52.1,57.56 54.25,59.71 72.42,59.71 74.96,62.25 82.11,62.25 83,61.37 83.89,61.37 84.52,60.73 102.68,60.73 102.94,60.48 116.15,60.48 117.04,59.59 120.21,59.59 120.46,59.33 141.93,59.33 142.29,58.97 142.29,53.89 144.21,51.97 149.93,51.97 172.39,29.51 172.39,27.22 174.54,25.07 174.54,15.12 174.31,14.88 138.12,14.88 136.97,13.74 109.5,13.74 105.94,17.3 103.45,17.3 102.66,16.51 102.66,1.17
GND on IN2: outline of 176 points within 24.3,14.62 135.84,62.7
GND on IN2: 46.41,7.28 46.01,6.87 37.26,6.87 36.79,7.34 36.79,10.78 37.42,11.42 39.89,11.42 41.66,13.19 44.92,13.19 45.5,12.61 45.5,12.49 46.41,11.57
GND on IN2: 66.77,98.45 67.94,98.45 68.93,99.44 69.66,99.44 70.26,98.84 77.08,98.84 78.26,100.03 80.8,100.03 81.88,98.95 82.77,98.95 82.94,98.78 82.93,98.78 82.93,95.74 82.71,95.53 66.69,95.53 66.27,95.94 66.27,97.95
GND on IN2: 97.85,104.08 100.56,104.08 101.06,103.58 101.06,102.83 101.45,102.44 102.35,102.44 102.71,102.07 102.71,99.17 100.29,96.75 97.1,96.75 96.53,97.33 96.53,102.76
GND on IN2: 112.4,97.69 112.4,90.62 111.15,89.38 107.51,89.38 106.6,90.29 106.6,90.78 107.67,91.85 107.67,97.18 108.44,97.94 112.15,97.94
GND on IN3: 108.39,99.49 107.89,98.99 107.89,91.27 107.44,90.81 106.87,90.81 106.71,90.65 106.71,89.42 106.91,89.22 111,89.22 112.52,90.74 112.52,99.03 112.06,99.49
GND on IN3: 66.72,95.71 66.3,96.12 66.3,98.34 66.41,98.45 67.28,98.45 68.47,99.63 69.5,99.63 70.73,98.4 73.71,98.4 74.02,98.72 74.02,101.26 78.78,106.02 90.37,106.02 94.08,102.3 94.08,100.64 95.21,99.52 97.53,99.52 97.7,99.68 97.7,101.79 98.22,102.31 102.2,102.31 102.6,101.9 102.6,97.28 101.83,96.51 90.49,96.51 90.18,96.82 83.2,96.82 82.58,96.21 82.55,96.21 82.05,95.71
GND on IN3: 6.14,119.28 15.22,119.28 16.24,118.26 16.24,115.79 15.54,115.09 10.97,115.09 10.84,115.21 10.84,115.79 10.71,115.91 8.81,115.91 8.24,115.34 6.71,115.34 6.46,115.09 6.46,111.98 6.59,111.85 7.03,111.85 7.29,112.1 7.29,112.23 7.67,112.61 12.3,112.61 13.32,111.59 16.24,111.59 16.81,111.02 16.81,106.77 16.37,106.32 10.78,106.32 8.49,108.61 6.08,108.61 5.7,108.99 5.7,118.83
GND on IN3: 40.76,8.3 42.05,8.3 43.12,7.22 46.1,7.22 46.55,7.67 46.55,11.55 46.22,11.88 45.19,11.88 44.94,11.63 43.77,11.63 43.04,12.37 40.8,12.37 40.17,11.73 40.17,8.89
GND on GND2: outline of 435 points within 0.2,0.2 371.2,140.1
GNDA on TOP (solid shape): 345.43,42.75 345.43,41.95 344.77,41.29 343.68,41.29 343.63,41.24 343.63,40.59 343.59,40.56 343.44,40.56 343.42,40.58 343.42,41.35 343.63,41.56 344.11,41.56 344.93,42.38 344.93,42.74 344.95,42.76 345.41,42.76
GNDA on BOTTOM (solid shape): 349.55,44.14 349.16,43.76 349.47,43.45 349.85,43.83 350.52,43.16 350.52,42.32 349.86,42.32 349.7,42.16 349.45,42.16 348.29,43.32 348.31,43.35 348.26,43.8 347.82,43.85 347.78,43.82 347.62,43.99 347.62,44.87 348.02,45.26 348.42,45.26
GNDA on GND1, GND2: outline of 81 points within 334.95,23.39 371.2,46
GNDA on VCC: 356.26,23.39 354.38,25.28 354.38,29.98 353.59,30.76 349.02,30.76 348.89,30.89 346.35,30.89 345.99,31.25 345.99,33.91 345.59,34.31 345.08,34.31 343.96,35.44 343.96,39.88 343.43,40.41 340.51,40.41 340.28,40.64 340.28,41.19 340.41,41.32 340.41,42.04 340.15,42.29 340.15,43.18 339.75,43.59 337.51,43.59 337.1,43.18 337.1,40.05 337.63,39.52 337.85,39.52 337.97,39.65 338.52,39.65 338.63,39.54 338.63,38.99 338.52,38.89 338.4,38.89 338.27,38.76 337.85,38.76 337.72,38.89 337.51,38.89 337.38,38.76 335.56,38.76 335.2,39.12 335.2,45.13 336.07,46 340.81,46 341.13,45.68 343.05,45.68 343.37,46 347.41,46 350.44,42.97 350.44,41.53 349.68,40.77 349.68,40.18 354.4,35.46 355.37,35.46 358.04,38.12 370.23,38.12 370.23,37.54 369.65,37.54 368.47,37.06 367.98,35.87 367.98,35.54 358.25,35.54 356.7,34.51 357.08,32.68 357.08,28.22 356.7,26.39 358.25,25.36 367.98,25.36 367.98,24.03 368,23.71 368.04,23.39
VCC_GT_B+ on IN3 (solid shape): 46.06,71.53 46.06,71.03 45.38,70.34 45.38,64.31 45.19,64.12 43.7,64.12 43.55,64.27 43.55,71.34 43.88,71.67 45.92,71.67
VCC_GT_B+ on TOP: 45.89,71.65 43.61,71.65 43.1,71.14 43.1,64.59 43.66,64.03 44.98,64.03 45.51,64.57 45.51,67.33 45.72,67.54 45.72,70.84 46.02,71.14 46.02,71.53
VCC_GT_B+ on BOTTOM: 43.02,71.45 43.02,66.22 43.23,66.01 44.01,66.01 44.14,65.89 44.14,64.54 44.22,64.46 45.21,64.46 45.39,64.64 45.39,67.18 45.73,67.52 45.73,70.93 47.09,72.3 47.09,74.94 46.97,75.05 44.48,75.05 43.61,74.19 43.61,72.03
VCC_GT_B+ on BOTTOM: 42.98,54.51 42.95,54.51 42.91,54.48 42.58,54.48 42.56,54.5 42.56,57.75 42.46,57.84 42.46,59.36 42.62,59.51 44.85,59.51 45.39,58.98 45.39,56.92
VCC_GT_B+ on IN1: 45.92,71.67 43.88,71.67 43.55,71.34 43.55,64.27 43.7,64.12 45.19,64.12 45.38,64.31 45.38,70.34 46.06,71.03 46.06,71.53
VCC_GT_B+ on IN2: 40.89,57.61 40.56,57.94 37.76,57.94 34.97,60.72 34.97,68.1 38.53,71.65 45.77,71.65 46.15,71.27 46.15,65.68 44.88,64.41 42.48,64.41 42.48,60.97 43.4,60.05 45.05,60.05 45.77,59.33 45.77,58.06 45.31,57.61
VCC_SA_B+ on TOP: 107.68,98.48 105.67,98.48 105.4,98.2 105.4,92.75 105.9,92.24 107.51,92.24 107.81,92.54 107.81,98.35
VCC_SA_B+ on BOTTOM: 104.89,93.74 104.95,93.68 104.95,93.32 105.51,92.76 106.22,92.76 106.35,92.63 106.35,91.29 106.45,91.19 107.51,91.19 107.67,91.34 107.67,93.85 108.38,94.56 108.38,98.78 107.72,99.44 103.6,99.44 103.49,99.33 103.49,97.13 103.73,96.88 104.64,96.88 104.86,96.67 104.86,94.67 104.74,94.55 104.39,94.55 104.33,94.49 104.33,93.83 104.43,93.73 104.45,93.74
VCC_SA_B+ on IN3: 107.04,98.57 104.83,98.57 104.46,98.21 104.46,95.87 105.67,94.67 105.67,92.06 106.62,91.1 107.47,91.1 107.66,91.29 107.66,97.95
VDD_ISL88738 on TOP (solid shape): 11.85,38.16 11.85,37.4 10.92,36.47 10.92,35.45 10.85,35.38 10.78,35.38 10.7,35.46 10.7,36.64 11.15,37.08 11.15,38.11 11.22,38.19 11.82,38.19
VDDP_ISL88738 on TOP (solid shape): 11.31,32.11 11.31,31.32 11.81,30.82 11.81,30.38 11.74,30.31 11.44,30.31 11.31,30.44 11.31,30.66 11.11,30.86 11.11,32.12 11.15,32.16 11.26,32.16
VIN_1.8VALW on BOTTOM (solid shape): 116.72,7.15 116.72,6.67 116.86,6.53 119.22,6.53 119.33,6.43 119.33,5.23 119.58,4.98 120.42,4.98 120.49,4.9 120.49,4.47 120.27,4.24 120.24,4.27 117.85,4.27 117.5,4.62 117.5,5.33 117.04,5.78 115.82,5.78 115.27,6.32 115.27,7.12 115.46,7.31 116.55,7.31
VIN_1VS_VCCIO on BOTTOM (solid shape): 161.97,60.99 161.97,59.66 159.69,57.38 158.03,57.38 157.94,57.46 156.41,57.46 156.32,57.38 154.15,57.38 152.57,58.95 152.57,60.1 152.65,60.17 153.44,60.17 153.56,60.3 156.21,60.3 156.61,60.71 159.8,60.71 160.16,61.06 161.9,61.06
+AC_IN on TOP (solid shape): 34.18,120.2 34.18,119.1 35.11,116.86 37.35,115.93 45.29,115.93 45.41,115.81 45.41,115.39 45.41,115.39 45.41,113.28 45.23,113.11 34.59,113.11 30.88,116.81 30.88,119.05 28.98,120.95 24.55,120.95 24.19,121.31 24.19,121.82 24.74,121.82 24.74,122.52 24.19,122.52 24.19,123.02 24.74,123.02 24.74,123.72 24.19,123.72 24.19,124.37 24.56,124.74 29.64,124.74
+AC_IN on BOTTOM (solid shape): 33.85,120.52 33.85,117.98 35.96,115.87 39.14,115.87 39.16,115.85 44.95,115.85 45.41,115.39 45.41,113.28 45.18,113.05 34.29,113.05 30.65,116.69 30.65,118.87 28.57,120.95 26.39,120.95 25.92,121.42 25.11,121.42 24.97,121.56 24.97,123.98 25.19,124.21 30.17,124.21
+AC_IN on VCC: 34.7,113.94 28.75,119.89 28.75,121.16 26.49,123.4 26.49,123.79 26.82,124.1 29.41,124.1 31.29,122.22 31.29,120.63 36.2,115.72 45.08,115.72 45.21,115.59 45.21,114.33 44.82,113.94
+BL_PWR_SRC on TOP (solid shape): 118.14,110.54 118.72,110.54 118.72,111.09 119.82,111.09 120.01,110.9 120.01,108.36 119.98,108.23 120.01,108.09 120.01,107.67 119.43,107.09 117.11,107.09 115.93,105.91 115.93,102.33 115.37,101.77 115.32,101.75 115.28,101.72 114.18,101.72 113.82,102.07 113.82,107.33 113.84,107.34 113.84,110.38 114.16,110.71 117.34,110.71 117.34,110.54 117.36,110.53 117.93,110.53 117.93,111.09 118.14,111.09
+BL_PWR_SRC on BOTTOM (solid shape): 115.85,107 115.85,102.07 115.84,102.06 115.84,101.06 115.72,100.93 114.75,100.93 113.9,101.79 113.9,103.85 114.46,104.41 114.46,106.95 114.61,107.1 115.75,107.1
+BL_PWR_SRC_P on TOP (solid shape): 124.51,116.74 124.51,112.8 123.49,111.78 121.84,111.78 121.32,111.26 118.56,111.26 118.55,111.25 118.55,111.15 118.56,111.15 118.56,110.71 118.55,110.71 118.31,110.71 118.3,110.71 118.3,111.25 117.76,111.25 117.76,110.77 117.52,110.77 117.52,111.25 113.97,111.25 113.73,111.49 113.73,113.63 114.59,114.49 119.97,114.49 120.88,115.4 120.88,116.54 121.33,116.99 124.25,116.99
+CHARGER_SRC on TOP (solid shape): 20.89,41.24 20.89,40.23 20.54,39.89 20.54,36.32 20.75,36.12 20.75,36.09 20.95,35.89 22.96,35.89 23.1,35.75 23.1,32.54 24.2,31.43 24.2,30.07 24.05,29.92 22.58,29.92 22.5,30 22.5,31.18 22.26,31.42 18.55,31.42 18.55,35.58 17.4,36.74 17.4,40.92 17.78,41.3 20.82,41.3
+CHARGER_SRC on BOTTOM (solid shape): 18.63,44.2 18.65,44.2 18.65,44.18 19.36,44.18 19.36,44.2 19.38,44.2 19.38,44.7 19.83,44.7 19.83,44.2 19.85,44.2 19.85,44.18 20.56,44.18 20.56,44.2 20.58,44.2 20.58,44.7 21.27,44.7 21.59,44.39 21.59,41.25 20.53,40.19 20.53,36.44 20.52,36.42 20.52,33.15 20.39,33.02 17.67,33.02 17.4,33.3 17.4,40.35 17.27,40.47 17.27,44.4 17.57,44.7 18.63,44.7
+CRT_VCC on BOTTOM (solid shape): 352.89,84.86 355.37,84.86 355.55,85.04 357.41,85.04 357.64,85.27 358.75,85.27 358.82,85.19 358.82,83.74 358.58,83.5 351.89,83.5 351.37,84.02 351.37,85.11 351.68,85.43 352.32,85.43
+CRT_VCC on BOTTOM (solid shape): 362.62,97.32 365.13,97.32 365.25,97.21 365.25,96.48 365.1,96.33 361.25,96.33 360.84,95.92 360.84,95.19 360.47,94.82 359.56,94.82 359.34,95.03 359.34,98.22 359.52,98.4 361.54,98.4
+CRT_VCC on IN2: 351.44,84.16 351.38,84.23 351.38,85.47 351.41,85.5 351.41,88.72 349.02,91.11 349.02,95.68 351.44,98.11 356.99,98.11 357.36,97.74 358.56,97.74 359.08,98.26 359.08,100.99 358.82,101.24 358.82,103.48 358.9,103.55 359.49,103.55 359.66,103.38 359.66,103.24 359.89,103.01 360.13,103.01 360.22,102.92 360.22,98.58 360.6,98.2 360.6,95.33 360.23,94.96 358.53,94.96 356.54,96.95 355.34,96.95 354.6,97.02 353.86,96.95 352.26,96.95 350.63,95.33 350.63,91.35 352.83,89.15 352.83,84.35 352.64,84.16
+DC_IN on BOTTOM (solid shape): 71.14,120.62 71.14,116.27 70.94,116.07 69.87,116.07 69.64,115.85 69.64,114.69 70.46,113.88 71.89,113.88 72.06,113.72 72.06,113.28 71.97,113.19 70.87,113.19 70.81,113.26 67.94,113.26 67.23,113.97 67.23,115.47 67,115.7 67,119.35 67.69,120.04 67.69,120.71 67.89,120.92 70.85,120.92
+DC_IN on TOP: 66.58,116.63 66.58,118.66 66.6,118.68 66.6,119.11 66.72,119.24 67.81,119.24 67.97,119.39 67.97,120.2 67.55,120.62 64.93,120.62 64.7,120.85 64.7,122.31 64.91,122.52 68.55,122.52 68.77,122.3 68.77,120.92 68.88,120.8 70.79,120.8 71.14,120.45 71.14,116.34 70.83,116.03 67.18,116.03
+DC_IN_SS on TOP (solid shape): 66.34,119.79 66.34,117.63 65.38,116.66 65.38,115.65 65.55,115.47 65.55,113.92 65.5,113.87 64.54,113.87 64.26,113.59 64.26,112.55 63.62,111.91 61.59,111.91 61.41,112.09 61.41,120.32 61.63,120.54 65.59,120.54
+DCIN_JACK on BOTTOM (solid shape): 66.73,119.57 66.73,116.29 65.66,115.21 64.56,115.21 63.55,116.23 61.77,116.23 61.13,116.86 61.13,119.3 61.5,119.67 66.63,119.67
+EDP_VDD on BOTTOM (solid shape): 139.7,107.46 139.78,107.45 140.44,107.45 140.49,107.46 140.55,107.47 140.58,107.48 140.89,107.16 140.89,105.54 140.15,104.8 140.15,103.81 139.75,103.4 138.12,103.4 137.51,104.01 137.51,106.17 137.61,106.27 137.85,106.27 137.85,106.78 137.51,106.78 137.51,107.01 137.85,107.01 137.85,107.49 139.61,107.49
+LCDVDD on TOP (solid shape): outline of 871 points within 107.92,99.03 137.33,107.64
+LCDVDD on BOTTOM (solid shape): 109.38,106.97 109.38,105.68 109.35,105.65 109.35,105.12 109.38,105.1 109.38,104.84 109.55,104.66 109.55,101.36 109.45,101.26 108.84,101.26 108.77,101.34 108.77,101.97 108.79,102 108.79,104 108.48,104.31 108.48,105.58 108.46,105.6 108.46,106.97 108.64,107.15 109.2,107.15
+LCDVDD on BOTTOM (solid shape): 137.72,107.56 137.72,107.14 137.38,107.14 137.38,107.14 137.18,107.14 137.16,107.11 137.16,106.68 137.18,106.65 137.41,106.65 137.41,106.66 137.72,106.66 137.72,106.4 137.08,106.4 137.03,106.35 137.03,103.56 136.88,103.4 134.92,103.4 134.11,104.22 134.11,105.84 134.82,106.55 134.82,107.67 134.9,107.75 137.54,107.75
+PBATT on TOP (solid shape): 20.65,6.35 20.65,3.71 20.14,3.2 19.86,3.2 17.87,1.21 13.16,1.21 13,1.37 13,5.21 13.81,6.02 17.75,6.02 18.21,6.48 20.52,6.48
+PWR_SRC on TOP (solid shape): 164.97,68.94 164.97,45.9 167.79,43.08 167.79,38.94 167.08,38.23 166.44,38.23 166.42,38.25 160.79,38.25 157.4,41.65 157.4,59.98 157.41,59.99 157.41,68.62 158.9,70.1 163.8,70.1
