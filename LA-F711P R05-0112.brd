# Allegro board LA-F711P R05-0112.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+3.3V_ALW2: length 268.9
  TOP w0.508: RE57.2 307.77,46.25 v2(307.36,46.66) ; v2(303.97,34.73) 303.78,34.73 303.7,34.81 v3(302.85,34.81) 300.23,34.81 298.41,32.99 298.41,31.6 299.13,30.88 299.13,27.98 297.88,26.73 297.88,23.55 300.45,20.98 300.55,20.98 301.58,19.94 301.58,18.63 299.56,16.6 v2(299.56,11.71) ; PR104.2 92.31,10.69 v2(100.5,10.69)
  IN3 w0.508: v2(303.97,34.73) 303.97,35.04 305.06,36.13 305.06,44.06 307.36,46.35 v2(307.36,46.66) ; v2(299.56,11.71) 299.07,11.23 294.71,11.23 293.59,10.11 286.85,10.11 285.24,8.5 270.1,8.5 269.9,8.29 269.46,8.29 267.26,6.1 258.1,6.1 257.59,5.59 254.47,5.59 251.43,2.55 223.08,2.55 222.79,2.26 216.15,2.26 213.75,4.66 203.47,4.66 201.5,6.63 197.02,6.63 190.33,13.32 188.3,13.32 187.25,14.38 181.81,14.38 179.81,12.37 171.37,12.37 170.43,11.43 160.6,11.43 153.79,4.62 117.88,4.62 112.21,10.29 109.27,10.29 108.27,11.28 101.09,11.28 v2(100.5,10.69)
+3.3V_ALW_DSW_R: length 2
  BOTTOM w0.508: RH439.2 201.71,9.25 202.28,8.68 QH7.1
+3.3V_ALW_PCH: length 543.5
  TOP w0.305: 172.88,44.97 172.88,44.81 172.82,44.76 JAPS1.1
  TOP w0.381: RH67.1 220.36,30.75 220.02,31.09 RH78.1 219.59,31.47 219.45,31.33 218.89,31.33 218.12,32.11 215.75,32.11 RH309.1 ; RH311.1 217.3,29.38 218.27,28.41 RH329.2 218.97,28.36 RH86.1 220.1,28.36 v2(220.28,28.18) ; RH80.1 224.02,29.76 223.22,30.57 221.62,30.57 221.44,30.75 221.06,30.75
  TOP w0.457: v2(212.12,10.37) 211.56,10.37 211.55,10.38 RH330.1
  TOP w0.508: v2(45.61,53.7) 45.61,51.94 43.84,50.17 RC137.2 ; v2(178.55,53.52) 177.3,52.27 177.08,52.27 175.69,50.88 175.69,47.78 172.88,44.97 ; RH77.1 221.53,32.02 v2(221.41,31.89) 221.41,31.1 221.06,30.75 RH67.1 ; RZ69.1 242.45,26.68 241.8,26.03 239.34,26.03 238.83,26.54 238.83,30.11 v2(238.85,30.13) ; v2(55.8,55.4) 55.8,53.14 57.26,51.68 v3(57.26,47.21) 57.26,47.14 56.63,46.51 RC133.1 ; v2(228.16,31.96) 228.06,31.87 RH81.1 ; RZ375.1 282.1,4.79 v2(281.85,5.04) 278.49,5.04 277.99,5.55 277.99,6.49 270.04,14.44 v2(270.04,17.82) ; v2(223.15,23.14) 223.4,23.14 223.9,22.64 225.78,22.64 228.29,25.15 v2(228.29,25.23) ; RZ379.1 v2(291.59,4.89)
  IN2 w0.508: v2(228.16,31.96) 228.16,33.45 230.25,35.53 233.57,35.53 234.51,34.59 236.69,34.59 237.37,35.28 241.04,35.28 v2(241.09,35.22) 241.09,34.59 238.85,32.35 v2(238.85,30.13) 238.85,28.83 236.62,26.61 v2(236.62,26.27) ; v2(200.61,13.33) 203.53,10.41 212.08,10.41 v2(212.12,10.37) 212.51,9.98 215.03,9.98 216.34,8.67 222.03,8.67 222.54,9.19 v2(222.54,9.4) ; v2(224.39,35.38) 224.39,34.66 224.65,34.4 v2(224.65,32.64) ; v2(45.61,53.7) 45.61,53.14 44.78,52.3 43.07,52.3 42.57,51.79 39.56,51.79 38.95,51.18 36.42,51.18 35.21,49.97 34.44,49.97 31.68,47.22 31.68,43.03 29.37,40.72 27.76,40.72 24.75,37.71 24.75,27.47 23.92,26.64 23.92,14.24 26.34,11.82 38.26,11.82 38.6,11.48 v2(38.6,11)
  IN3 w0.508: v2(55.8,55.4) 55.16,54.76 51.35,54.76 50.34,55.78 47.7,55.78 v2(45.61,53.7) ; v2(38.6,11) 38.6,10.64 38.41,10.45 38.41,2.35 39.11,1.65 104.67,1.65 109.27,6.25 113.23,6.25 115.79,3.68 154.05,3.68 159.53,9.17 161.21,9.17 162.58,10.54 170.51,10.54 171.47,11.51 181.87,11.51 183.66,9.71 190.36,9.71 v2(190.61,9.46) ; v2(220.28,28.18) 220.28,27.15 217.77,24.64 217.77,22.98 v2(217.68,22.89) ; v2(281.85,5.04) 281.85,4.53 282.48,3.9 290.6,3.9 v2(291.59,4.89)
  BOTTOM w0.305: RH185.1 222.05,11.11 222.05,9.89 v2(222.54,9.4) 223.14,8.8 JSPI1.16
  BOTTOM w0.381: v2(236.62,26.27) 236.92,25.97 UH7.5
  BOTTOM w0.508: RH440.1 201.72,11.96 202.61,12.85 ; RH185.1 222.18,11.55 222.18,13.42 222.86,14.1 222.86,17.51 222.69,17.68 222.69,19.53 223.22,20.06 223.22,23.02 223.13,23.12 223.13,23.14 v2(223.15,23.14) ; v2(228.16,31.96) 229.85,30.27 229.85,26.05 229.35,25.54 228.6,25.54 v2(228.29,25.23) 228.29,24.51 227.78,24 RH203.2 227.48,23.68 227.47,23.67 RH204.2 ; RH310.1 208.75,12.09 210.6,10.24 210.6,9.49 RH101.1 210.98,9.23 v2(212.12,10.37) ; RC557.2 224.63,32.65 v2(224.65,32.64) ; v2(224.39,35.38) 223.91,35.86 RC74.1 ; v2(270.04,17.82) 270.93,17.82 273.3,20.19 273.3,22.92 271.4,24.83 270.22,24.83 270.22,24.83 269.85,24.83 268.4,26.28 267.39,26.28 266.41,27.25 257.46,27.25 255.43,25.22 244.7,25.22 244.27,24.79 238.2,24.79 237.28,25.7 UH7.5 ; v2(178.55,53.52) 179.01,53.07 179.01,46.41 179.29,46.13 179.29,44.03 180.79,42.53 180.79,36.51 183.63,33.68 183.63,30.31 182.97,29.65 182.97,27.79 184.03,26.72 184.03,25.82 182.86,24.66 182.86,21.25 183.61,20.51 190.85,13.27 197.85,13.27 198.66,14.08 199.68,14.08
  vias: v2(199.87,13.44)
+3.3V_ALW_PCH_UZ3:
  vias: v3(191.31,6.3)
+3.3V_ALW_PCHRES: length 2.9
  TOP w0.508: RH299.1 v2(215.97,39.34) 216.23,39.6 217.43,39.6 217.97,40.13
  vias: v2(203.98,16.64) v2(204.69,16.6) v2(215.64,34.65) v2(216.22,34.65) v2(216.38,27.44) v2(216.97,27.44) v3(204.82,15.6)
+3.3V_ALW_UE1: length 34.2
  TOP w0.102: v2(309.66,46.81) 309.66,46.81 v1(309.22,47.26)
  TOP w0.203: 318.12,39.95 318.12,41.85 318.3,42.03 318.3,42.7 CE23.1
  TOP w0.229: UE1.B7 318.12,39.95
  TOP w0.356: UE1.G8 v2(318.92,35.15) ; v2(314.12,32.67) 314.12,32.75 UE1.K2 ; UE1.M9 v2(320.52,31.15)
  TOP w0.508: v2(318.38,44.44) 318.38,44.29 318.27,44.18 CE14.1 CE23.1
  IN2 w0.508: v2(318.38,44.44) 318.38,44.29 317.06,42.98 310.97,42.98 309.37,44.57 309.37,46.52 v2(309.66,46.81)
  IN3 w0.508: v2(309.66,46.81) 309.39,46.81 308.12,45.54 308.12,38.05 309.34,36.83 v2(309.67,36.83)
  BOTTOM w0.356: CE19.1 318.73,35.66 318.92,35.47 v2(318.92,35.15)
  BOTTOM w0.381: CE20.1 319.96,30.89 320.22,31.15 v2(320.52,31.15)
  vias: v2(309.08,36.22) v2(309.65,36.22) v2(310.94,35.46)
+3.3V_ALW_UZ12: length 0.8
  TOP w0.102: v1(248.23,33.95) 248.36,33.82 249.02,33.82
+3.3V_ALWP: length 38.9
  TOP w0.102: v1(88.74,10.39) 89.02,10.11 v2(89.02,9.75)
  IN1 w0.305: v2(89.35,10.47) 91.01,10.47 92.43,11.89 98.19,11.89 100.68,9.4 v2(105.51,9.4)
  IN3 w0.254: v2(89.02,9.75) 89.05,9.73 89.58,9.73 91.99,12.14 98.33,12.14 100.64,9.83 102.54,9.83 102.84,10.13 v2(105.23,10.13)
  BOTTOM w0.254: PU100.14 88.46,9.5 88.72,9.75 v2(89.02,9.75)
  BOTTOM w0.305: PR108.2 v2(89.35,10.47)
+3.3V_CAM: length 8.3
  BOTTOM w0.254: CZ1.1 118.65,103.94 118.65,106.42 JEDP1.11
  BOTTOM w0.508: CZ1.1 118.86,103.47 118.88,103.46 118.88,103.39 118.9,103.36 CV22.1 CV23.1 118.9,100.98 v3(119.23,100.65) 119.97,99.91 QZ1.1
+3.3V_CPS: length 2.1
  BOTTOM w0.203: UT9.27 24.15,107.81 24.24,107.72 24.62,107.72 v2(24.68,107.78) ; UT9.52 19.88,114.05 v2(19.29,114.64)
  vias: v1(19.58,115.06)
+3.3V_DSW: length 36.9
  TOP w0.102: RH93.2 221.62,18.26 221.88,18 222.5,18 v1(222.65,18.15)
  TOP w0.508: RH93.2 RH94.2 221.4,19.57 220.87,20.1 v2(220.87,20.17)
  BOTTOM w0.508: RH440.2 202.62,11.53 RH434.1 RH439.1 202.62,9.25 203.89,7.98 206.19,7.98 206.69,7.48 206.69,5.92 207.15,5.46 214.89,5.46 215.4,5.97 215.4,7.44 219.61,11.65 220.13,11.65 221.54,13.06 221.54,13.68 222.2,14.33 222.2,16.66 220.91,17.94
+3.3V_EC_PLL: length 5.7
  TOP w0.356: UE1.F1 313.07,36.35 311.73,37.68 CE18.1 310.92,38.2 310.88,38.2 CE17.1 310.19,38.2 309.26,38.2 RE314.1
+3.3V_FUSE: length 0.5
  BOTTOM w0.254: v2(210.21,22.61) 210.09,22.49 UH1.AT44
  vias: v3(209.64,20.01)
+3.3V_HDD: length 33.8
  TOP w0.508: v2(252.46,11.65) 252.46,11.92 252.8,12.27 252.8,18.26 v2(253.26,18.72)
  BOTTOM w0.203: CN16.1 249.91,19.81 249.91,19.46 249.64,19.19 UN7.10 ; UN7.20 247.64,13.86
  BOTTOM w0.508: 247.64,13.86 247.11,13.33 247.11,12.9 CN17.1 246.3,12.72 245.79,12.22 245.79,10.25 246.3,9.74 RN12.1 RN20.1 248.85,9.72 RN10.2 249.86,9.74 RN16.1 251.71,9.74 252.46,10.49 v2(252.46,11.65) ; v2(253.26,18.72) 253.27,18.71 RN18.1 ; CN16.1 250.4,20.31 252.14,20.31 252.65,20.81 v2(252.65,21.79) 250.97,23.47 RN6.1 RN8.2 RN14.1
  vias: v2(259.08,17.47) v2(259.66,17.47) v2(260.27,17.47) v3(255.23,20.56)
+3.3V_HDD_M2:
  vias: v2(342.59,3.73) v2(342.9,3.2) v2(343.28,3.71) v2(343.63,3.23) v2(343.99,3.71) v2(356.79,4.6) v2(356.79,3.96) v2(357.42,4.6) v2(357.42,3.96) v2(358.19,4.6) v2(358.19,3.96) v3(347.26,4.47) v3(353.52,3.41) v3(364.04,4.2)
+3.3V_LAN: length 284.3
  TOP w0.381: UL2.5 CL15.1 313.14,90.51 312.67,90.04 311.35,90.04 310.93,90.47 RL30.1
  TOP w0.508: 324.93,78.38 325.22,78.67 325.22,79.27 324.9,79.6 RL4.2 ; 324.93,78.38 323.56,77.01 318.41,77.01 318.11,77.32 v2(312.54,77.32) ; 324.93,78.38 327.83,78.38 328.47,79.02 v2(328.47,80.9) 328.43,80.86 RL6.2 326.95,81.7 326.67,81.98 RL5.2 ; v2(310.19,90.64) RL30.1 ; 311.96,75.84 309.55,75.84 308.41,74.71 308.41,68.78 301.81,62.18 297.91,62.18 291.04,55.31 291.04,51.64 290.24,50.84 290.24,43.05 291.27,42.03 291.27,40.1 290.77,39.61 288.78,39.61 285.67,36.49 285.67,33.4 279.19,26.92 279.19,24.44 281.26,22.37 281.26,21.68 279.27,19.69 279.27,17.41 279.01,17.15 v2(279.01,15.87) ; v2(223.3,18.47) 223.3,18.04 222.63,17.37 RL70.1 ; v2(339.9,124.23) 339.26,124.23 338.12,125.37 335.83,125.37 JLOM1.12
  TOP w1.016: 317.93,114.32 317.93,118.01 319.63,119.71 319.63,123.77 321.24,125.38 JLOM1.9 ; 308.02,84.35 306.2,86.17 306.2,96.27 314.37,104.44 314.37,109.75 316.91,112.29
  IN1 w0.508: v2(310.19,90.64) 309.29,89.74 309.29,84.1
  IN2 w0.508: v2(279.01,15.87) 277.88,14.74 254.33,14.74 253.6,15.47 244.9,15.47 243.19,17.18 237.92,17.18 237.2,17.89 229.41,17.89 228.7,17.18 224.59,17.18 v2(223.3,18.47)
  BOTTOM w0.508: v2(328.47,80.9) 329.97,80.9 336.79,87.72 336.79,95.34 343.33,101.88 343.33,112.42 344.51,113.6 CL19.1 342.64,123.57 341.98,124.23 v2(339.9,124.23)
  vias: v2(309.42,83.46) v2(310.05,83.46) v2(312.51,76.04) v2(313.2,76.05) v3(311.57,83.93)
+3.3V_LAN_OUT: length 4
  TOP w0.203: UL1.19 321.05,90.6 v2(321.16,90.7) ; v2(322.88,90.7) 322.88,90.08 322.65,89.85 UL1.15
  BOTTOM w0.508: CL29.1 v2(321.16,90.7)
  vias: v2(316.43,88.38) v2(316.44,87.81) v2(327.58,85.06) v2(327.58,84.48) v3(325.98,89.9)
+3.3V_LAN_UZ2:
  vias: v1(312.04,73.04)
+3.3V_M_TPM:
  vias: v1(241.79,34.9)
+3.3V_MMI_AUX: length 20.4
  TOP w0.508: CR27.1 17.86,73.89 ; CR27.1 CR28.1 ; CR27.1 CR1.1
  TOP w1.016: 14.33,61.44 12.93,61.44 9.88,64.49 9.88,72.34 11.67,74.14 14.07,74.14
  vias: v3(16.01,74.93)
+3.3V_MMI_IN: length 1.2
  TOP w0.102: 17,58.81 v1(15.81,58.81)
+3.3V_PDA_VOUT: length 3
  BOTTOM w0.076: UT5.H2 30.64,88.95 29.86,88.95 29.29,89.52 v1(29.12,89.52)
  BOTTOM w0.102: v1(29.12,89.52) 28.9,89.52
  BOTTOM w0.104: CT83.1 28.24,89.52 28.9,89.52
+3.3V_PGPPBC: length 1.1
  BOTTOM w0.254: UH1.AN26 v2(208.38,30.66) ; UH1.AP26 v2(209.14,30.66)
  vias: v3(214.13,29.77)
+3.3V_PGPPEF: length 1.5
  BOTTOM w0.254: UH1.AE36 205.04,26.22 v2(205.22,26.04) ; v2(205.25,26.63) 205.25,26.88 205.15,26.98 UH1.AE35
  vias: v3(205.89,25.58)
+3.3V_PGPPG: length 0.5
  BOTTOM w0.254: UH1.AN21 208.37,34.34 v2(208.37,34.35)
  vias: v3(212.98,33.71)
+3.3V_PGPPHK: length 1.3
  BOTTOM w0.254: v2(202.99,26.04) 203.16,26.22 UH1.AC36 ; v2(202.9,26.64) 202.96,26.64 203.3,26.98 UH1.AC35
  vias: v3(201.46,22.95)
+3.3V_PHVC: length 3.5
  TOP w0.254: v2(212.13,39.39) 212.41,39.67 v1(212.68,39.67) 212.93,39.67 213.21,39.39 213.21,39.22 213.43,39.01 214.13,39.01 RH299.2
  BOTTOM w0.254: UH1.AW9 211.92,39.61 v2(212.13,39.39)
+3.3V_PHVLDO: length 4.6
  TOP w0.254: v2(211.51,40.18) 212.88,40.18 213.09,40.39 213.53,40.39 213.83,40.68 214.27,40.68
  BOTTOM w0.254: v2(211.51,40.18) 211.58,40.25 211.91,40.25 UH1.AY8 212.33,40.32 212.39,40.37 UH1.BB7
  vias: v3(215.43,40.94)
+3.3V_PRTC: length 3.7
  TOP w0.089: RH297.2 v1(215.81,17.32)
  TOP w0.508: RH297.2 CH33.1 CH65.1 218.72,17.38 v2(218.72,18.15)
+3.3V_PUSB2: length 26.5
  TOP w0.508: v2(210.5,19.53) 210.66,19.53 v1(211.19,18.99) 211.58,18.6 211.58,15.91 210.68,15.01 RH302.2
  IN3 w0.381: v2(210.5,19.53) 209.64,19.53 208.9,20.27 208.9,21.67 207.81,22.75 207.81,23.72 207.29,24.25 207.29,31.68 206.86,32.11 201.55,32.11 v2(201.38,32.27)
  BOTTOM w0.254: v2(201.38,32.27) 201.27,32.27 UH1.V23
+3.3V_RTC_LDO: length 239.5
  TOP w0.508: v2(163.66,2.43) 162.87,3.22 162.87,4.06 161.45,5.47 158.28,5.47 156.26,3.45 119.17,3.45 113.97,8.66 v3(113.18,8.66) 112.19,8.66 110.64,10.21 109.5,10.21 108.38,11.33 107.11,11.33 106.35,10.57 106.35,8.79 105.84,8.28 105.84,3.91 103.48,1.55 95.42,1.55 94.41,2.56 94.41,7.64 93.01,9.04 PR105.2 ; PD3.3 298.62,6.18 v2(298.72,6.08) ; v2(258.01,2.14) 257.65,1.78 206.98,1.78 206.62,2.14 v2(202.8,2.14)
  IN1 w0.508: v2(202.8,2.14) 202.29,1.64 191.9,1.64 190.39,3.14 190.39,5.33 187.88,7.84 184.26,7.84 177.85,1.42 164.66,1.42 v2(163.66,2.43)
  IN3 w0.381: v2(258.01,2.14) 259.13,3.26 266.59,3.26 270.82,7.49 285.37,7.49 286.53,8.66 297.4,8.66 298.72,7.35 v2(298.72,6.08)
+3.3V_RUN: length 675.8
  TOP w0.203: UV6.26 328.33,74.81 CV106.1 ; RV622.1 328.97,66.67 327.93,67.71 UV6.14
  TOP w0.254: v2(279.88,40.32) 279.88,40.25 278.62,38.99 UV9.12 ; UV9.6 279.17,35.99 v2(279.42,36.24) ; v2(270.25,33.68) 270.44,33.49 UV9.36 ; UV9.1 278.81,33.49 279.45,32.85 280.56,32.85 280.91,32.51 CV61.1 ; CV62.1 269.4,35.63 270.66,35.63 270.8,35.49 UV9.32
  TOP w0.305: LGA1.2 268.98,4.08 v2(268.78,3.89) 269.08,3.58 LGA1.3 ; LGA1.10 272.63,6.65 CN3.1 272.96,6.69 274.19,5.46 274.19,4.29
  TOP w0.381: v2(218.9,10.04) 218.84,9.98 QH4.2 ; CV62.1 269.22,35.19 269.06,35.03 v2(269.06,34.86) ; QH4.5 215.9,9.98 215.72,9.8 215.72,9.04 216.1,8.66 216.34,8.66 216.86,8.14 RH374.2 ; RC370.2 215.77,33.07 219.12,33.07 220.14,34.09 v2(220.18,34.09) ; QV3.2 114.6,124.1 114.22,124.48 113.66,124.48 RV19.2 ; RH339.1 RH355.1 217.84,30.07 217.84,29.5 218.18,29.16 220.02,29.16 RH267.2 220.51,29.06 220.84,28.73 220.84,27.96 221.27,27.53 RH375.1 ; QV5.2 118.78,124.14 118.54,124.38 117.75,124.38 117.47,124.1 QV3.5 ; v2(226.55,36.18) 226.21,35.84 RH131.2
  TOP w0.508: 268.22,15.82 268.4,15.65 ; RV326.1 125.93,97.66 123.19,97.66 v2(121.91,98.95) ; CV106.1 328.47,74.83 v2(328.98,74.32) ; v2(73.73,12.9) 73.66,12.97 73.66,14.42 73.46,14.62 RD8.1 ; v2(315.27,20.18) 315.34,20.18 315.85,20.69 RE547.2 ; CV7.1 333.75,71.58 v2(333.68,71.65) 333.37,71.35 CV100.1 332.88,71.32 LV30.1 ; QV5.2 118.78,123.03 119.1,122.71 RV20.2 ; v2(324.34,66.13) RV124.1 ; RN226.1 272.29,9.53 275.75,6.07 276.64,6.07 ; v2(175.94,17.42) 176.15,17.42 176.53,17.04 RD22.1 RD20.1 ; RV81.2 273.85,29.61 v2(273.46,29.22) ; v2(252.88,32.18) 252.7,32.01 252.7,31.29 RZ362.1 ; RH222.2 210.1,43.35 RH221.2 ; RH222.2 RH223.2 ; RH222.2 210.78,43.99 210.78,44.3 211.14,44.66 211.14,45.85 v2(211.42,46.13) ; RV621.1 268.15,31.62 267.72,32.04 v2(267.72,32.19) ; RE67.2 302.86,42.99 302.15,42.29 v2(302.15,41.91) ; RV106.2 v2(326.56,76.48) ; v2(256.47,32.18) 255.85,32.81 255.85,34.99 254.53,36.31 251.55,36.31 250.88,36.97 244.72,36.97 244.14,36.4 RZ89.1 ; RV20.2 119.1,121.51 117.12,119.53 115.97,119.53 v2(109.41,112.97) 108.76,113.61 101.87,113.61 94.79,120.69 RV18.1 ; RV20.2 117.06,122.2 116.42,122.85 114.72,122.85 113.46,124.1 RV19.2 ; v2(268.04,39.01) 267.61,38.58 RV71.2 ; RD10.1 92.49,22.95 95.73,19.71 97.84,19.71 101.14,16.41 101.14,15.52 99.49,13.87 RD6.1 98.68,13.18 98.51,13.02 96.68,13.02 v2(96.47,13.23) 96.46,13.23 96.26,13.43 96.26,13.44 96.19,13.51 96.19,13.66 RD4.1 ; RV622.1 328.94,66.6 RV620.1 329.52,65.71 v2(329.7,65.9) ; RH333.2 RH374.2 216.86,7.39 v2(217.36,6.9) ; v2(279.71,32.07) 280.55,32.07 280.91,32.43 CV61.1 ; v2(282.89,35.92) 282.78,36.03 RV79.2 RV83.2 ; v2(240.24,32.52) 240.24,30.94 240.82,30.36 RZ365.2 ; v2(256.35,8.62) 256.35,7.75 260.86,3.24 263.86,3.24 264.32,3.69 RN4.1 ; RD24.1 153.93,13.58 RD19.1 154.82,13.44 155.06,13.19 v2(155.06,12.67) ; v2(225.02,43.32) 226.2,42.14 226.2,38.29 225.86,37.95 v2(224.02,37.95) ; RE51.1 204.49,66.51 RE48.1 203.61,65.62 205.33,63.9 208.78,63.9 219.16,53.52 v2(219.16,51.56) ; v2(306.21,20.09) 306.21,14.62 302.73,11.14 v2(302.66,11.14) ; v2(209.06,44.89) 207.69,44.89 206.73,43.93 RH225.2 206.73,42.86 RH224.2 ; v2(322.5,75.08) 321.97,74.56 LV14.1 ; RV107.2 v2(327.45,76.48)
  TOP w1.016: 268.4,15.65 268.46,15.58 268.46,14.74 276.24,6.97
  IN1 w0.508: v2(282.89,35.92) 282.89,36.67 279.88,39.69 v2(279.88,40.32) ; v2(279.71,32.07) 279.71,35.94 v2(279.42,36.24) ; v2(73.73,12.9) 73.53,12.9 72.83,13.61 33.48,13.61 32.08,15.01 32.08,22.39 33.33,23.64 33.33,24 34.19,24.87 34.19,35.45 29.59,40.06 v2(29.59,42.1)
  IN2 w0.508: v2(154.95,93.74) 154.62,93.41 137.3,93.41 134.48,96.23 127.07,96.23 125.37,97.93 122.92,97.93 v2(121.91,98.95) ; v2(267.72,32.19) 267.2,31.67 256.98,31.67 v2(256.47,32.18) v2(252.88,32.18) 251.63,32.18 250.73,33.08 243.43,33.08 243.38,33.03 242.44,33.03 241.94,33.53 240.92,33.53 240.24,32.85 v2(240.24,32.52) ; v2(269.06,34.86) 269.06,34.86 269.06,34.19 269.57,33.68 v2(270.25,33.68) ; v2(73.73,12.9) 73.73,13.21 74.06,13.54 96.16,13.54 v2(96.47,13.23) 97.07,13.23 97.3,13.46 139.82,13.46 139.9,13.54 140.46,13.54 ; v2(173.33,27.66) v2(173.78,27.2) 173.78,25.69 176.54,22.93 178.64,22.93 180.07,21.5 180.07,16.99 179.51,16.43 177.17,16.43 176.18,17.42 v2(175.94,17.42) 175.48,17.42 174.82,16.77 174.82,15.22 174.44,14.83 170.91,14.83 170.76,14.68 158.95,14.68 157.83,13.56 155.11,13.56 ; 25.12,59.26 25.12,57.71 28.27,54.56 28.27,43.18 29.35,42.1 v2(29.59,42.1) ; 155.11,13.56 140.48,13.56 140.46,13.54 ; 155.11,13.56 155.06,13.51 v2(155.06,12.67) ; v2(140.46,12.7) 140.46,13.54
  IN2 w1.524: 25.12,59.26 27.07,59.26 28.28,58.04 32.54,58.04 33.19,58.7 33.19,68.63 35.2,70.64 35.2,73.48 34.45,74.23 32.55,74.23 31.56,75.22 24.65,75.22 21.23,78.64 21.23,87.1 18.11,90.22 18.11,95.48 17.43,96.15
  IN3 w0.254: v2(275.08,4.66) 272.41,1.99 269.03,1.99 268.78,2.25 v2(268.78,3.89)
  IN3 w0.508: v2(223.35,28.3) 223.35,28.1 223.02,27.77 223.02,26.68 224.79,24.91 225.36,24.91 225.86,24.41 v2(225.86,24.29)
  BOTTOM w0.254: CA7.1 120.72,104.27 120.27,104.71 119.64,104.71 119.15,105.21 119.15,106.42 JEDP1.10
  BOTTOM w0.305: JUSH1.19 303.33,8.95 303.35,8.97 303.35,9.75 303.31,9.79 CZ67.1
  BOTTOM w0.381: v2(223.35,28.3) 223.35,28.47 223.59,28.7 RH331.1 ; v2(218.86,48.83) 218.27,48.83 217.67,48.23 RH199.2 ; v2(219.16,51.56) 217.8,51.56 217.14,50.9 UC3.5 216.43,50.9 215.85,51.48 CH10.1
  BOTTOM w0.508: v2(222.54,34.13) 222.87,33.81 RH207.1 ; v2(302.66,11.14) CZ72.1 CZ67.1 ; RH361.1 226.09,36.18 v2(226.55,36.18) ; RN2.1 267.14,20.43 264.99,20.43 264.19,21.23 263.8,21.23 ; v2(108.13,102.02) 108.36,102.25 RV8.2 ; RV632.2 v2(154.95,93.74) ; v2(121.91,98.95) QZ1.3 122.46,99.74 122.46,100.15 121.03,101.58 121.03,103.41 CA7.1 ; v2(268.04,39.01) 268.79,39.01 269.39,39.61 270.59,39.61 271.35,40.37 v2(271.35,40.42) 271.46,40.42 271.51,40.37 271.76,40.37 271.95,40.18 273.01,40.18 273.11,40.28 279.84,40.28 v2(279.88,40.32) ; v2(225.86,24.29) 226.15,24 RH402.1 ; RZ542.2 140.34,86.91 v2(140.57,87.13) ; v2(217.36,6.9) 216.98,7.27 216.98,8.12 v2(218.9,10.04) ; RH373.2 223.23,37.52 RH378.1 223.82,37.74 v2(224.02,37.95) 224.23,37.74 RH319.1 ; v2(63.93,84.02) PR1716.1 ; RH90.1 RH214.1 RH345.1 224.96,43.96 225.02,43.9 v2(225.02,43.32)
  BOTTOM w1.016: RT397.1 16.38,103.88 16.4,103.87 16.32,103.79 16.32,103.78 16.2,103.66 16.2,103.2 15.82,102.82 15.82,100.31 16.46,99.67 16.46,99.5 16.39,99.44 16.39,98.11
  vias: v2(17.01,97.77) v2(17.01,97.19) v2(23.29,58.57) v2(23.67,59.21) v2(24.05,59.71) v2(25.7,59.33) v2(171.83,37.76) v2(172.49,37.79) v2(204.03,9.22) v2(204.62,9.25) v2(204.62,8.66) v2(205.2,9.26) v2(205.3,8.61) v2(205.79,9.27) v2(206.02,8.64) v2(206.36,9.27) v2(206.65,8.64) v2(206.94,9.27) v2(207.29,8.64) v2(207.54,9.27) v2(208.11,9.25) v2(257.86,21.61) v2(258.49,21.61) v2(259.13,21.61) v2(259.76,21.61) v2(260.4,21.61) v2(267.95,17.78) v2(268.59,17.78) v2(335.14,19.56) v2(335.5,20.03) v2(335.56,19.16) v2(335.94,19.58) v2(336.34,19.14) v2(336.37,20.03) v2(336.9,19.61) v3(337.03,13.36)
+3.3V_RUN_AUDIO: length 23.1
  TOP w0.508: v2(344.47,30.42) 344.82,30.42 345.11,30.71 CA68.1 345.28,30.76 RA59.1 RA61.1 ; 338.5,24.14 337.79,24.85 337.79,25.32 337.23,25.88 RA18.2 337.31,26.44 338.25,26.44 338.55,26.75 CA67.1 338.55,27.65 339.11,28.21 339.11,28.88 v2(339.16,28.93) 338.93,28.93 337.99,29.87 LA14.2
  IN1 w0.508: v2(344.47,30.42) 344.47,30.58 343.91,31.14 341.71,31.14 339.74,29.17 339.4,29.17 v2(339.16,28.93)
  BOTTOM w0.508: v2(344.47,30.42) 344.47,30.05 343.99,29.57 342.76,29.57 342.4,29.93 LA12.2
  vias: v3(339.51,23.44)
+3.3V_RUN_AUDIO_DVDD:
  vias: v1(339.71,32.42)
+3.3V_RUN_AUDIO_IO: length 1.2
  BOTTOM w0.102: LA12.1 341.98,32.29 v1(341.44,31.75)
  vias: v2(342.59,33.39)
+3.3V_RUN_AUDIO_UZ5:
  vias: v3(335.58,21.37)
+3.3V_RUN_CARD: length 6.1
  TOP w1.016: 28.42,64.17 28.12,64.17 26.15,62.19 23.1,62.19
  vias: v2(17.5,64.8) v2(17.5,64.21) v2(21.59,62.36) v2(22.22,62.41) v2(30.33,64.48) v2(30.96,64.48) v3(31.49,64.06)
+3.3V_RUN_DIMM1: length 7.1
  TOP w0.305: v2(94.33,20.24) 94.41,20.17 CD28.1 93.94,19.62 CD27.1
  TOP w0.508: CD27.1 93.65,20.76 v1(92.86,21.55) RD10.2
  BOTTOM w0.305: v2(94.33,20.24) 93.72,20.85 JDIMM1.255
+3.3V_RUN_DIMM2: length 6.2
  TOP w0.102: RD26.2 174.78,27.59 v1(174.57,27.8)
  TOP w0.381: CD59.1 174.27,24.86 CD60.1 174.53,24.22 174.86,23.89 v2(174.86,23.56)
  TOP w0.508: RD26.2 174.78,25.36 CD59.1
  BOTTOM w0.305: JDIMM2.255 174.72,23.42 v2(174.86,23.56)
+3.3V_RUN_UT9: length 26.4
  TOP w0.102: RT303.1 v1(16.43,114.58)
  TOP w0.381: RT246.1 22.32,109.74 22.35,109.71 22.8,109.71 22.96,109.87 RT141.2 23.28,109.82 23.54,109.82 23.68,109.68 24.18,109.68 24.51,109.35 24.51,109.11 25.36,108.25 25.87,108.25 26.29,107.84 RT305.2
  TOP w0.508: RT303.1 17.62,114.91 17.38,115.15 v2(17.38,115.34) ; v2(28.69,109.12) 28.56,109.12 28.11,109.56 RT135.2 RT137.2 27.56,108.24 27.03,107.72 ; RT139.2 17.64,118.52 v2(17.83,118.33) 18.4,117.75 LT11.1 ; RT308.2 27.22,107.53 27.03,107.72 ; 27.03,107.72 26.97,107.66 RT305.2 26.29,107.23 25.78,106.72 RT304.2
  IN2 w0.508: 22.75,105.02 23.35,104.42 24.88,104.42 25.51,105.05 25.51,105.37 25.83,105.69 26.78,105.69 27.57,106.48 27.57,108.51 28.18,109.12 v2(28.69,109.12)
  BOTTOM w0.508: v2(22.06,105.24) 22.07,105.24 RT131.2
  vias: v2(18.28,108.04) v2(18.93,107.69)
+3.3V_RUN_UZ3:
  vias: v1(196.88,6.86)
+3.3V_SPI: length 89
  TOP w0.305: v2(236.13,11.04) 235.45,10.36 RH335.1
  TOP w0.508: v2(228.65,19.81) 228.65,19.59 228.59,19.53 v3(228.59,17.64) 228.59,14.6 228.32,14.33 v2(228.32,14.27) ; v2(237.71,7.37) 237.71,8.88 239.56,10.72 v2(239.56,11.25) 239.56,11.47 238.25,12.78 v2(238.25,15.47) ; RH615.1 201.07,15.64 v2(200.95,15.53) 201.14,15.34 DH3.1
  IN1 w0.508: v2(239.56,11.25) 238.55,12.26 236.27,12.26 235.56,12.97 229.62,12.97 v2(228.32,14.27)
  IN2 w0.508: v2(239.56,11.25) 238.14,11.25 237.93,11.04 v2(236.13,11.04) 233.52,11.04 233.36,11.2 223.82,11.2 v2(222.84,12.18) 222.56,12.45 222.56,12.57 220.38,14.76 215.86,14.76 215.53,15.09 208.48,15.09 207.97,14.58 201.9,14.58 v2(200.95,15.53)
  BOTTOM w0.305: JSPI1.15 223.64,9.12 222.61,10.15 222.61,10.71 222.81,10.91 RH185.2
  BOTTOM w0.381: UC5.8 226.11,20.01 CH9.1 ; CH270.1 237.38,6.16 237.54,6.01 237.54,5.64 237.69,5.49 238.26,5.49 238.41,5.64 UC6.8
  BOTTOM w0.457: v2(237.71,7.37) 237.03,6.68 CH270.1
  BOTTOM w0.508: UC5.8 228.14,20.64 228.65,20.13 v2(228.65,19.81) ; RH30.1 238.23,16.82 238.23,15.48 v2(238.25,15.47) ; RH185.2 222.84,11.29 v2(222.84,12.18) ; v2(200.95,15.53) 201.07,15.64 RH601.1
+3.3V_TBTA_FLASH: length 107.1
  TOP w0.508: RT106.2 29.74,86.26 RT107.2 30.38,85.62 30.38,85.11 RT66.2 RT67.2 30.22,83.57 v3(29.37,83.57) 27.46,83.57 v2(27.3,83.73) ; v2(26.34,90.6) 26.36,90.58 27.25,90.58 27.56,90.88 29.43,90.88 29.84,90.47 30.4,90.47 30.5,90.58 RT76.2
  IN1 w0.381: v2(39.49,94.35) 37.58,92.43 34.36,92.43 33.85,91.92 29.72,91.92 28.58,90.78 26.48,90.78 26.31,90.6
  IN1 w0.508: v2(26.34,90.6) 26.31,90.6 25.35,89.64 25.35,88.26 25.78,87.83 26.64,87.83 27.38,88.57 v2(27.53,88.57) 27.53,84.76 27.48,84.71 27.48,83.9 v2(27.3,83.73)
  IN2 w0.508: v2(54.45,99.89) 49.27,94.72 v2(49.27,91.41) 46.41,88.56 46.41,85.2 v2(49.59,82.03) 49.59,81.61 49.34,81.36 47.13,81.36 v2(46.45,82.03) 45.07,83.41 27.61,83.41 v2(27.3,83.73)
  BOTTOM w0.305: JDB1.1 v2(54.45,99.89)
  BOTTOM w0.381: v2(39.49,94.35) 39.59,94.35 40.43,93.5 40.43,91.45 39.66,90.67 39.66,90.27 39.56,90.18 39.56,89.71 38.72,88.86 RT98.2
  BOTTOM w0.508: v2(27.3,83.73) 26.02,82.45 24.99,82.45 24.48,82.96 RT379.2 RT378.2 ; v2(49.27,91.41) 49.09,91.6 UT6.8 49.09,94.32 RT50.1 50.58,94.39 CT70.1 ; RT53.1 RT52.1 46.67,82.25 v2(46.45,82.03) ; RT95.2 27.16,90.54 26.4,90.54 v2(26.34,90.6) ; v2(49.59,82.03) 50.03,82.47 RT51.1
+3.3V_TP: length 24.1
  TOP w0.508: RZ116.1 150.72,6.22 150.11,6.22 v2(150.03,6.3) ; v2(155.06,7.47) 154.86,7.26 154.4,7.26 RZ20.1 RZ21.1 ; 140.75,9.62 145.21,9.62 145.32,9.73 v3(146.35,9.73) 149.3,9.73 v2(150.06,8.97) 150.34,9.25 RZ117.1
  IN1 w0.508: v2(155.06,7.47) 154.94,7.34 153.89,7.34 152.73,6.17 150.16,6.17 v2(150.03,6.3) 150.06,6.32 v2(150.06,8.97)
  BOTTOM w0.305: JKBTP1.9 140.02,10.67 v2(139.87,10.82)
  BOTTOM w0.508: RZ117.1 150.34,9.25 v2(150.06,8.97) ; v2(150.03,6.3) 150.08,6.25 150.75,6.25 RZ116.1
+3.3V_VDD_DCI: length 1.7
  BOTTOM w0.102: v1(18.84,113.5) 18.84,113.38 19.06,113.16 19.06,113.16 19.22,113 v2(19.26,113)
  BOTTOM w0.203: UT9.49 v2(19.26,113)
+3.3V_VDD_DCIN: length 70.8
  TOP w0.381: PC9.1 72.93,116.6 PU1.5 ; v2(72.92,110.71) 72.92,111.51 72.45,111.98 v3(71.96,111.98) PR17.1
  TOP w0.508: v2(71.55,116.99) 71.94,116.6 PC9.1 ; PR27.2 v2(77.21,119.28)
  IN2 w0.508: v2(54.28,106.83) 54.28,108.98 54.92,109.63 57.16,109.63 59.3,111.76 62.95,111.76 63.31,111.4 72.22,111.4 v2(72.92,110.71) ; v2(73.57,110.78) 74.04,111.25 74.04,114.45 71.55,116.94 v2(71.55,116.99)
  BOTTOM w0.508: v2(71.55,116.99) 72.82,116.99 74.98,119.15 77.09,119.15 v2(77.21,119.28) ; PD1801.3 40.56,108.48 45.61,108.48 47.49,106.6 54.05,106.6 v2(54.28,106.83) 54.28,105.43 55.06,104.65 55.06,103.2 54.68,102.82 53.79,102.82 52.09,104.52 PR1208.1 PR1206.1
+3.3V_VDD_PIC: length 78.8
  TOP w0.381: PU1200.5 56.67,100.46 PC1204.1 56,100.41 v2(55.62,100.02) ; PR1214.1 65.85,102.73 65.03,102.73 64.97,102.79 PR1253.1 64.16,102.79 64.15,102.78 63.68,102.78 v2(63.29,103.17)
  TOP w0.508: v2(38.02,100.21) 38.48,100.66 38.48,106.48 38.65,106.65 v2(38.65,107.21) ; PR1226.1 62.53,105.99 PR1254.2 62.39,104.91 63.29,104.01 v2(63.29,103.17)
  TOP w0.762: 24.94,86.99 24.79,87.15 24.79,89.15 25.37,89.74 25.37,91.01 25.68,91.31 25.68,93.01 25.31,93.38 25.31,95.64 24.81,96.14
  IN2 w0.508: v2(63.29,103.17) 62.63,103.83 61.34,103.83 57.53,100.02 v2(55.62,100.02) 55.12,100.53 53.5,100.53 53.11,100.14 49.06,100.14 48.27,100.93 48.27,100.95 47.3,101.92 39.73,101.92 v2(38.02,100.21) 37.91,100.1 34.15,100.1 32.56,101.69 29.96,101.69 29,100.74 v2(27.5,100.74)
  BOTTOM w0.508: v2(38.65,107.21) 38.65,107.09 38.94,106.8 PR1240.1 39.39,107.52 39.14,107.77 39.14,108.36 PD1801.2 ; PR1237.1 38.4,99.84 38.03,100.21 v2(38.02,100.21) ; PR1236.2 28.93,104.27 28.93,101.83 29.26,101.5
  BOTTOM w1.016: 18.43,100.27 17.47,100.27 16.98,100.77 16.98,102.31 17.35,102.68
  vias: v2(19.41,100.56) v2(19.6,100) v2(23.59,97.41) v2(24,96.93) v2(26.79,100.76) v3(21.81,97.92)
+3.3V_VDD_PIC_PDA: length 3.7
  BOTTOM w0.203: v2(28.88,89.96) 29.22,89.96 30,89.19 UT5.H1
  BOTTOM w0.229: UT5.B1 30.38,86.16 30.25,86.03 29.84,86.03 29.02,85.21 v2(28.96,85.21)
  vias: v3(27.56,86.4)
+3.3V_VGA: length 3.6
  TOP w0.203: UV6.1 324.72,72.23 324.4,72.54 324.4,73.18 v1(323.92,73.66) 323.45,74.13 LV14.2
+3.3V_WLAN: length 28.4
  TOP w1.524: 293.92,16.15 293.92,16.5 294.8,17.37 294.8,20.77 294.86,20.84 294.86,26.29 295.27,26.7 295.27,32.77 298.47,35.97 298.47,37 299.27,37.8 300.14,37.8 300.45,37.86 300.73,37.98 300.76,38 302.15,38 303.27,39.13
  vias: v2(297.53,19) v2(297.52,18.41) v2(298.13,19.01) v2(298.15,19.67) v2(298.15,18.41) v2(303.42,41.96) v2(303.45,41.4) v2(304.08,42.01) v3(292.28,12.98) v3(294.62,14.02) v3(297.16,14.82)
+3.3V_WLAN_UZ4:
  vias: v3(290.19,7.42)
+3.3V_WWAN: length 29.9
  TOP w0.102: 313.17,63.69 v3(314.83,63.69)
  TOP w0.254: v2(363.19,49.39) 362.85,49.05 UZ29.1 ; UZ29.6 359.98,51 359.93,51.05 CZ155.1 ; UZ29.10 356.62,49.05 CZ154.1 356.5,49.32 v2(356.87,49.68)
  TOP w0.508: CZ20.1 343.67,60.6 v2(343.67,60.73) ; CZ155.1 359.98,51.51 v2(360.59,51.51)
  BOTTOM w0.508: 326.27,66 326.8,65.47 RZ43.2
  BOTTOM w1.016: CZ26.1 350.83,58.06 351.96,56.93 356.09,56.93 357.69,55.33 357.69,50.61
  BOTTOM w3.048: 336.57,65.66 333.16,65.66
  vias: v2(310.18,64.27) v2(310.43,63.65) v2(310.82,64.27) v2(311.1,63.68) v2(311.45,64.27) v2(311.73,63.75) v2(357.67,49.62)
+3.3V_WWAN_UZ2:
  vias: v3(312.95,67.98)
+5V_ALW: length 515.6
  TOP w0.102: v2(121.47,96.17) 120.88,96.17 v3(120.19,96.87)
  TOP w0.203: v2(317.35,70.84) 317.12,70.61 316.54,70.61 316.44,70.51 UZ2.4 ; v2(333.21,17.71) 333.21,17.72 333.21,17.72 UZ5.4 ; UZ4.4 v2(286.73,4.6)
  TOP w0.254: v2(264.95,4.65) 264.95,5.38 264.8,5.53 UZ23.4 ; UZ8.4 330.25,49.03 329.87,49.42
  TOP w0.305: UZ3.4 195.03,3.39 195.17,3.25 v2(195.17,3.05) ; v2(146.88,70.94) 146.48,71.35 145.18,71.35 144.97,71.56 UZ19.3
  TOP w0.381: PR1754.1 50.77,82.62 v2(51.29,82.62)
  TOP w0.508: PR1900.1 87.42,94.08 87.83,94.49 PC1908.1 87.88,94.5 v2(87.88,95.19) ; v2(97.23,95.35) 97.23,96.09 PC1918.1 PR1904.1 96.16,96.51 95.63,97.04 v2(94.88,97.04) ; v2(74.98,122.9) 74.98,126.39 73.89,127.48 PR7.1 ; RI13.2 341.29,64.96 342.16,65.84 345.08,65.84 345.11,65.81 ; 40.8,61.7 41.17,61.33 43.6,61.33 v2(43.63,61.29) ; 40.8,61.7 40.8,58.95 42.49,57.26 45.58,57.26 v2(46.05,57.73) ; 40.8,61.7 40.8,63.68 ; v2(51.54,77.4) 39.94,77.4 38.21,75.67 37.8,75.26 v2(37.74,75.26) 40.8,72.2 40.8,63.68 ; v2(304.97,11.14) 304.97,10.31 305.14,10.14 305.14,9.33 303.58,7.77 v2(303.58,5.1) ; v2(353.08,40.87) 352.36,40.14 351.7,40.14 RA53.2 ; 329.87,49.42 329.29,49.42 328.78,49.92 328.78,52.22 328.89,52.33 328.89,56.18 329.97,57.26 334.98,57.26 335.86,56.39 337.4,56.39 337.74,56.04 337.74,54.09 338.18,53.64 343.47,53.64 345.61,55.79 345.61,60.6 v2(344.6,61.62) ; RV9.2 122.36,100.3 121.14,99.08 121.14,97.75 121.47,97.42 v2(121.47,96.17) 125.53,96.17 129.22,92.48 129.84,92.48 129.92,92.4 UZ21.3 ; v2(67.83,101.08) 67.84,101.06 67.84,99.62 67.06,98.84 v2(66.71,98.84) 66.38,98.84 65.87,98.33 PR1800.1 65.87,97.34 PC1814.1 ; 40.8,63.68 41.51,62.97 v2(42.77,62.97) ; 346.12,70.76 351.07,75.72 351.07,86.38 348.66,88.8 348.66,104.19 352.56,108.09 352.56,123.25 LED3.2
  IN1 w0.508: v2(51.54,77.4) 51.49,77.44 51.49,78.66 50.38,79.78 50.38,82.19 50.8,82.62 v2(51.29,82.62)
  IN2 w0.508: v2(97.23,95.35) 97.65,95.77 101.61,95.77 104.89,99.05 118.59,99.05 121.46,96.17 v2(121.47,96.17) ; v2(353.08,40.87) 353.65,41.43 353.65,44.02 352.45,45.22 352.45,46.02 349.62,48.85 349.41,48.85 348.9,49.36 348.9,50.54 349.31,50.95 349.31,53.09 345.36,57.05 345.36,59.82 344.6,60.58 v2(344.6,61.62) ; v2(85.31,96.84) 85.52,97.04 86.32,97.04 86.89,96.47 87.54,96.47 87.88,96.12 v2(87.88,95.19) 87.88,94.92 87.6,94.64 84.53,94.64 83.3,95.87 83.3,102.6 82.99,102.91 78.61,102.91 77.9,102.2 v2(77.9,101.43) 77.9,100.3 76.9,99.3 76.31,99.3 76.25,99.24 v2(76.21,99.24) 76.15,99.3 76.03,99.3 74.96,100.37 68.63,100.37 67.11,98.84 v2(66.71,98.84)
  IN3 w0.508: v2(87.88,95.19) 87.88,95.58 88.11,95.81 89.1,95.81 90.06,94.84 95.8,94.84 95.9,94.74 96.88,94.74 97.23,95.09 v2(97.23,95.35) 101.34,95.35 105.79,90.9 105.79,88.82 105.44,88.47 105.44,87.84 105.95,87.32 v2(106.22,87.32) ; v2(203.78,3.57) 203.08,2.87 201.7,2.87 201.23,2.4 195.56,2.4 195.17,2.79 v2(195.17,3.05) ; v2(51.54,77.4) 51.49,77.34 50.55,77.34 48.65,79.25 48.65,89.13 55.86,96.34 62.94,96.34 65.44,98.84 v2(66.71,98.84)
  BOTTOM w0.254: PU1800.2 68.71,100.8 68.38,101.13 67.88,101.13 v2(67.83,101.08) ; PU1901.2 95.12,97.28 v2(94.88,97.04) ; PC2018.1 107.42,87.68 PU2001.15 ; v2(42.77,62.97) 43,63.2 PU2000.2 ; v2(77.9,101.43) 78.18,101.15 PU1801.2 ; PU1901.15 97.41,95.53 v2(97.23,95.35) ; PC2008.1 45.2,60.71 PU2000.15 ; v2(76.21,99.24) 76.44,99 PU1801.15 ; v2(87.88,95.19) 87.77,95.3 PU1900.15 ; PU1900.2 85.64,97.17 v2(85.31,96.84)
  BOTTOM w0.305: PU1800.15 66.73,98.82 v2(66.71,98.84) ; CZ64.1 304.18,10.25 303.81,9.88 303.81,8.97 303.83,8.95 JUSH1.18 ; JLED1.6 320.54,7.05 321.62,5.97 324,5.97 324.19,6.16 326.34,6.16 326.75,5.74 v2(332.28,5.74)
  BOTTOM w0.381: v2(51.54,77.4) 53.85,77.4 PR1745.1 ; v2(46.05,57.73) 51.01,57.73 53.35,60.07 55.98,60.07 57.73,58.32 63.18,58.32 66.13,61.26 66.13,62.32 67.18,63.38 UZ26.3
  BOTTOM w0.508: v2(304.97,11.14) CZ69.1 304.19,11.01 CZ64.1 ; v2(333.49,6.06) 333.49,6.26 337.59,10.36 337.59,16.81 335.85,18.55 334.05,18.55 v2(333.21,17.71) ; v2(167.74,73.13) 167.72,73.15 152.17,73.15 149.96,70.94 v2(146.88,70.94) ; v2(203.78,3.57) 205.04,4.83 213.53,4.83 214.64,3.72 218.02,3.72 219.3,2.44 243.51,2.44 246.3,5.23 ; PC2018.1 106.35,87.2 v2(106.22,87.32) 105.93,87.03 PR2004.1 ; PC2008.1 43.84,60.32 PR2000.1 43.84,61.09 v2(43.63,61.29) ; v2(51.29,82.62) 51.56,82.89 51.56,84.7 51.08,85.18 51.08,85.97 PR2007.1
  vias: v2(23.54,94.21) v2(23.57,93.62) v2(24.13,94.39) v2(24.15,93.75) v2(34.11,103.48) v2(34.11,102.84) v2(36.88,75.34) v2(37.02,75.88) v2(37.23,74.83) v2(37.63,75.91) v2(37.66,74.42) v2(98.32,121.01) v2(98.98,121.01) v2(99.64,120.98) v2(100.3,121.01) v2(134.41,125.37) v2(134.79,124.74) v2(135.05,125.37) v2(135.43,124.74) v2(135.68,125.37) v2(136.06,124.74) v2(136.32,125.37) v2(136.7,124.74) v2(136.95,125.37) v2(137.33,124.74) v2(137.59,125.37) v2(137.97,124.74) v2(167.76,68.27) v2(168.13,68.74) v2(168.47,68.28) v2(168.93,68.73) v2(243.16,21.55) v2(243.19,20.97) v2(243.8,21.55) v2(243.9,20.99) v2(244.43,21.55) v2(244.59,20.95) v2(244.99,21.49) v2(245,7.98) v2(245.27,20.98) v2(245.26,7.31) v2(245.64,21.48) v2(245.66,7.95) v2(246,20.98) v2(245.97,7.37) v2(246.27,21.5) v2(246.27,7.95) v2(246.62,21.02) v2(246.69,7.4) v2(246.93,7.98) v2(247.32,7.42) v2(247.67,7.98) v2(248.02,7.42) v2(248.33,7.95) v2(248.74,7.42) v2(261.3,5.08) v2(261.93,5.08) v2(262.53,5.08) v2(283.08,5.23) v2(283.13,4.6) v2(283.74,5.23) v2(283.74,4.6) v2(284.32,5.23) v2(284.32,4.6) v2(284.91,5.21) v2(284.93,4.57) v2(285.62,4.6) v2(303.2,70.13) v2(303.2,69.37) v2(303.2,68.6) v2(303.83,69.87) v2(303.83,68.99) v2(334.56,67.97) v2(334.95,68.48) v2(335.2,67.72) v2(335.58,68.86) v2(335.58,68.22) v3(244.33,18.55) v3(246.3,9.42)
+5V_ALW2: length 3.1
  TOP w0.102: v3(120.06,128.29) 120.25,128.49 120.63,128.49 121.33,129.18 121.33,130.64
+5V_ALW_PDA: length 1.5
  BOTTOM w0.203: UT5.D11 36.05,87.19 v2(36.28,86.96)
  BOTTOM w0.254: v2(34.42,89.15) 34.84,89.15 UT5.H10
  vias: v2(35.86,86.13) v2(36.27,85.48) v3(36.93,79.53)
+5V_ALWP: length 50.2
  TOP w0.254: v2(120.38,131.72) 120.44,131.79 PU102.14
  TOP w0.305: v2(119.12,132.56) PR117.2
  IN1 w0.305: v2(119.12,132.56) 119.12,133.15 120.19,134.21 120.19,135.49 122.07,137.37 133.1,137.37 135.91,134.55 135.91,132.08 v2(135.25,131.42)
  IN3 w0.254: v2(120.38,131.72) 120.2,131.9 120.2,134 121.31,135.1 121.31,135.86 122.14,136.7 122.73,136.7 123.64,137.62 131.9,137.62 134.84,134.67 134.84,132.74 134.54,132.44 v2(134.03,132.44)
  vias: v2(134.03,133.02) v2(135.25,130.66) v2(135.33,129.59) v2(135.35,128.9) v3(134.32,130.29)
+5V_HDD: length 3.2
  BOTTOM w0.508: 264.71,19.2 265.97,19.2 266.48,18.69 RN1.1
  vias: v2(263.62,18.44) v2(264.21,18.44) v2(264.84,18.44) v3(261.78,14.53)
+5V_HDD_UZ23:
  vias: v1(260.42,8.5)
+5V_PD_VDD: length 1.5
  BOTTOM w0.102: RT111.1 36.31,102.23 v1(36.31,102.41)
+5V_RUN: length 445.6
  TOP w0.381: CZ92.1 135.49,8.7 v2(135.17,8.38)
  TOP w0.508: v2(299.13,51.48) 299.13,50.57 300.02,49.68 RZ370.1 ; v2(301.82,11.84) 301.95,11.71 301.95,10.95 302.59,10.31 303.2,10.31 303.45,10.06 303.45,8.72 302.69,7.96 302.69,4.67 303.25,4.11
  TOP w1.016: 277.85,13.44 280.3,15.89 280.3,16.99 280.82,17.52 280.82,17.71 282.37,19.26 282.37,23.39 281.15,24.61 281.15,27.25 287.44,33.54 287.44,36.19 289.2,37.96 290.71,37.96 292.97,40.22 292.97,41.35 292.72,41.6 292.72,43.61 291.99,44.34 291.99,53.76 294.11,55.87
  TOP w2.032: 209.72,66.06 220.05,55.73 224.28,55.73 236.99,43.02 237.44,43.02 239,41.46 241.45,41.46 244.55,38.37 251.46,38.37 252.13,37.71 255.86,37.71 259.76,33.81 259.76,26.14 261.16,24.74 261.16,23.55 262.43,22.28
  IN1 w2.032: 208.45,69.72 180.54,97.64 161.9,97.64 159.08,100.46 159.08,100.86
  IN2 w0.508: v2(154.96,101.99) 154.96,101.07 167.13,88.9 167.13,57.23 168.12,56.24 168.12,44.36 170.02,42.45 170.02,37.18 178.69,28.52 180.94,28.52 182.53,26.93 182.53,26.23 183.09,25.67 183.09,18.12 183.99,17.22 v2(184.34,17.22) ; 295.35,56.66 299.13,52.88 v2(299.13,51.48)
  IN3 w0.508: v2(184.34,17.22) 183.42,16.31 181.09,16.31 179.09,14.3 176.88,14.3 175.59,13 170.99,13 170.05,12.06 158.19,12.06 156.69,10.57 151.73,10.57 151.2,10.04 146.68,10.04 146.24,9.6 136.39,9.6 v2(135.17,8.38)
  BOTTOM w0.305: JKBTP1.16 136.52,9.46 136.22,9.16 135.95,9.16 v2(135.17,8.38) ; JUSH1.20 302.83,8.71 302.17,9.37 302.17,9.83 301.78,10.22 CZ66.1
  BOTTOM w0.381: CZ66.1 CZ71.1
  BOTTOM w0.508: CZ71.1 301.82,11.35 v2(301.82,11.84) ; v2(206.19,68.55) 206.09,68.45 JFAN1.4
  BOTTOM w1.016: 352.56,86.21 351.17,87.6 340.1,87.6 332.15,79.65 327.2,79.65 325.7,81.15 311.55,81.15 296.03,65.63 296.03,58.65 294.99,57.61
  vias: v2(123.67,123.01) v2(123.67,122.33) v2(124.43,122.99) v2(124.35,122.3) v2(141.02,103.58) v2(141.78,103.56) v2(153.96,102.93) v2(154.38,102.41) v2(207.97,68.25) v2(208.48,67.42) v2(208.78,68.35) v2(209.3,67.41) v2(278.74,5.96) v2(279.37,5.96) v2(280.01,5.96) v2(280.64,5.96) v2(281.28,5.96) v2(292.68,1.75) v2(293.33,1.72) v2(293.92,1.71) v2(294.26,57.2) v2(294.52,1.69) v2(294.73,56.87) v2(295.12,1.69) v3(329.48,13.74)
+5V_RUN_AUDIO: length 29.3
  TOP w0.508: LA5.2 346.38,47.55 v2(345.93,47.99)
  IN2 w0.508: v2(330.6,32.98) 331.17,33.55 331.17,34.16 331.49,34.48 331.49,37.59 331.92,38.02 331.92,45.08 333.66,46.82 344.76,46.82 v2(345.93,47.99)
  vias: v3(331.56,25.02)
+5V_RUN_AUDIO_UZ5:
  vias: v3(330.5,21.78)
+5V_RUN_CHG: length 2.8
  TOP w0.102: RZ370.2 v1(301.99,50.96)
  TOP w0.508: RZ370.2 301.99,49.11 QZ4.1
+5V_RUN_PVDD_L:
  vias: v3(332.05,36.47)
+5V_RUN_UZ4:
  vias: v3(284.68,9.17)
+5V_TBT_VBUS: length 1.4
  BOTTOM w0.102: CT93.1 37.34,104.69 v3(37.8,104.23)
+5V_TBTA_VBUS_D:
  vias: v1(36.43,111.18)
+5V_TSP:
  vias: v2(123.87,104.65) v2(124.38,104.34) v3(126.49,104.33)
+5V_USB_CHG_PWR: length 19.3
  IN2 w2.54: 341.18,71.46 344.62,71.46 346.25,69.83 346.25,65.28 346.49,65.04 346.49,61.41 349.31,58.58 350.34,58.58
  vias: v2(338.3,71.91) v2(338.27,71.21) v2(338.27,70.45) v2(338.92,71.54) v2(338.92,70.8) v2(352.55,58.38) v2(352.85,57.86) v2(353.22,58.37) v2(353.65,57.83) v2(353.97,58.34) v3(337.82,71.58)
+GND_CHASSIS:
  vias: v1(338.18,117.42) v2(338.49,118.19) v2(339.13,118.19)
+VBUS_DC_SS: length 102.3
  TOP w0.508: 46.53,111.4 46.4,111.28 46.4,107.34 45.39,106.32 43.21,106.32 v3(39.81,102.92) 39.14,102.26 39.14,95.67 40.17,94.63 40.17,94.49 40.3,94.36 40.3,91.05 37.13,87.88 37.13,82.45 34.77,80.09 v2(27.91,80.09)
  IN3 w0.508: v2(15.75,80.62) 15.12,80.62 8.17,73.67 8.17,64.5 10.41,62.25 10.41,45.8 12.68,43.52 v2(13,43.52)
  BOTTOM w0.508: PD903.2 12.85,43.37 v2(13,43.52) ; v2(15.75,80.62) 22.35,80.62 22.94,81.21 26.78,81.21 v2(27.91,80.09)
+VCC1V8A_TBTA_LDO: length 4
  TOP w0.102: v2(28.94,91.91) v1(29.6,91.91)
  TOP w0.508: CT73.1 28.88,91.85 v2(28.94,91.91)
  BOTTOM w0.254: v2(28.94,91.91) 29.86,91 29.86,90.53 30.19,90.19 UT5.K1
+VCC1V8D_TBTA_LDO: length 36.6
  IN3 w0.508: v2(27.33,82.83) 27.56,82.83 27.99,83.26 27.99,87.4 28.27,87.68 28.27,90.35 29.76,91.85 33.32,91.85 38.4,96.93 v2(38.4,97.97)
  BOTTOM w0.254: 30.67,85.17 30.88,85.38 UT5.A2
  BOTTOM w0.381: v2(27.33,82.83) 27.4,82.91 CT72.1 27.99,83.34 28.51,83.86 29.36,83.86 30.67,85.17
  BOTTOM w0.508: v2(38.4,97.97) 38.62,97.97 39.61,96.98 v1(39.61,95.87) 39.61,95.13 41.05,93.69 RT97.1
+VCC_CORE: length 103.6
  TOP w0.457: PC1176.1 111.72,67.82 112.1,67.82 ; PC1051.1 106.89,63.32 v2(107.27,63.32) ; PC1175.1 105.42,67.25 v2(105.02,67.25) ; PC1114.1 107.01,70.89 v2(107.39,70.89) ; PC1180.1 110.15,68.41 v2(109.77,68.41) ; PC1116.1 111.72,70.23 v2(112.1,70.23) ; PC1045.1 105.31,62.7 v2(104.93,62.7) ; PC1054.1 105.41,68.46 v2(105.01,68.46) ; v2(112.1,69.02) 111.72,69.02 PC1046.1 ; PC1172.1 110.65,72.02 v2(110.27,72.02) ; PC1044.1 111.6,63.32 v2(111.98,63.32) ; v2(107.39,68.46) 107.01,68.46 PC1056.1 ; PC1115.1 105.41,70.89 v2(105.01,70.89) ; PC1052.1 103.06,68.46 v2(102.66,68.46) ; PC1173.1 112.35,72.15 v2(112.35,71.77) ; v2(109.78,65.98) 110.15,65.98 PC1177.1 ; v2(112.11,66.61) 111.73,66.61 PC1179.1 ; v2(102.66,69.67) 103.06,69.67 PC1042.1 ; v2(102.66,70.89) 103.06,70.89 PC1113.1 ; v2(102.67,67.25) 103.07,67.25 PC1174.1 ; v2(105.01,69.67) 105.41,69.67 PC1111.1 ; v2(109.64,62.7) 110.02,62.7 PC1043.1 ; PC1178.1 107.01,66.63 v2(107.41,66.63) ; PC1041.1 107.01,69.67 v2(107.39,69.67) ; PC1048.1 110.16,69.61 v2(109.78,69.61) ; v2(110.28,70.82) 110.65,70.82 PC1112.1 ; v2(109.77,67.19) 110.14,67.19 PC1181.1
  TOP w0.508: PC1075.1 v2(106.47,64.94) ; PC1106.1 v2(110.48,64.94) ; PC1108.1 v2(105.86,64.94) ; PC1053.1 v2(100.67,63.52) ; PC1105.1 v2(111.15,64.95)
  BOTTOM w0.203: UC1.AA31 v2(106.18,75.57) ; v2(106.18,75.57) UC1.AB32 ; v2(106.18,75.57) UC1.AB31 ; UC1.AM36 97.97,78.5 v2(98.3,78.17) 97.98,77.85 UC1.AM35 ; v2(105.39,74.93) UC1.AC30 UC1.AC29 ; v2(105.39,74.93) UC1.AC31 ; v2(105.39,74.93) UC1.AB30 UC1.AB29 ; UC1.V33 v2(109.32,76.87) UC1.V34 ; UC1.AC33 v2(105.39,76.22) UC1.AC32 ; UC1.AN35 97.18,77.85 v2(97.51,77.52) 97.19,77.2 UC1.AN34 ; UC1.U34 v2(110.11,77.52) UC1.U35 ; UC1.AP36 96.4,78.5 v2(96.73,78.17) 96.41,77.85 UC1.AP35 ; 104.6,78.17 UC1.AD36 ; 104.6,78.17 UC1.AC36 ; 104.6,78.17 UC1.AD35 ; v2(106.96,80.13) 106.64,79.8 UC1.AA38 ; UC1.AJ33 100.33,76.55 v2(100.66,76.22) 100.66,76.19 100.37,75.9 UC1.AJ32 ; UC1.W37 v2(108.54,78.82) UC1.W36 ; UC1.AD31 v2(104.6,75.57) UC1.AD32 ; v2(109.32,80.13) 109,79.8 UC1.V38 ; UC1.N38 112.81,79.8 112.51,79.51 v2(112.51,79.46) ; v2(109.33,74.94) 109.72,74.56 UC1.U30 UC1.U29 UC1.T29 UC1.T30 v2(110.11,74.93) UC1.U31 ; UC1.AN36 97.19,78.5 v2(97.51,78.82) 97.18,79.15 UC1.AN37 ; UC1.P30 UC1.P29 ; UC1.AD33 v2(104.6,76.87) UC1.AD34 ; UC1.AB35 v2(106.18,78.17) UC1.AB36 ; UC1.R34 v2(111.69,77.52) UC1.R35 ; UC1.R37 v2(111.69,78.82) UC1.R36 ; UC1.AL35 98.76,77.85 v2(99.09,77.52) ; UC1.AL36 98.77,78.5 v2(99.09,78.82) 98.76,79.15 UC1.AL37 ; UC1.AC35 v2(105.39,77.52) UC1.AC34 ; UC1.AA33 v2(106.96,76.22) UC1.AA32 ; UC1.AE35 v2(103.81,77.52) ; UC1.R31 111.22,75.25 v2(110.9,75.57) ; v2(111.7,75.55) 112.04,75.9 UC1.P32 ; UC1.W35 v2(108.54,77.52) ; v2(103.81,80.13) 103.49,79.8 UC1.AE38 ; UC1.AB37 v2(106.18,79.48) UC1.AB38 ; v2(106.96,74.93) 107.34,74.55 UC1.Y30 UC1.Y29 ; v2(112.46,76.23) 112.54,76.23 UC1.N32 ; UC1.AK37 99.41,79.15 v2(99.09,79.48) 99.42,79.8 UC1.AK38 ; UC1.AK33 99.55,76.55 v2(99.88,76.87) 99.55,77.2 UC1.AK34 ; UC1.AL31 98.67,75.25 98.35,75.57 v2(98.3,75.57) ; v2(110.9,75.57) UC1.T31 ; v2(110.9,75.57) UC1.T32 ; v2(103.03,75.57) 103.03,75.61 103.37,75.9 UC1.AE32 ; UC1.T37 v2(110.9,79.48) UC1.T38 ; UC1.V32 v2(109.32,75.57) UC1.V31 ; UC1.AJ34 100.34,77.2 v2(100.66,77.52) 100.33,77.85 UC1.AJ35 ; UC1.W29 UC1.W30 108.11,74.55 v2(107.73,74.93) 108.05,75.25 UC1.W31 ; UC1.AN38 97.19,79.8 v2(97.51,80.13) ; UC1.W38 108.22,79.8 v2(108.54,80.13) ; UC1.Y36 v2(107.75,78.17) UC1.Y35 ; UC1.P34 112.03,77.2 v2(111.68,76.85) 111.98,76.55 UC1.P33 ; UC1.AD37 v2(104.6,79.48) UC1.AD38 ; UC1.T36 v2(110.9,78.17) UC1.T35 ; UC1.P35 112,77.85 v2(111.66,78.19) 111.77,78.19 UC1.P36 ; v2(107.75,75.57) UC1.Y32 ; v2(107.75,75.57) UC1.W32 ; v2(107.75,75.57) UC1.Y31 ; UC1.Y34 107.42,77.2 v2(107.76,76.86) 107.46,76.55 UC1.Y33 ; v2(99.09,76.22) 99.09,76.19 98.8,75.9 UC1.AL32 ; UC1.AL38 98.37,80.13 v2(98.3,80.13) ; UC1.AE36 v2(103.81,78.82) UC1.AE37 ; UC1.N35 v2(112.47,78.17) UC1.N36 ; UC1.AK36 99.55,78.5 v2(99.88,78.17) 100.21,78.5 UC1.AJ36 ; UC1.AF38 102.7,79.8 v2(103.03,79.48) 102.7,79.15 UC1.AF37 ; UC1.V37 v2(109.32,79.48) ; UC1.R38 110.97,80.13 v2(110.9,80.13) ; v2(112.49,78.83) 112.82,79.15 UC1.N37 ; UC1.AA34 v2(106.96,77.52) UC1.AA35 ; UC1.AF35 v2(103.03,78.17) UC1.AF36 ; UC1.AA37 v2(106.96,78.82) UC1.AA36 ; UC1.U32 v2(110.11,76.22) UC1.U33 ; UC1.V36 v2(109.32,78.17) UC1.V35 ; UC1.AM31 97.57,75.59 v2(97.5,75.59) 97.46,75.59 UC1.AN31 ; UC1.R33 v2(111.69,76.22) UC1.R32 ; UC1.AP37 96.41,79.15 v2(96.73,79.48) 96.4,79.8 UC1.AP38 ; v2(110.11,78.82) UC1.U36
  BOTTOM w0.254: v2(97.51,76.22) 97.44,76.22 UC1.AN32 ; v2(97.51,76.22) 97.58,76.22 UC1.AM33 ; v2(97.51,76.22) 97.18,76.55 UC1.AN33 ; v2(97.51,76.22) 97.84,75.9 UC1.AM32 ; UC1.N30 112.99,74.67 112.99,75.13 UC1.N31 112.82,75.25 v2(112.48,75.6) ; UC1.AH13 UC1.AH14 ; UC1.AH14 UC1.AG14 ; UC1.AH14 100.95,61.78 v2(100.57,62.17) ; UC1.AH14 UC1.AJ14 ; v2(111.66,74.9) 112.01,74.55 UC1.P30 ; UC1.P31 112,75.25 v2(111.7,75.55) ; v2(103.03,75.57) 103.1,75.57 UC1.AE31 103.36,75.19 103.36,74.61 UC1.AE30
  vias: v2(72.48,88.47) v2(72.48,87.84) v2(72.48,87.2) v2(72.46,86.64) v2(72.56,90.32) v2(72.56,89.69) v2(72.56,89.05) v2(73.11,88.47) v2(73.11,87.84) v2(73.11,87.2) v2(73.08,86.6) v2(73.2,90.32) v2(73.2,89.69) v2(73.2,89.05) v2(73.75,88.47) v2(73.75,87.84) v2(73.75,87.2) v2(73.71,86.59) v2(73.83,90.32) v2(73.83,89.69) v2(73.83,89.05) v2(73.83,85.95) v2(74.47,90.32) v2(74.47,89.69) v2(74.47,89.05) v2(75.03,89.69) v2(75.03,89.05) v2(75.05,90.32) v2(75.5,89.37) v2(75.6,90) v2(78.13,90.21) v2(78.13,89.57) v2(78.11,87.1) v2(78.15,88.92) v2(78.15,88.29) v2(78.15,87.65) v2(78.76,90.21) v2(78.76,89.57) v2(78.79,88.92) v2(78.79,88.29) v2(78.79,87.65) v2(78.79,87.02) v2(79.4,90.21) v2(79.4,89.57) v2(79.42,88.92) v2(79.42,88.29) v2(79.42,87.65) v2(79.42,87.02) v2(80.01,90.19) v2(80.01,89.56) v2(80.03,88.91) v2(80.06,88.29) v2(80.06,87.65) v2(80.06,87.02) v2(80.64,90.19) v2(80.64,89.56) v2(80.67,88.91) v2(80.69,88.29) v2(80.69,87.65) v2(80.69,87.02) v2(81.33,88.29) v2(81.33,87.65) v2(81.33,87.02) v2(81.33,86.38) v2(84.46,89) v2(84.87,89.47) v2(85.04,90.04) v2(85.09,88.85) v2(85.64,85.89) v2(85.67,90.3) v2(85.67,89.66) v2(85.67,89.03) v2(85.67,88.39) v2(85.67,87.76) v2(85.67,87.12) v2(85.67,86.49) v2(86.31,90.3) v2(86.31,89.66) v2(86.31,89.03) v2(86.31,88.39) v2(86.31,87.76) v2(86.31,87.12) v2(86.31,86.49) v2(86.28,85.89) v2(86.94,90.3) v2(86.94,89.66) v2(86.94,89.03) v2(86.94,88.39) v2(86.94,87.76) v2(86.94,87.12) v2(86.94,86.49) v2(86.91,85.89) v2(87.55,85.89) v2(87.58,88.39) v2(87.58,87.76) v2(87.58,87.12) v2(87.58,86.49) v2(88.21,88.39) v2(88.21,87.76) v2(88.21,87.12) v2(88.21,86.49) v2(88.18,85.89) v2(88.85,88.39) v2(88.85,87.76) v2(88.85,87.12) v2(88.85,86.49) v2(88.82,85.89) v2(90.22,90.27) v2(90.22,89.64) v2(90.22,89) v2(90.8,90.02) v2(91.21,89.6) v2(92.66,90.04) v2(92.66,89.47) v2(92.66,88.9) v2(93.26,90.45) v2(93.26,89.81) v2(93.26,89.18) v2(93.26,88.54) v2(93.26,87.91) v2(93.26,87.27) v2(93.26,86.64) v2(93.33,85.9) v2(93.9,90.45) v2(93.9,89.81) v2(93.9,89.18) v2(93.9,88.54) v2(93.9,87.91) v2(93.9,87.27) v2(93.9,86.64) v2(93.93,85.9) v2(94.53,90.45) v2(94.53,89.81) v2(94.53,89.18) v2(94.53,88.54) v2(94.53,87.91) v2(94.53,87.27) v2(94.53,86.64) v2(94.56,85.9) v2(95.14,85.9) v2(95.17,90.45) v2(95.17,89.81) v2(95.17,89.18) v2(95.17,88.54) v2(95.17,87.91) v2(95.17,87.27) v2(95.17,86.64) v2(95.74,85.9) v2(95.8,90.45) v2(95.8,89.81) v2(95.8,89.18) v2(95.8,88.54) v2(95.8,87.91) v2(95.8,87.27) v2(95.8,86.64) v2(96.44,90.45) v2(96.44,89.81) v2(96.44,89.18) v2(96.44,88.54) v2(96.44,87.91) v2(96.44,87.27) v2(96.44,86.64) v2(96.44,85.9) v2(96.73,75.57) v2(96.74,74.93) v2(96.97,90.06) v2(96.96,89.43) v2(97.19,85.9) v2(97.29,62.34) v2(97.79,85.9) v2(97.96,62.36) v2(98.29,74.93) v2(98.41,90.32) v2(98.41,89.69) v2(98.42,85.9) v2(98.59,73.17) v2(98.99,90.31) v2(98.98,89.69) v2(98.98,89.05) v2(99.01,85.9) v2(99.11,74.93) v2(99.18,73.17) v2(99.21,62.36) v2(99.61,90.32) v2(99.61,89.69) v2(99.61,89.05) v2(99.6,85.9) v2(99.88,75.57) v2(99.87,72.03) v2(99.87,71.4) v2(99.87,70.76) v2(99.87,70.13) v2(100.22,85.9) v2(100.75,87.3) v2(100.66,74.93) v2(100.76,87.91) v2(100.76,86.72) v2(100.76,86.16) v2(101.03,73.17) v2(101.27,62.15) v2(101.42,87.91) v2(101.42,87.27) v2(102.05,87.91) v2(102.05,87.27) v2(102.69,87.91) v2(102.69,87.27) v2(102.66,73.18) v2(103.06,62.25) v2(103.3,90.45) v2(103.3,89.81) v2(103.3,89.18) v2(103.3,88.54) v2(103.3,87.91) v2(103.3,87.27) v2(103.33,73.17) v2(103.73,62.23) v2(104.36,62.18) v2(105.13,73.17) v2(105.27,62.14) v2(105.72,73.17) v2(105.95,62.14) v2(106.35,64.06) v2(107.53,73.17) v2(107.65,62.17) v2(108.15,73.18) v2(108.29,62.17) v2(109.08,62.15) v2(109.77,62.13) v2(109.96,73.17) v2(110.28,72.62) v2(110.42,62.07) v2(110.54,73.17) v2(110.92,64.04) v2(111.79,73.17) v2(112.37,73.17) v2(112.43,61.98) v2(114.5,62.2) v3(90.95,86.28)
+VCC_FUSEPRG: length 11.3
  TOP w0.305: RC326.1 126.94,72.92 121.05,72.92 119.82,74.16 118.57,74.16 118.28,73.87 117.85,73.87 v1(117.78,73.94) 117.49,74.22 117.49,74.28 117.39,74.38 v2(117.39,74.4)
  BOTTOM w0.203: UC1.G30 117.39,74.51 v2(117.39,74.4)
+VCC_GT: length 68.4
  TOP w0.381: v2(94.17,71.12) 93.79,71.12 PC1014.1
  TOP w0.457: v2(89.52,64.24) 89.95,64.24 PC1003.1 ; PC1017.1 92.27,69.87 v2(91.82,69.87) ; PC1006.1 93.79,68.7 v2(94.17,68.7) ; PC1010.1 86.69,71.08 v2(87.11,71.08) ; v2(89.46,71.08) 89.04,71.08 PC1012.1 ; PC1008.1 86.69,64.24 87.11,64.24 v2(87.16,64.2) ; PC1011.1 86.68,69.85 v2(87.12,69.85) ; PC1009.1 89.95,63.02 v2(89.52,63.02) ; PC1005.1 86.69,63.02 87.12,63.02 v2(87.16,62.97) ; PC1002.1 92.39,64.35 v2(92.39,63.94) ; v2(94.19,69.91) 93.79,69.91 PC1001.1 ; PC1013.1 92.27,71.08 v2(91.81,71.08) ; PC1007.1 92.27,68.66 v2(91.81,68.66) ; PC1015.1 88.79,68.4 89.04,68.66 v2(89.46,68.66) ; PC1018.1 86.66,68.63 v2(87.12,68.63) ; v2(89.47,69.87) 89.06,69.87 88.8,69.61 PC1019.1
  BOTTOM w0.102: UC1.BK21 84.26,67.56 v2(83.9,67.91) ; v2(85.36,67.76) 85.09,67.5 UC1.BJ21 ; v2(83.9,63.18) 83.9,63.21 UC1.BK16
  BOTTOM w0.203: UC1.AU36 94.04,78.5 v2(94.36,78.82) 94.04,79.15 UC1.AU37 ; UC1.BB31 90.35,75.57 v2(90.43,75.57) 90.1,75.9 UC1.BB32 ; UC1.AY38 91.67,79.8 v2(92,79.48) 91.68,79.15 UC1.AY37 ; UC1.BH35 85.37,77.85 v2(85.7,77.52) 85.38,77.2 UC1.BH34 ; UC1.BF29 86.84,73.9 86.49,73.51 86.14,73.9 UC1.BG29 ; v2(88.07,80.13) 87.74,79.8 UC1.BE38 ; UC1.BJ38 v2(84.92,80.15) 85.26,79.8 UC1.BH38 85.64,79.48 v2(85.7,79.48) 85.38,79.15 UC1.BH37 ; UC1.BF31 86.96,75.25 v2(87.28,75.57) 86.95,75.9 UC1.BF32 ; UC1.AY36 91.67,78.5 v2(92,78.17) 91.68,77.85 UC1.AY35 ; UC1.BG35 86.16,77.85 v2(86.49,77.52) 86.17,77.2 UC1.BG34 ; UC1.BE37 87.74,79.15 v2(88.07,78.82) 87.74,78.5 UC1.BE36 ; UC1.AV33 93.26,76.55 v2(93.58,76.87) 93.25,77.2 UC1.AV34 ; v2(92.79,80.13) 92.47,79.8 UC1.AW38 ; UC1.BF35 86.96,77.85 v2(87.28,78.17) 86.95,78.5 UC1.BF36 ; UC1.BA31 90.89,75.25 v2(91.21,74.93) 90.84,74.55 UC1.BA30 ; UC1.BC38 89.32,79.8 v2(89.64,80.13) ; UC1.AW33 92.46,76.55 v2(92.79,76.22) 92.47,75.9 UC1.AW32 ; UC1.BD33 88.53,76.55 v2(88.85,76.87) 88.52,77.2 UC1.BD34 ; UC1.BC36 89.32,78.5 v2(89.64,78.82) 89.31,79.15 UC1.BC37 ; UC1.BD36 88.52,78.5 v2(88.85,78.17) 88.53,77.85 UC1.BD35 ; UC1.AT36 94.82,78.5 v2(95.15,78.17) 94.83,77.85 UC1.AT35 ; UC1.BA32 90.89,75.9 v2(91.21,76.22) 90.89,76.55 UC1.BA33 ; UC1.BA36 90.76,78.5 v2(90.43,78.17) ; UC1.BB34 90.1,77.2 v2(90.43,76.87) 90.11,76.55 UC1.BB33 ; UC1.AY32 91.67,75.9 v2(92,75.57) 91.68,75.25 UC1.AY31 ; UC1.BE33 87.74,76.55 v2(88.07,76.22) 87.74,75.9 UC1.BE32 ; UC1.BG31 86.17,75.25 v2(86.49,74.93) 86.87,74.55 UC1.BF30 ; UC1.BB38 90.1,79.8 v2(90.43,79.48) 90.11,79.15 UC1.BB37 ; UC1.AU31 93.89,75.25 v2(93.59,74.94) 93.59,74.94 UC1.AU30 ; UC1.BE35 87.74,77.85 v2(88.07,77.52) 87.74,77.2 UC1.BE34 ; UC1.AW35 92.46,77.85 v2(92.79,77.52) 92.47,77.2 UC1.AW34 ; UC1.BF38 86.95,79.8 v2(87.28,79.48) 86.96,79.15 UC1.BF37 ; UC1.AT31 94.83,75.25 v2(95.15,75.57) 94.82,75.9 UC1.AT32 ; UC1.AV36 93.25,78.5 v2(93.58,78.17) 93.26,77.85 UC1.AV35 ; UC1.AU38 94.04,79.8 v2(94.36,80.13) ; UC1.BB35 90.11,77.85 v2(90.43,78.17) ; v2(85.7,78.17) 85.37,78.5 UC1.BH36 ; UC1.BD32 88.52,75.9 v2(88.85,75.57) 89.17,75.25 UC1.BC31 ; UC1.AW36 92.47,78.5 v2(92.79,78.82) 92.46,79.15 UC1.AW37 ; UC1.BB36 90.1,78.5 v2(90.43,78.17) ; UC1.AV31 93.26,75.25 v2(93.58,75.57) 93.25,75.9 UC1.AV32 ; UC1.BA34 90.89,77.2 v2(91.21,77.52) 90.89,77.85 UC1.BA35 ; UC1.BG33 86.16,76.55 v2(86.49,76.22) ; UC1.AT37 94.83,79.15 v2(95.15,79.48) 94.82,79.8 UC1.AT38 ; UC1.AT34 94.82,77.2 v2(95.15,76.87) 94.83,76.55 UC1.AT33
  BOTTOM w0.254: UC1.BG31 v2(85.7,75.57) UC1.BG32 ; v2(85.7,78.17) 86.03,78.5 UC1.BG36 ; UC1.BT15 UC1.BR15 81.06,62.83 81.61,62.83 UC1.BP15 ; UC1.BT16 80.52,63.4 80.84,63.4 UC1.BR16 UC1.BP16 ; v2(87.3,74.92) 87.63,75.25 UC1.BE31 ; PR1725.2 94.48,82.94 v2(93.29,81.75)
  vias: v2(56.31,62) v2(56.31,61.37) v2(56.31,60.73) v2(56.43,67.84) v2(56.43,67.21) v2(56.43,66.57) v2(56.94,62) v2(56.94,61.37) v2(56.94,60.73) v2(57.07,67.84) v2(57.07,67.21) v2(57.07,66.57) v2(57.58,62) v2(57.58,61.37) v2(57.58,60.73) v2(57.7,67.84) v2(57.7,67.21) v2(57.7,66.57) v2(58.72,64.99) v2(58.72,64.22) v2(58.72,62.7) v2(59.23,69.87) v2(59.23,69.24) v2(59.23,68.6) v2(59.55,64.99) v2(59.55,64.22) v2(59.55,62.7) v2(59.86,69.87) v2(59.86,69.24) v2(59.86,68.6) v2(60.37,64.99) v2(60.37,64.22) v2(60.37,62.7) v2(60.5,69.87) v2(60.5,69.24) v2(60.5,68.6) v2(61.13,69.87) v2(61.13,69.24) v2(61.13,68.6) v2(61.26,64.99) v2(61.26,64.22) v2(61.26,62.7) v2(62.09,64.99) v2(62.09,64.22) v2(65.83,74.89) v2(65.83,74.13) v2(65.83,73.37) v2(65.83,72.61) v2(65.83,71.84) v2(65.83,71.08) v2(65.83,70.32) v2(66.66,74.89) v2(66.66,74.13) v2(66.66,73.37) v2(66.66,72.61) v2(66.66,71.84) v2(66.66,71.08) v2(66.66,70.32) v2(67.48,74.89) v2(67.48,74.13) v2(67.48,73.37) v2(67.48,72.61) v2(67.48,71.84) v2(67.48,71.08) v2(67.48,70.32) v2(68.37,74.13) v2(68.37,73.37) v2(68.37,72.61) v2(68.37,71.84) v2(68.37,71.08) v2(77.68,69.08) v2(77.8,65.34) v2(77.98,67.51) v2(78.12,73.03) v2(79.33,72.96) v2(79.58,69.08) v2(79.7,63.83) v2(81.87,78.38) v2(82.65,63.96) v2(83.27,77.38) v2(83.88,69.46) v2(83.9,64.74) v2(84.58,69.47) v2(84.58,67.11) v2(84.58,66.32) v2(85.44,69.6) v2(85.36,63.31) v2(85.68,72.01) v2(85.7,71.35) v2(85.73,70.09) v2(85.75,69.04) v2(85.68,67.28) v2(85.71,66.71) v2(85.73,66.15) v2(85.72,65.56) v2(85.66,64.4) v2(87.7,62.31) v2(88.32,62.23) v2(88.63,71.65) v2(88.85,74.95) v2(88.93,62.22) v2(89.23,71.65) v2(89.51,66.66) v2(89.52,62.23) v2(90.52,62.23) v2(91.97,74.93) v2(93.25,62.33) v2(93.75,71.72) v2(93.84,62.33) v2(94.34,71.72) v3(63.42,69.4)
