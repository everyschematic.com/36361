# Allegro board LA-F711P R05-0112.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB20_N2_R: length 10.9
  BOTTOM w0.097: LI3.2 20.2,87.32 20.09,87.21 19.96,87.21 19.85,87.32 19.85,87.82 19.8,87.86 19.8,88.23 19.99,88.41 19.99,89.81 19.68,90.12 18.91,90.12 18.82,90.22 DI2.3 17.98,90.19 v4(16.94,90.19) 16.68,90.19 16.43,90.45 16.43,91.09 16.23,91.29 15.97,91.29 JUSB2.2
USB20_N3: length 169.3
  IN3 w0.102: v2(197.34,48.53) 196.95,48.15 195.83,48.15 195.58,47.89 195.09,47.89 193.92,49.07 193.92,56.7 185.51,65.1 184.36,65.1 166.44,83.03 164.13,83.03 152.73,94.43 152.73,96.74 139.19,110.28 135.24,110.28 125.51,120 93.64,120 93.17,120.47 79.35,120.47 78.47,121.35 77.42,121.35 v2(77.4,121.37)
  BOTTOM w0.089: UH1.K4 197.29,42.01 197.28,42.01 197.1,42.19 197.1,42.64 197.18,42.72 197.18,42.79 197.23,42.84 197.23,44.67 196.5,45.4 196.5,48.26 196.69,48.45 197.26,48.45 v2(197.34,48.53)
  BOTTOM w0.097: v2(77.4,121.37) 77.4,121.22 77.15,120.97 76.97,120.97 76.54,121.4 76.54,121.45 76.21,121.78 76.16,121.78 75.72,122.21 75.72,123.15 76.03,123.46 76.16,123.46 76.26,123.36 76.26,123.14 76.35,123.04 LI4.1
USB20_N3_R: length 13.3
  TOP w0.097: v2(83.24,121.78) 83.41,121.95 83.68,121.95 84.68,122.95 84.74,122.95 85.15,123.36 85.15,123.42 86.26,124.53 86.26,125.41 JUSB3.2
  BOTTOM w0.097: LI4.2 78.57,123.04 78.78,123.25 80.14,123.25 81.41,121.98 81.64,121.98 81.73,121.88 81.73,121.36 DI3.3 82.24,121.36 82.24,121.78 82.34,121.88 83.14,121.88 v2(83.24,121.78)
USB20_N4: length 222.2
  IN3 w0.089: 193.15,39.84 193.17,39.84 193.19,39.86 195.07,39.86 195.92,39 195.92,38.26 196.18,38.01 196.55,38.01 196.66,38.11 196.94,38.11 196.95,38.1 v2(197,38.1)
  IN3 w0.102: 193.15,39.84 192.81,39.84 191.19,41.45 185.97,41.45 183.25,44.17 182.37,44.17 176.42,50.12 176.42,64.07 169.47,71.02 167.44,71.02 147.52,90.93 138.92,90.93 131.12,98.74 130,98.74 125.06,103.68 123.79,103.68 122.65,104.82 122.65,105.56 120.79,107.43 119.21,107.43 113.07,113.57 101.92,113.57 101.34,114.16 90.97,114.16 90.38,113.57 78,113.57 72.2,107.77 71.02,107.77 69.92,106.67 65.83,106.67 65.44,106.28 61.33,106.28 60,104.96 40.39,104.96 37.18,101.75 37.18,101.29 32.38,96.49 32.38,95.85 32.17,95.64 32.17,95.31 v2(32.58,94.89)
  BOTTOM w0.076: 32.3,93.6 32.28,93.57 32.28,92.34 32.62,91.99 32.62,90.43 UT5.K5
  BOTTOM w0.089: UH1.M10 198.32,39.1 198.17,39.26 198.09,39.27 197.89,39.09 197.89,38.64 197.65,38.4 197.09,38.4 197,38.31 197,38.1 v2(197,38.1)
  BOTTOM w0.097: v2(32.58,94.89) 32.36,94.67 32.36,94.49 32.3,94.43 32.3,93.6
USB20_N6: length 1.6
  TOP w0.089: v2(196.82,40.01) 197.08,40.01 T300.1
  BOTTOM w0.094: v2(196.82,40.01) 196.83,40.01 197.2,40.38 UH1.K7
USB20_N8: length 166.5
  TOP w0.097: RI48.1 326.67,52.92 LI8.4 326.54,52.45 326.49,52.4 326.49,51.76 326.16,51.43 325,51.43 323,53.43 v2(322.17,53.43)
  IN1 w0.099: v2(194.96,48.62) 195.24,48.9 195.4,48.9 195.62,49.12 195.62,50.76 196.7,51.84 202.16,51.84 203.95,50.05 203.95,50.05 203.99,50.01 205.48,50.01 206.19,49.3 207.07,49.3 v2(207.25,49.12)
  IN3 w0.102: v2(322.17,53.43) 321.99,53.61 321.01,53.61 319.68,52.27 318.11,52.27 317.58,51.75 310.84,51.75 306.51,47.42 302.07,47.42 301.31,46.66 301.31,42.91 299.51,41.11 299.51,41.01 298.76,40.26 297.91,40.26 293.51,35.86 283.94,35.86 283.37,35.29 282.26,35.29 280.54,33.58 277.85,33.58 277.17,32.9 271.9,32.9 270.27,31.27 268.16,31.27 267.7,30.81 252.69,30.81 252.24,31.27 250.5,31.27 249.57,32.19 246.83,32.19 246.14,32.88 244.3,32.88 244.2,32.99 239.87,32.99 239.66,32.78 238.48,32.78 237.65,33.61 237.65,33.69 228.92,42.42 228.68,42.42 224.44,46.65 223.37,46.65 220.79,49.24 217.08,49.24 215.89,50.43 209.68,50.43 208.56,49.31 207.43,49.31 v2(207.25,49.12)
  BOTTOM w0.089: v2(194.96,48.62) 194.96,48.83 195.13,49 195.26,49 195.42,48.83 195.42,44.91 196.01,44.33 196.01,43.45 195.83,43.26 195.83,42.99 195.76,42.92 195.76,42.36 195.93,42.19 195.93,42 195.83,41.89 195.65,41.89 195.61,41.93 UH1.G4
USB20_N8_R: length 3.2
  TOP w0.097: v2(326.64,54.89) 326.39,54.64 326.39,54.45 326.54,54.3 LI8.3 326.72,53.86 RI48.2
  BOTTOM w0.097: v2(326.64,54.89) 326.49,54.74 326.49,54.19 326.65,54.03 JNGFF2.9
USB20_N9: length 98.4
  IN3 w0.089: 195.86,43.44 195.91,43.4 195.91,43.39 197.49,41.8 197.49,41.06 197.65,40.9 197.78,40.89 197.88,40.96 197.94,41.16 v2(197.95,41.17)
  IN3 w0.102: v2(135.74,102.26) 136.03,101.97 136.61,101.97 137.01,101.57 137.01,99.33 141.22,95.11 148.8,95.11 162.76,81.15 165.15,81.15 184.53,61.77 185.61,61.77 190.81,56.57 190.81,48.49 195.84,43.46 195.86,43.44
  BOTTOM w0.094: UH1.M6 198.04,41.08 v2(197.95,41.17)
  BOTTOM w0.097: v2(135.74,102.26) 135.44,101.96 134.62,101.96 134.27,102.31 133.02,102.31 132.84,102.5 LV27.3
USB20_N9_R: length 12.5
  BOTTOM w0.097: JEDP1.2 123.15,105.7 122.84,105.39 122.84,104.86 123.92,103.78 124.21,103.78 124.25,103.81 124.83,103.81 124.87,103.78 125.51,103.78 126.01,103.28 127.1,103.28 128.04,102.34 128.4,102.34 128.58,102.52 DV4.2 128.81,103.29 129.76,102.34 130.74,102.34 130.9,102.5 LV27.4
USB20_N10: length 193.5
  IN1 w0.099: v2(184.39,28.88) 184.64,28.63 185.01,28.63 185.31,28.33 185.31,20.92 196.33,9.91 209.62,9.91 211.65,7.88 212.85,7.88 213.19,7.54 218.78,7.54 219.41,6.91 223.75,6.91 224.72,5.94 232.97,5.94 233.31,6.27 255.45,6.27 257.41,8.24 265.88,8.24 267.84,10.2 278.09,10.2 279.4,8.89 292.52,8.89 293.09,8.32 308.34,8.32 308.85,7.8 v2(308.85,6.9)
  BOTTOM w0.089: UH1.H3 196.55,42.72 196.55,43.16 196.58,43.19 196.58,44.55 195.97,45.16 195.97,49.34 195.08,50.23 191.86,50.23 191.86,50.23 191.84,50.23
  BOTTOM w0.097: v2(184.39,28.88) 184.39,28.87 184.6,28.66 184.69,28.66 184.79,28.76 184.79,29.55 184.47,29.87 184.47,34.01 181.63,36.86 181.63,42.88 180.13,44.38 180.13,46.48 179.85,46.76 179.85,51.14 181,52.29 189.78,52.29 191.84,50.23 ; JUSH1.8 308.83,8.2 308.83,7.7 308.66,7.52 308.66,7.09 v2(308.85,6.9)
USB20_N11: length 115.5
  IN3 w0.102: v2(140.03,98.46) 140.14,98.35 141.26,98.35 143.29,96.32 148.48,96.32 163.02,81.78 165.65,81.78 184.39,63.04 185.28,63.04 192.14,56.18 192.14,48.19 198.1,42.22 198.1,41.89 198.83,41.17 198.83,40.29 199.17,39.94 199.17,39.62 198.77,39.21 198.77,39.07 v2(198.88,38.97)
  BOTTOM w0.094: v2(198.88,38.97) UH1.R10
  BOTTOM w0.097: v2(140.03,98.46) 139.87,98.3 127.68,98.3 127.24,97.87 121.15,97.87 117.87,101.15 117.87,101.79 118.01,101.93 LZ1.1
USB20_N11_R: length 3.1
  BOTTOM w0.097: LZ1.2 118.01,103.93 117.82,104.12 117.82,105.28 117.99,105.45 117.99,105.65 118.15,105.81 JEDP1.12
USB20_N14: length 127.1
  TOP w0.089: 196.27,50.15 196.26,50.15 196.26,47.92 194.61,46.27 193.32,46.27 192.64,45.59 192.64,44.49 193.01,44.12 193.01,43.1 194.51,41.6 195.01,41.6 195.12,41.67 v2(195.19,41.95)
  TOP w0.097: v2(195.63,53.59) 195.83,53.39 196.01,53.39 196.27,53.13 196.27,50.15
  IN3 w0.102: v2(195.63,53.59) 195.84,53.38 196.76,53.38 197.67,54.29 217.13,54.29 217.98,53.44 221.71,53.44 224.89,50.26 227.01,50.26 233.42,43.85 234.12,43.85 239.01,38.96 243.15,38.96 243.93,38.19 249.06,38.19 249.93,37.32 252.5,37.32 253.04,36.78 263.75,36.78 264.44,37.07 266.62,37.07 266.95,37.4 268.12,37.4 269.58,38.86 270.01,38.86 270.13,38.98 272.15,38.98 272.46,39.3 277.5,39.3 278.78,40.58 279.17,40.58 280.48,41.9 284.2,41.9 285.52,40.58 289.74,40.58 289.82,40.65 289.82,40.83 v2(289.56,41.1)
  BOTTOM w0.089: UH1.E5 195.19,41.78 v2(195.19,41.95)
  BOTTOM w0.097: RI50.1 290.99,37.43 LI9.1 290.47,37.56 290.27,37.75 289.79,37.75 289.58,37.95 289.58,40.03 289.76,40.21 289.76,40.9 v2(289.56,41.1)
USB20_N14_R: length 3.1
  BOTTOM w0.097: RI50.2 291.9,37.35 LI9.2 292.59,37.56 292.74,37.7 293.47,37.7 293.51,37.73 293.67,37.73 293.79,37.61 JNGFF1.5
USB20_P1: length 183.4
  TOP w0.097: UI3.3 340.5,66.81 340.34,66.65 340.34,64.74 340.44,64.64 340.44,64.29 v2(340.63,64.11)
  IN1 w0.099: v2(340.63,64.11) 340.52,64 340.52,63.52 339.24,62.23 333.71,62.23 331.55,60.08 324.16,60.08 323.74,59.66 321.9,59.66 320.8,58.56 320.8,55.62 319.86,54.67 315.11,54.67 313.01,56.77 309.27,56.77 306.69,54.19 304.98,54.19 v2(304.84,54.05)
  IN3 w0.102: v2(196.85,49.66) 196.85,49.76 197.04,49.95 197.28,49.95 197.67,50.34 197.67,51.59 199.53,53.45 216.78,53.45 217.63,52.59 221.36,52.59 224.54,49.42 226.6,49.42 233.09,42.92 233.85,42.92 238.66,38.12 242.8,38.12 243.58,37.35 248.7,37.35 249.56,36.48 252.15,36.48 252.69,35.94 266.68,35.94 267.3,36.56 268.55,36.56 269.46,37.47 272.03,37.47 272.87,38.31 277.81,38.31 279.06,39.56 292.24,39.56 294.87,42.19 294.87,45.81 303.23,54.17 304.72,54.17 v2(304.84,54.05)
  BOTTOM w0.089: v2(196.85,49.66) 197.05,49.66 197.14,49.75 197.14,50 197.05,50.09 196.46,50.09 196.32,49.95 196.32,45.33 196.97,44.68 196.97,44.67 196.99,44.66 196.99,43.11 196.95,43.07 196.95,42.9 UH1.J2
USB20_P2: length 266.8
  IN3 w0.102: v2(22.91,86.59) 22.95,86.63 22.95,86.76 23.29,87.11 23.82,87.11 24.05,87.34 24.05,88.57 22.22,90.4 22.22,102.13 22.08,102.27 22.08,102.96 23.1,103.97 23.1,106.26 23.98,107.15 23.98,107.73 24.68,108.43 24.68,113.76 25.95,115.03 25.95,116.17 27.21,117.43 29.61,117.43 30.84,116.2 30.84,114.3 31.13,114.01 31.13,112.12 35.09,108.16 36.47,108.16 37.01,107.62 42.07,107.62 42.2,107.49 59.22,107.49 60.89,109.16 68.49,109.16 75.71,116.38 77.14,116.38 77.78,117.03 82.23,117.03 84.72,119.52 92.72,119.52 93.1,119.14 124.53,119.14 137.66,106 142.22,106 148.91,99.31 148.91,96.45 163.18,82.18 166.04,82.18 184.64,63.59 185.72,63.59 192.65,56.66 192.65,48.25 193.85,47.05 194.88,47.05 200.1,41.83 200.1,40.28 199.65,39.84 199.65,36.83 199.43,36.61 198.85,36.61 198.69,36.78 198.69,37.26 198.79,37.36 198.97,37.36 199.08,37.26 199.08,37.07 v2(199.06,37.05)
  BOTTOM w0.094: v2(199.06,37.05) 198.98,37.05 UH1.N15
  BOTTOM w0.097: LI3.4 22.14,86.72 22.31,86.89 22.61,86.89 v2(22.91,86.59)
USB20_P2_R: length 11
  BOTTOM w0.097: LI3.3 20.29,86.72 19.98,87.02 19.88,87.02 19.62,87.28 v4(19.62,87.53) 19.62,88.3 19.8,88.49 19.8,89.74 19.6,89.94 18.91,89.94 18.82,89.84 DI2.2 17.91,90.01 17.27,90.01 17.23,89.97 16.64,89.97 16.24,90.37 16.24,91.01 16.15,91.11 15.95,91.11 JUSB2.3
USB20_P3: length 169.4
  IN3 w0.102: v2(77.39,120.64) 77.88,121.13 78.38,121.13 79.26,120.25 93.08,120.25 93.55,119.79 125.42,119.79 135.15,110.06 139.1,110.06 152.51,96.64 152.51,94.34 164.04,82.81 166.35,82.81 184.27,64.88 185.42,64.88 193.7,56.61 193.7,48.98 195,47.67 195.67,47.67 195.92,47.93 197.26,47.93 v2(197.34,47.85)
  BOTTOM w0.089: v2(197.34,47.85) 197.34,48.02 197.09,48.27 196.76,48.27 196.67,48.18 196.67,45.48 197.42,44.73 197.42,42.69 197.58,42.53 197.58,42.26 197.49,42.17 197.4,42.17 197.32,42.25 UH1.K3
  BOTTOM w0.097: v2(77.39,120.64) 77.25,120.78 76.89,120.78 75.54,122.14 75.54,123.22 75.95,123.64 LI4.4
USB20_P3_R: length 13.3
  TOP w0.097: v2(83.24,122.36) 83.47,122.13 83.6,122.13 v4(84.78,123.32) 86.08,124.61 86.08,125.42 85.75,125.75 85.6,125.75 JUSB3.3
  BOTTOM w0.097: LI4.3 78.57,123.64 78.78,123.43 80.22,123.43 81.49,122.16 81.64,122.16 81.73,122.26 81.73,122.78 DI3.2 82.24,122.78 82.24,122.26 82.44,122.07 82.94,122.07 v2(83.24,122.36)
USB20_P4: length 222.2
  IN3 w0.089: 193.15,40.06 193.17,40.06 193.19,40.03 195.14,40.03 196.1,39.08 196.1,38.34 196.25,38.18 196.48,38.18 196.57,38.27 v2(196.57,38.49)
  IN3 w0.102: v2(31.95,94.89) 31.95,95.73 32.16,95.95 32.16,96.58 36.96,101.39 36.96,101.84 40.3,105.18 59.91,105.18 61.24,106.5 65.35,106.5 65.74,106.89 69.83,106.89 70.93,107.99 72.11,107.99 77.91,113.79 90.29,113.79 90.88,114.38 101.43,114.38 102.01,113.79 113.16,113.79 119.3,107.64 120.88,107.64 122.87,105.65 122.87,104.91 123.88,103.9 125.15,103.9 130.09,98.96 131.21,98.96 139.01,91.15 147.62,91.15 167.53,71.24 169.56,71.24 176.64,64.16 176.64,50.21 182.46,44.39 183.34,44.39 186.06,41.67 191.28,41.67 192.9,40.06 193.15,40.06
  BOTTOM w0.076: 32.12,93.66 32.12,93.65 32.11,93.64 32.11,92.27 32.46,91.92 32.46,91.82 32.38,91.74 32.14,91.74 32.06,91.66 32.06,91.54 32.14,91.45 32.38,91.45 32.46,91.38 32.46,90.77 UT5.L5
  BOTTOM w0.089: v2(196.57,38.49) 196.9,38.49 196.98,38.58 197.58,38.58 197.71,38.71 197.71,39.17 197.9,39.33 197.9,39.43 UH1.L9
  BOTTOM w0.097: 32.12,93.66 32.12,94.51 32.18,94.57 32.18,94.67 v2(31.95,94.89)
USB20_P6: length 1.3
  TOP w0.089: v2(196.65,40.57) 196.65,40.73 T301.1
  BOTTOM w0.094: v2(196.65,40.57) 196.65,40.57 196.99,40.9 UH1.K6
USB20_P8: length 166.5
  TOP w0.097: RI47.1 325.91,52.92 LI8.1 326.04,52.49 326.3,52.23 326.3,51.83 326.09,51.62 325.07,51.62 323.08,53.61 322.55,53.61 322.17,54 v2(322.17,54.01)
  IN1 w0.099: v2(194.97,49.36) 194.97,49.26 195.12,49.11 195.31,49.11 195.41,49.21 195.41,50.85 196.61,52.05 202.25,52.05 204.03,50.26 204.04,50.26 204.08,50.22 205.57,50.22 206.28,49.51 207.05,49.51 v2(207.25,49.71)
  IN3 w0.102: v2(322.17,54.01) 321.98,53.82 320.92,53.82 319.59,52.49 318.02,52.49 317.49,51.97 310.74,51.97 306.42,47.64 301.98,47.64 301.09,46.75 301.09,43 299.29,41.2 299.29,41.1 298.67,40.48 297.82,40.48 293.42,36.08 283.85,36.08 283.28,35.51 282.17,35.51 280.45,33.79 277.76,33.79 277.08,33.12 271.81,33.12 270.18,31.49 268.06,31.49 267.61,31.03 252.79,31.03 252.33,31.49 250.59,31.49 249.67,32.41 246.92,32.41 246.23,33.1 244.39,33.1 244.29,33.21 239.78,33.21 239.57,33 238.57,33 237.87,33.7 237.87,33.78 229.01,42.64 228.77,42.64 224.53,46.87 223.46,46.87 220.88,49.46 217.17,49.46 215.98,50.65 209.59,50.65 208.47,49.52 207.43,49.52 v2(207.25,49.71)
  BOTTOM w0.089: UH1.G5 195.89,41.7 196.12,41.94 196.12,42.25 196.07,42.3 196.07,42.32 195.95,42.44 195.95,42.84 196.02,42.91 196.02,43.19 196.2,43.37 196.2,44.41 195.6,45.01 195.6,48.9 195.33,49.17 195.11,49.17 194.97,49.31 v2(194.97,49.36)
USB20_P8_R: length 3.2
  TOP w0.097: v2(326.06,54.89) 326.21,54.74 326.21,54.46 326.04,54.29 LI8.2 325.86,53.87 RI47.2
  BOTTOM w0.097: JNGFF2.7 326.15,54.03 326.31,54.19 326.31,54.64 v2(326.06,54.89)
USB20_P9: length 98.5
  IN3 w0.089: 195.8,43.23 195.81,43.23 197.32,41.72 197.32,40.98 197.57,40.73 198.08,40.68 198.09,40.68 v2(198.24,40.64)
  IN3 w0.102: v2(135.74,101.52) 135.97,101.75 136.52,101.75 136.79,101.48 136.79,99.24 141.13,94.89 148.71,94.89 162.67,80.93 165.06,80.93 184.44,61.55 185.52,61.55 190.6,56.47 190.6,48.4 195.76,43.23 195.8,43.23
  BOTTOM w0.094: v2(198.24,40.64) 198.24,40.59 198.53,40.29 UH1.N8
  BOTTOM w0.097: LV27.2 132.84,101.9 133.06,102.13 134.19,102.13 134.54,101.78 135.48,101.78 v2(135.74,101.52)
USB20_P9_R: length 12.4
  BOTTOM w0.097: LV27.1 130.95,101.9 130.7,102.15 129.85,102.15 129.06,101.36 DV4.3 128.58,101.95 128.38,102.15 127.96,102.15 127.02,103.09 125.94,103.09 125.43,103.59 v4(124.54,103.59) 123.84,103.59 122.65,104.79 JEDP1.3
USB20_P10: length 193.4
  IN1 w0.099: v2(184.41,28.04) 184.41,28.14 184.69,28.42 184.92,28.42 185.1,28.24 185.1,20.84 196.24,9.7 209.53,9.7 211.57,7.67 212.76,7.67 213.1,7.33 218.69,7.33 219.32,6.7 223.66,6.7 224.63,5.73 233.06,5.73 233.4,6.06 255.53,6.06 257.5,8.03 265.97,8.03 267.93,9.99 278,9.99 279.31,8.68 292.43,8.68 293,8.11 308.25,8.11 308.64,7.72 308.64,7.26 308.29,6.91 v2(308.15,6.91)
  BOTTOM w0.089: UH1.H2 196.37,43.04 196.37,43.25 196.39,43.27 196.39,44.47 195.79,45.07 195.79,49.26 195,50.05 191.86,50.05 191.86,50.05 191.85,50.05 191.85,50.05 191.76,50.05 191.72,50.09 191.72,50.09 191.71,50.1
  BOTTOM w0.097: v2(308.15,6.91) 308.45,7.21 308.45,7.53 308.33,7.65 JUSH1.9 ; 191.71,50.1 189.7,52.11 181.07,52.11 180.03,51.07 180.03,46.84 180.32,46.55 180.32,44.45 181.81,42.96 181.81,36.93 184.66,34.09 184.66,29.94 184.98,29.62 184.98,28.68 184.77,28.47 184.21,28.47 184.11,28.38 184.11,28.14 184.21,28.04 v2(184.41,28.04)
USB20_P11: length 115.5
  IN3 w0.102: v2(140.03,97.72) 140.03,97.89 140.27,98.13 141.17,98.13 143.2,96.1 148.39,96.1 162.92,81.56 165.56,81.56 184.3,62.82 185.19,62.82 191.92,56.09 191.92,48.1 197.89,42.13 197.89,41.84 198.61,41.12 198.61,40.19 198.97,39.83 198.97,39.69 198.88,39.59 198.68,39.59 v2(198.57,39.7)
  BOTTOM w0.094: v2(198.57,39.7) UH1.P9
  BOTTOM w0.097: v2(140.03,97.72) 140.03,97.87 139.79,98.11 127.75,98.11 127.32,97.68 121.08,97.68 117.69,101.07 117.69,101.74 117.41,102.01 LZ1.4
USB20_P11_R: length 3.1
  BOTTOM w0.097: JEDP1.13 117.65,106.42 117.65,105.82 117.8,105.66 117.8,105.53 117.63,105.35 117.63,104.12 117.41,103.9 LZ1.3
USB20_P14: length 127.1
  TOP w0.089: 196.08,50.15 196.08,50.15 196.08,47.99 194.54,46.44 193.24,46.44 192.46,45.67 192.46,44.41 192.83,44.05 192.83,43.03 194.44,41.43 195.08,41.43 195.12,41.46 195.21,41.51 v2(195.48,41.44)
  TOP w0.097: 196.08,50.15 196.08,53.05 195.95,53.18 195.81,53.18 v2(195.63,53)
  IN3 w0.102: v2(290.14,41.1) 290.04,41 290.04,40.56 289.84,40.36 285.42,40.36 284.11,41.68 280.57,41.68 279.26,40.36 278.87,40.36 277.59,39.08 272.55,39.08 272.24,38.76 270.22,38.76 270.1,38.65 269.67,38.65 268.21,37.18 267.04,37.18 266.71,36.86 264.49,36.86 263.79,36.56 252.95,36.56 252.41,37.11 249.84,37.11 248.97,37.97 243.83,37.97 243.06,38.74 238.91,38.74 234.03,43.63 233.33,43.63 226.92,50.04 224.8,50.04 221.62,53.22 217.89,53.22 217.04,54.07 197.76,54.07 196.85,53.16 195.79,53.16 v2(195.63,53)
  BOTTOM w0.089: v2(195.48,41.44) 195.37,41.33 UH1.F6
  BOTTOM w0.097: v2(290.14,41.1) 289.94,40.9 289.94,40.13 289.77,39.95 289.77,38.03 289.86,37.93 290.2,37.93 290.32,38.06 LI9.4 290.99,38.18 RI49.1
USB20_P14_R: length 3.1
  BOTTOM w0.097: RI49.2 291.9,38.26 LI9.3 292.65,38.06 292.78,37.92 293.65,37.92 293.84,38.11 JNGFF1.3
USB_OC0#: length 201.6
  TOP w0.102: UI3.13 337.55,69.7 337.42,69.83 333.88,69.83 332.53,68.48 332.53,67.33 329.42,64.22 329.42,60.73 327.16,58.47 326.25,58.47 324.57,60.15 321.59,60.15 319.99,61.75 v1(306.6,61.75) 300.5,61.75 295.93,57.18 295.93,55.63 294.03,53.72 294.03,46.55 294.35,46.22 294.35,40.63 290.86,37.14 289.52,37.14 288.41,36.03 288.41,31.09 284.57,27.24 284.57,19.56 281.28,16.27 281.23,16.27 v2(281.16,16.2) ; RPH8.3 198.85,18.08 198.98,18.21 v2(199.36,18.21)
  IN1 w0.099: v2(199.36,18.21) 199.77,18.21 200.92,17.06 204.88,17.06 205.37,16.57 208.37,16.57 208.61,16.82 209.62,16.82 210.22,16.21 211.76,16.21 211.94,16.4 215.21,16.4 215.29,16.49 221.8,16.49 221.98,16.31 228.87,16.31 230.38,14.8 232.33,14.8 232.78,15.25 235.89,15.25 237.04,14.1 243.58,14.1 244.52,15.04 277.61,15.04 278.84,16.27 280.1,16.27 280.1,16.27 281.09,16.27 v2(281.16,16.2)
  IN2 w0.102: v2(199.36,18.21) 199.35,18.22 199.35,18.54 199.78,18.96 199.78,19.75 203.95,23.93 v2(205.2,23.93)
  BOTTOM w0.089: v2(205.2,23.93) 205.62,24.35 205.62,25.74 206.09,26.21 UH1.AH36 ; v2(199.36,18.21) 199.35,18.19 199.35,16.48
  BOTTOM w0.102: RPH6.3 199.35,16.48
USB_OC1#: length 304.6
  TOP w0.102: v2(198.85,19.34) v1(198.46,18.95) 198.02,18.51 198.02,17.31 198.28,17.05 199.25,17.05 199.35,17.15 RPH8.2
  IN1 w0.099: v2(178.4,74.86) 178.11,74.57 176.92,74.57 173.21,78.28 172.45,78.28 163.41,87.32 144.32,106.42 144.32,109.85 136.7,117.47 123.08,117.47 120.63,115.02 117.79,115.02 112.02,120.8 101.97,120.8 98.78,117.6 84.68,117.6 84.32,117.96 77.34,117.96 76.37,116.99 75.62,116.99 70.76,112.13 66.66,112.13 66,111.47 63.31,111.47 62.51,110.67 54.87,110.67 54.64,110.44 47.93,110.44 47.71,110.65 33.18,110.65 31.48,112.36 31.48,114.07 31.06,114.49 31.06,115.06 30.55,115.57 30.55,116.43 29.37,117.61 28.05,117.61 25.08,114.64 23.48,114.64 23.01,114.17 23.01,108.65 22.34,107.97 22.34,106.77 21.57,106.01 21.57,104.86 v2(21.45,104.74)
  IN2 w0.102: v2(180.06,54.01) 179.54,54.01 177.38,56.17 177.38,73.84 v2(178.4,74.86) ; v2(198.85,19.34) 199.04,19.52 199.04,20.77 202.78,24.51 205.71,24.51 206.26,23.96 206.72,23.96 v2(206.74,23.98)
  BOTTOM w0.089: 198.85,16.48 198.85,16.95 199,17.1 199,19.19 v2(198.85,19.34) ; v2(206.74,23.98) 207.34,24.58 UH1.AL40
  BOTTOM w0.102: UI1.3 20.44,98.67 21.28,99.52 21.28,102.54 20.9,102.92 20.9,104.19 v2(21.45,104.74) ; v2(180.06,54.01) 179.44,53.4 179.44,46.59 179.73,46.31 179.73,44.21 181.23,42.71 181.23,36.69 184.07,33.84 184.07,29.78 183.4,29.11 183.4,28.24 184.46,27.17 184.46,25.64 183.3,24.48 183.3,21.43 190.62,14.11 196.73,14.11 198.22,15.6 198.59,15.6 198.85,15.86 RPH6.2 198.85,16.48
USB_OC2#: length 209.2
  TOP w0.102: v2(200.34,19.53) 199.8,19.53 198.41,18.14 198.41,18.13 198.35,18.07 RPH8.4 ; v2(171.14,99.59) 171.14,97.59 v1(168.58,95.02) 167.36,93.8 167.36,78.86 186.53,59.69 v2(186.53,59.32)
  IN1 w0.089: 199.9,39.12 199.9,39.85 200.2,40.15 200.2,41.72 198.93,42.99 196.99,42.99 196.64,43.33 ; v2(207.21,22.5) 205.67,22.5
  IN1 w0.099: 196.64,43.33 195.84,44.13 188.48,44.13 187.5,45.11 v2(187.5,45.19) ; 199.9,39.12 199.9,33.25 198.15,31.5 198.15,29.1 198.56,28.69 199.78,28.69 201.49,26.98 201.73,26.98 202.36,26.35 202.36,25.15 202.83,24.68 203.42,24.68 205.6,22.5 205.67,22.5
  IN2 w0.122: v2(200.34,19.53) 200.44,19.63 200.44,20.08 202.93,22.56 206.65,22.56 206.72,22.49 207.21,22.49 v2(207.21,22.5)
  IN3 w0.102: v2(186.53,59.32) 187.18,58.67 187.18,47.54 187.5,47.22 v2(187.5,45.19)
  BOTTOM w0.089: v2(207.21,22.5) 207.21,22.48 207.13,22.39 UH1.AJ44 ; v2(200.34,19.53) 200.71,19.16 200.71,18.14 199.85,17.28 199.85,16.48
  BOTTOM w0.102: v2(171.14,99.59) 171.14,100.58 148.81,122.92 126.22,122.92 123.8,120.5 105.51,120.5 101.11,124.89 98.08,124.89 97.1,123.91 UI2.3 ; 199.85,16.48 RPH6.4
USB_OC3#: length 20.8
  TOP w0.089: 199.85,17.91 199.85,18.48 199.77,18.56 v1(199.77,19) 200.14,19 v2(200.33,18.81)
  TOP w0.102: RPH8.1 199.85,17.91
  IN2 w0.122: v2(200.33,18.81) 200.59,18.81 201.29,19.51 201.29,20.57 203.03,22.31 206.38,22.31 206.62,22.07 207.41,22.07 207.63,22.29 207.63,24.11 v2(207.89,24.37)
  BOTTOM w0.089: v2(200.33,18.81) 200.33,18.99 199.46,19.86 198.81,19.86 198.35,19.4 198.35,18.99 198.83,18.51 198.83,17.36 198.35,16.89 198.35,16.48 ; UH1.AL41 207.89,24.18 v2(207.89,24.37)
  BOTTOM w0.102: 198.35,16.48 RPH6.1
USB_OC4#: length 12.7
  TOP w0.102: RPH7.1 216.26,23.96 216.44,23.78 216.44,22.38 216.23,22.18 215.56,22.18 214.34,23.4 213.15,23.4 212.73,23.82 212.58,23.82 212.3,24.11 211.81,24.11 211.61,23.91 211.61,23.46 212.11,22.97 212.11,22.3 211.86,22.06 211.52,22.06 211.37,21.9 211.37,21.51 v1(211,21.15) 210.78,20.93 v2(210.78,20.61)
  BOTTOM w0.089: UH1.AV47 210.84,20.66 v2(210.78,20.61)
USB_OC5#: length 7.7
  TOP w0.102: RPH7.2 215.33,23.46 214.14,24.65 213.87,24.65 v1(213.41,25.11) 213.28,25.24 212.45,25.24 212.28,25.41 212.1,25.41 211.43,26.08 210.43,26.08 210.08,26.43 v2(210.02,26.43)
  BOTTOM w0.089: v2(210.02,26.43) 210.01,26.43 209.57,26.87 UH1.AR35
USB_OC6#: length 7.8
  TOP w0.102: RPH7.3 215.39,22.96 215.29,23.06 215.29,23.21 214.06,24.44 213.61,24.44 213.02,25.03 212.39,25.03 212.23,25.19 211.85,25.19 v1(211.55,25.49) 211.16,25.88 210.09,25.88 210.04,25.83 v2(210.02,25.83)
  BOTTOM w0.089: v2(210.02,25.83) 210.02,25.83 209.88,25.83 209.6,26.1 UH1.AR37
USB_OC7#: length 7
  TOP w0.102: v2(211.34,23.1) 211.23,23.21 211.23,23.91 211.62,24.3 212.38,24.3 212.64,24.04 212.99,24.04 v1(213.2,23.82) 213.37,23.65 214.43,23.65 215.62,22.46 RPH7.4
  BOTTOM w0.089: v2(211.34,23.1) 211.25,23.19 UH1.AV43
USB_POWERSHARE_EN#: length 71.8
  TOP w0.102: v2(312.45,25.51) 312.45,24.23 312.04,23.82 RPE11.3 ; UI3.6 v2(342.69,68.7)
  TOP w0.104: UE1.J3 v2(314.92,33.55)
  IN1 w0.099: v2(314.92,33.55) 314.38,33.55 313.72,32.89 313.72,31.21 313.9,31.02 313.9,29.5 314.1,29.3 314.1,27.28 313.01,26.19 313.01,26.06 v2(312.45,25.51)
  IN3 w0.102: v2(314.92,33.55) 315.34,33.97 316.68,33.97 316.94,34.23 316.94,34.51 317.38,34.95 317.66,34.95 318.93,36.22 318.93,41.06 322.72,44.84 322.72,47.61 324,48.89 324,55.56 322.8,56.76 322.8,60.96 323.29,61.44 323.6,61.44 325.2,63.04 328.47,63.04 328.57,62.94 330.14,62.94 330.17,62.97 331.16,62.97 332.09,62.04 337.56,62.04 338.29,62.76 338.29,64.29 v2(342.69,68.7)
USB_POWERSHARE_VBUS_EN: length 117.3
  TOP w0.102: v2(344.22,68.48) 344.22,68.73 344.02,68.94 v1(343.85,68.94) 343.53,68.94 342.8,68.2 UI3.5 ; RPE11.1 310.1,22.26 309.68,22.26 v2(309.54,22.12) 308.55,22.12 RE702.1
  TOP w0.104: UE1.J2 314.08,33.51 313.62,33.51 313.08,32.97 313.08,32.85 311.98,31.75 310.22,31.75 309.86,32.11 309.86,33.36 309.21,34.02 301.07,34.02 299.92,32.86 299.92,30.76 299.57,30.41 299.57,26.75 298.97,26.16 298.97,24.73 298.58,24.33 v2(298.58,23.71)
  IN2 w0.102: v2(324.74,24.03) 324.4,24.03 323.22,22.85 320.21,22.85 320.14,22.77 317.22,22.77 317,22.99 310.41,22.99 v2(309.54,22.12) 309.14,21.72 302.84,21.72 302.69,21.87 300.45,21.87 298.61,23.71 v2(298.58,23.71)
  IN3 w0.102: v2(344.22,68.48) 344.52,68.17 344.52,63.86 341.78,61.13 340.09,61.13 339.19,60.23 339.19,53.35 338.37,52.54 338.37,50.61 333.31,45.55 333.31,39.01 331.87,37.57 331.87,27.85 329.75,25.73 326.43,25.73 324.85,24.14 324.85,24.14 v2(324.74,24.03)
USB_PWR_EN1#: length 401.9
  TOP w0.102: RPE11.4 311.87,24.32 v1(311.98,24.43) 312.02,24.47 v2(312.02,25.11)
  TOP w0.104: UE1.K3 v2(314.92,32.75)
  IN1 w0.099: v2(179.59,74.3) 176.88,74.3 173.12,78.06 172.36,78.06 143.91,106.5 143.91,109.91 136.6,117.22 123.29,117.22 120.85,114.78 117.58,114.78 111.83,120.52 102.1,120.52 98.91,117.33 84.31,117.33 83.94,117.7 77.53,117.7 76.57,116.74 75.69,116.74 70.85,111.9 66.75,111.9 66.05,111.2 63.42,111.2 62.66,110.44 54.96,110.44 54.63,110.11 47.75,110.11 47.53,110.32 33.13,110.32 31.23,112.23 31.23,113.94 30.83,114.34 30.83,114.93 30.25,115.52 30.25,116.42 29.31,117.36 28.24,117.36 25.12,114.24 23.69,114.24 23.48,114.03 23.48,108.42 22.65,107.59 22.65,105.12 22.14,104.61 v2(22.08,104.61) ; v2(312.02,25.11) 312.03,25.1 312.62,25.1 313.23,25.71 313.23,26.09 314.33,27.19 314.33,32.32 314.75,32.75 v2(314.92,32.75)
  IN2 w0.102: v2(314.92,32.75) 314.92,33.01 314.54,33.39 314.54,33.56 310.45,37.66 308.63,37.66 306.8,35.83 301.76,35.83 301.1,35.16 298.7,35.16 297.68,36.18 297.68,36.94 296.67,37.96 282.33,37.96 282.15,38.14 279.2,38.14 278.78,37.72 278.78,34.48 276.44,32.14 269.85,32.14 267.96,34.03 252.16,34.03 251.7,34.48 243.79,34.48 241.64,36.63 236.77,36.63 235.09,38.32 225.65,38.32 224.7,39.27 221.81,39.27 220.74,38.2 218.41,38.2 216.66,39.95 216.66,40.56 212.65,44.57 212.65,49.57 207.22,55 198.6,55 197.57,53.97 196.8,53.97 192.32,58.45 188.78,58.45 184.97,54.64 180.65,54.64 178.08,57.22 178.08,72.78 v2(179.59,74.3)
  BOTTOM w0.102: v2(22.08,104.61) 21.48,104.01 21.48,102.92 21.81,102.59 21.81,99.15 UI1.4
USB_PWR_EN2#: length 326
  TOP w0.102: v2(312.46,26.09) 312.95,25.6 v1(312.95,25.4) 312.95,24.41 311.86,23.32 RPE11.2
  TOP w0.104: UE1.G5 v2(316.52,35.95)
  IN1 w0.099: v2(312.46,26.09) 312.78,26.41 312.78,28.67 313.67,29.56 313.67,29.59 313.67,29.59 313.67,30.93 313.49,31.11 313.49,33.01 314.37,33.89 314.37,34.34 315.26,35.23 315.8,35.23 v2(316.52,35.95)
  IN3 w0.102: v2(321.85,61.73) 322.58,61 322.58,56.64 323.77,55.44 323.77,48.98 320.9,46.11 320.9,44.13 318.5,41.73 318.5,37.44 318.19,37.13 317.96,37.13 317.7,36.87 317.7,36.49 317.54,36.33 317.16,36.33 317,36.17 316.74,36.17 v2(316.52,35.95)
  BOTTOM w0.102: UI2.4 98.99,124.59 101.04,124.59 105.36,120.27 123.97,120.27 126.22,122.52 147.48,122.52 175.64,94.36 195.51,94.36 212.8,77.07 212.8,63.4 217.38,58.83 222.35,58.83 236.51,44.67 238.53,44.67 240.46,42.73 241.65,42.73 244.7,39.68 249.24,39.68 250.36,38.56 264.9,38.56 270.74,41.05 271.18,41.17 278.32,44.22 279.24,44.22 289.37,54.36 293.32,54.36 301.53,62.56 318.51,62.56 319.75,61.32 321.44,61.32 v2(321.85,61.73)
USH_DET#: length 54.8
  TOP w0.104: v2(323.67,39.12) 323.62,39.06 323.62,39.05 UE1.C13
  IN1 w0.099: v2(323.67,39.12) 323.25,39.53 322.25,39.53 321.49,38.77 319.6,38.77 319.21,38.38 319.21,35.7 319.45,35.46 319.45,34.95 319.34,34.84 319.34,31.6 317.5,29.76 317.5,24.6 316.53,23.63 316.53,19.98 315.59,19.04 314.1,19.04 v2(313.64,18.58)
  BOTTOM w0.102: v2(323.67,39.12) 323.9,39.12 324.97,40.18 RE526.2 ; DZ7.2 295.23,10.5 295.74,11.01 RZ87.1 298.37,11.01 298.92,11.56 298.92,13.76 300.42,15.26 v1(301.29,15.26) 303.03,15.26 303.33,14.97 307.38,14.97 309.55,17.13 312.67,17.13 313.62,18.08 313.62,18.56 v2(313.64,18.58)
USH_DET#_R: length 5.6
  BOTTOM w0.102: JUSH1.26 299.83,8.8 299.27,9.36 298.56,9.36 298.34,9.58 RZ87.2 297.89,10.1 297.62,10.36 DZ7.1 v1(296.93,9.19)
USH_EXPANDER_SMBCLK: length 40.8
  TOP w0.107: UE1.B3 v2(314.92,39.15)
  IN1 w0.099: v2(314.92,39.15) 314.37,38.6 314.37,36.62 313.64,35.88 313.64,34.3 313.04,33.7 313.04,29.56 312.28,28.81 312.28,28.09 311.65,27.46 v2(311.65,26.14)
  BOTTOM w0.107: v2(311.65,26.14) 311.65,26.11 311.66,26.11 311.66,25.43 311.61,25.39 311.61,24.94 312.94,23.62 313.44,23.62 314.85,22.2 314.85,17.35 312,14.5 309.39,14.5 309.14,14.24 309.14,13.28 RZ8.2 309.16,12.02 309.16,11 CZ62.1 309.16,9.76 309.16,9.5 308.75,9.08 307.82,9.08 307.32,8.57 307.32,8.21 JUSH1.11
USH_EXPANDER_SMBDAT: length 40.9
  TOP w0.107: v2(316.52,37.55) UE1.E5
  IN1 w0.099: v2(311.25,25.71) 311.8,25.71 312.06,25.97 312.06,26.31 311.88,26.49 311.88,27.37 312.5,27.99 312.5,28.71 313.26,29.47 313.26,33.25 314.12,34.1 314.12,35.69 314.78,36.34 315.09,36.34 315.32,36.58 315.32,36.89 315.6,37.17 316.14,37.17 v2(316.52,37.55)
  BOTTOM w0.107: JUSH1.12 306.83,8.78 307.62,9.57 308.54,9.57 308.68,9.7 308.68,9.83 CZ63.1 308.63,10.88 308.63,12.14 RZ9.2 308.91,13.41 308.91,14.34 309.29,14.73 311.8,14.73 314.62,17.55 314.62,22.11 313.5,23.23 v1(313.24,23.23) 313,23.23 311.38,24.84 311.38,25.58 v2(311.25,25.71)
USH_PWR_STATE#: length 51.9
  TOP w0.102: RZ10.2 301.91,8.27 v1(301.02,9.16) 300.58,9.6 299.65,9.6 299.32,9.92 v2(299.32,10.21) 299.32,10.42 299.1,10.64 299.1,16.9 301.1,18.9 301.1,19.82 300.37,20.55 300.27,20.55 297.45,23.37 297.45,26.91
  TOP w0.104: UE1.H2 314.12,34.35 312.53,34.35 312.39,34.21 311.02,34.21 311.01,34.23 309.45,34.23 309.43,34.25 305.67,34.25 304.31,35.61 302,35.61 301.63,35.24 300.05,35.24 297.98,33.17 297.98,31.42 298.6,30.8 298.6,28.07 297.45,26.91
  BOTTOM w0.102: v2(299.32,10.21) 299.32,10.06 300.3,9.08 301.19,9.08 301.3,8.97 301.68,8.97 301.83,8.81 JUSH1.22
USH_RST#_R: length 3.4
  BOTTOM w0.102: RZ114.2 300.82,9.41 v1(300.85,9.41) 301.21,9.41 301.43,9.19 301.77,9.19 302.33,8.64 JUSH1.21
VCI_IN1#: length 4.6
  TOP w0.102: UE1.B5 v2(316.52,39.15)
  BOTTOM w0.102: v2(316.52,39.15) 316.52,39.29 v1(316.1,39.71) 315.71,40.09 315.71,41.55 RE507.1
VCI_IN2#: length 5.1
  TOP w0.104: UE1.D4 v2(315.72,38.35)
  BOTTOM w0.102: v2(315.72,38.35) 315.72,39.22 315.1,39.85 315.1,42.28 RE508.1
VCT_LAN_R1: length 7.2
  TOP w0.102: v1(329.98,83.81) RL3.1 329.67,84.8 328.9,85.57 325.8,85.57 325.35,86.01 324.9,86.01 324.82,86.1 UL1.6
VGA_IDENTIFY: length 10.3
  TOP w0.104: UE1.L9 v2(319.72,31.95)
  BOTTOM w0.102: v2(319.72,31.95) 319.72,32.07 320.16,32.5 320.16,32.98 320.34,33.16 320.8,33.16 320.94,33.3 320.94,34.8 321.12,34.98 v1(322.59,34.98) 325.13,34.98 325.73,35.57 RE85.1 RE84.1
VID0_VCCIO: length 4
  BOTTOM w0.254: PU401.9 153.33,60.53 153.64,60.84 153.64,61.32 v1(154.27,61.95) PR418.2 155.67,61.95 155.7,61.93 PR420.1
VID1_VCCIO: length 4.9
  BOTTOM w0.102: PR417.2 v1(154.28,65)
  BOTTOM w0.254: PU401.8 152.23,61.65 153.36,62.78 PR419.1 154.02,63.12 154.28,63.37 PR417.2
VR_SVID_ALERT#: length 14.4
  TOP w0.102: v2(71.94,84.85) 71.61,85.18 71.61,85.51 RC153.1 70.29,85.94 RC152.2
  TOP w0.203: PR1717.1 v2(64.17,78.81) 64.78,78.81 PR1706.2
  IN3 w0.099: 67.89,81.43 67.89,80.39 66.31,78.81 v2(64.17,78.81)
  IN3 w0.102: 67.89,81.43 70.93,84.47 71.56,84.47 v2(71.94,84.85)
VR_SVID_CLK: length 32.1
  TOP w0.102: CC325.1 77.05,84.25 v2(76.91,84.11) 77.12,84.11 77.95,83.29 v1(77.95,82.24) 77.95,81.06 81.37,77.64 81.37,77.22 81.64,76.94 83.33,76.94 83.71,76.56 84.58,76.56 v2(84.92,76.22)
  TOP w0.203: PR1715.2 64.11,79.7 v2(64.17,79.75) 64.22,79.7 64.76,79.7 PR1707.2
  IN3 w0.099: v2(64.17,79.75) 66.55,79.75 67.31,80.5
  IN3 w0.102: 67.31,80.5 67.31,82.37 70.23,85.29 72.21,85.29 72.83,84.67 76.48,84.67 76.91,84.24 v2(76.91,84.11)
  BOTTOM w0.076: UC1.BH32 85.24,75.9 v2(84.92,76.22)
VR_SVID_DATA: length 39.7
  TOP w0.102: RC157.2 70.85,84.44 75.24,84.44 v2(75.76,83.92) 75.76,82.93 v1(76.18,82.51) 76.83,81.86 76.83,79.55 79,77.38 79,76.53 79.7,75.84 82.09,75.84 82.4,76.15 82.79,76.15 83.66,75.28 84.32,75.28 84.54,75.06 84.54,74.15 v2(85.34,73.35)
  TOP w0.203: PR1719.2 64.11,77.93 v2(64.17,77.88) 64.22,77.93 64.77,77.93 PR1705.1
  IN3 w0.089: 68.38,80.14 66.12,77.88 v2(64.17,77.88)
  IN3 w0.102: 68.38,80.14 68.38,81.11 70.81,83.54 75.38,83.54 v2(75.76,83.92)
  BOTTOM w0.102: v2(85.34,73.35) 85.44,73.45 UC1.BH29
VRALERT#: length 15.7
  BOTTOM w0.089: UH1.BE32 214.38,28.4 214.61,28.62 219.38,28.62 219.4,28.6 219.67,28.6 219.78,28.72 220.59,28.72 222.1,27.2 v1(223.17,27.2) 223.17,26.8
  BOTTOM w0.102: 223.17,26.8 223.47,26.51 224.79,26.51 225.04,26.25 225.04,25.76 225.37,25.44 227.39,25.44 227.48,25.35 RH203.1
VSET_5105: length 6
  TOP w0.104: UE1.C9 v2(320.52,39.15)
  BOTTOM w0.102: 320.98,40.16 320.54,40.59 320.54,41.35 320.65,41.45 320.72,41.45 RE77.1 321.1,41.87 320.62,42.35 320.62,43.61 v1(320.75,43.74) ; v2(320.52,39.15) 320.52,39.62 CE38.1
  BOTTOM w0.104: 320.98,40.16 CE38.1
VSN_1PH: length 3.7
  TOP w0.203: PR1709.2 63.01,85.87 PC1700.2 62.72,84.7 v1(61.63,84.7) 61.32,84.7 61.02,84.39 PU1700.51
VSN_2PH: length 7.8
  TOP w0.102: PC1719.1 v1(60.98,72.81)
  TOP w0.203: PU1700.37 58.93,78.2 59.17,77.96 59.17,75.9 60.36,74.72 PR1730.1 60.98,74.69 PC1719.1
VSN_4PH: length 5.7
  TOP w0.203: PU1700.2 59.33,86.12 59.71,86.51 59.71,86.59 60.12,86.99 v2(60.12,87.4) 60.33,87.4 PR1727.2
  BOTTOM w0.102: PC1712.2 v1(59.1,88.21)
  BOTTOM w0.203: v2(60.12,87.4) 60.14,87.43 PC1712.2
VSP_1PH: length 4.5
  TOP w0.203: PU1700.52 60.93,84.79 v1(62.07,85.94) 62.07,86.21 62.61,86.74 PC1707.2 PR1711.2
VSP_2PH: length 5.7
  TOP w0.203: PU1700.38 59.33,78.72 v1(59.85,78.2) 60.16,77.89 60.16,75.83 60.37,75.61 PC1713.1 61.01,76.48 PR1728.1
VSP_4PH: length 6.2
  TOP w0.203: PC1711.2 62.14,87.55 61.63,87.05 v1(61.27,87.05) 60.85,87.05 v2(60.21,86.41) 59.73,85.93 PU1700.1
  BOTTOM w0.203: PR1723.2 61.86,88.06 v2(60.21,86.41)
VSYNC_CONN: length 11.4
  BOTTOM w0.107: JCRT1.14 362.64,95.66 359.58,92.61 v1(359.58,89.75) CV132.1 RV121.1 RV1651.2
VSYNC_CRT: length 44.5
  TOP w0.107: v2(330.37,69.75) 330.29,69.83 UV6.18
  IN1 w0.099: v2(330.37,69.75) 330.89,70.27 331.26,70.27 332.29,69.24 332.89,69.24 334.73,71.08 334.73,78.65 340.52,84.45 348.73,84.45 350.41,86.13 350.41,86.64 349.8,87.24 v2(349.8,88.92)
  BOTTOM w0.107: RV1651.1 356.74,87.45 356.6,87.59 353.15,87.59 v1(352.65,88.1) 352.07,88.67 350.06,88.67 v2(349.8,88.92)
WIGIG_32KHZ: length 3.2
  BOTTOM w0.102: JNGFF1.50 304.08,26.36 304.31,26.59 v1(304.34,26.59) 305.23,26.59 RZ56.2
WLAN_COEX1: length 62
  TOP w0.102: RZ130.2 341.37,56.4 340.91,55.93 v2(340.38,55.93)
  IN1 w0.099: v2(340.38,55.93) 340.34,55.89 340.34,54.98 339.33,53.97 328.82,53.97 328.68,53.83 326.23,53.83 323.49,51.09 322.88,51.09 321.4,49.61 321.4,46.61 320.93,46.14 320.93,43.92 319.91,42.91 317.39,42.91 315.51,41.03 315.51,40.54 313.89,38.91 313.89,36.82 313.16,36.08 313.16,34.5 312.3,33.65 312.3,29.15 311.87,28.72 v2(311.87,28.25)
  BOTTOM w0.102: JNGFF1.48 303.13,26.86 303.48,27.2 306.77,27.2 307.28,26.69 308.98,26.69 v1(310.24,27.96) 310.46,28.17 311.07,28.17 311.13,28.11 311.52,28.11 311.66,28.25 v2(311.87,28.25)
WLAN_COEX2: length 61
  TOP w0.102: RZ129.2 340.23,57.24 v2(340.33,57.13)
  IN1 w0.099: v2(340.33,57.13) 339.94,56.74 339.94,55.53 338.82,54.42 337.73,54.42 337.15,54.99 335.75,54.99 335.52,54.77 334.94,54.77 334.06,55.64 330.18,55.64 328.59,54.06 326.14,54.06 323.4,51.32 322.79,51.32 321.1,49.63 321.1,46.63 320.71,46.24 320.71,44.02 319.82,43.13 317.29,43.13 315.29,41.13 315.29,40.63 313.67,39.01 313.67,36.91 312.93,36.18 312.93,34.59 312.08,33.74 312.08,29.24 v2(311.35,28.52)
  BOTTOM w0.102: JNGFF1.46 303.2,27.36 303.27,27.43 307.49,27.43 307.77,27.71 v1(308.58,27.71) 309.53,27.71 310.22,28.4 311.25,28.4 311.35,28.5 v2(311.35,28.52)
WLAN_COEX3: length 60.6
  TOP w0.102: RZ128.2 339.66,57.17 v2(339.71,57.13)
  IN1 w0.099: v2(308.74,28.36) 308.74,28.41 309.14,28.81 310.96,28.81 311.85,29.7 311.85,33.83 312.71,34.69 312.71,36.27 313.44,37 313.44,39.1 315.06,40.73 315.06,41.22 317.2,43.36 319.73,43.36 320.48,44.11 320.48,46.33 320.87,46.73 320.87,50.13 325.03,54.28 328.5,54.28 330.08,55.87 334.15,55.87 335.03,54.99 335.43,54.99 335.66,55.22 337.24,55.22 337.82,54.64 338.73,54.64 339.71,55.62 v2(339.71,57.13)
  BOTTOM w0.102: JNGFF1.44 303.56,27.86 303.75,27.66 306.96,27.66 v1(307.2,27.9) 307.31,28.01 308.39,28.01 308.74,28.36 v2(308.74,28.36)
WLAN_PWR_EN: length 5.5
  TOP w0.102: RZ70.2 287.2,3.79 287.2,4.97 287.13,5.05 UZ4.5 ; RZ70.2 RZ71.2 ; RZ70.2 288.07,3.78 RZ38.2 289.25,3.8 DZ9.1
WLAN_WIGIG60GHZ_DIS#: length 30.9
  TOP w0.102: UE1.L13 323.57,32.1 v2(324.6,32.1) 324.93,32.1 325.46,32.64 v1(325.46,32.82) 325.72,33.08 RE8.1 ; v2(303.79,24.76) 303.37,24.76 303.21,24.6 303.1,24.6 DZ1.1
  IN2 w0.102: v2(324.6,32.1) 323.6,31.11 323.6,27.63 322.35,26.38 321.47,26.38 319.49,24.4 309.84,24.4 309.77,24.46 304.26,24.46 303.96,24.76 v2(303.79,24.76)
WLAN_WIGIG60GHZ_DIS#_R: length 3.7
  TOP w0.102: v2(300.68,24.8) 300.92,24.55 DZ1.2 v1(301.35,23.27)
  BOTTOM w0.102: JNGFF1.56 300.74,24.86 v2(300.68,24.8)
WWAN_COEX1: length 5.5
  TOP w0.102: v1(342.38,56.74) 342.38,57.99 342.1,58.26 RZ373.1 341.95,58.27 RZ130.1 341.37,58.64 341.01,59 v2(340.4,59)
  BOTTOM w0.102: JNGFF2.64 v2(340.4,59)
WWAN_COEX2: length 5.7
  TOP w0.102: RZ372.1 340.23,58.27 RZ129.1 340.15,58.34 340.15,58.56 v2(339.71,59)
  BOTTOM w0.102: v2(339.71,59) 340.11,59.41 340.11,59.76 339.9,59.97 JNGFF2.62 v1(339.9,62.88)
WWAN_COEX3: length 3.4
  TOP w0.102: v2(339.71,59.59) 339.3,59.18 339.3,58.75 339.66,58.39 RZ128.1 339.1,58.26 RZ374.1
  BOTTOM w0.102: v2(339.71,59.59) 339.4,59.9 JNGFF2.60
WWAN_PWR_EN: length 3.5
  BOTTOM w0.102: RZ43.1 CZ198.1 325.9,63.33 JNGFF2.6
WWAN_RADIO_DIS#: length 28.3
  TOP w0.089: v2(324.87,38.12) 324.87,38.01 323.53,36.67 322.99,36.67 322.67,36.35 UE1.F12
  TOP w0.102: v2(326.55,59.11) 326.42,59.23 DZ5.1
  IN3 w0.102: v2(326.55,59.11) 326.55,58.75 326.73,58.57 326.73,56.92 328.7,54.96 328.7,48.69 327.55,47.54 327.55,46.41 327.95,46.01 327.95,43.38 327.67,43.09 327.67,40.94 v2(327.62,40.89)
  BOTTOM w0.102: v2(324.87,38.12) 325.12,38.37 v1(325.75,38.37) 326.17,38.37 RE10.1 326.88,39.6 327.48,40.2 327.48,40.69 327.62,40.83 v2(327.62,40.89)
WWAN_RADIO_DIS#_R: length 3.6
  TOP w0.102: v2(326.39,62.18) 326.42,62.15 DZ5.2 v1(325.07,61.48)
  BOTTOM w0.102: JNGFF2.8 326.41,60.7 326.41,62.16 v2(326.39,62.18)
WWAN_WAKE#: length 40.5
  TOP w0.102: UE1.M13 323.64,31.55 323.76,31.42 324.53,31.42 326.35,33.24 327.01,33.24 327.25,33.48 329.31,33.48 RE38.1 329.11,34.07 v1(328.52,34.07) 328.01,34.07 v2(327.93,34.14)
  IN3 w0.102: v2(335.2,55.4) 335.2,54.89 335,54.69 335,53.77 334.64,53.41 334.64,50.87 331.83,48.05 331.83,47.56 330.67,46.4 330.67,39.5 328.66,37.49 328.66,35.19 327.93,34.46 v2(327.93,34.14)
  BOTTOM w0.102: v2(335.2,55.4) 334.95,55.65 330.84,55.65 330.15,54.97 JNGFF2.23
XCLK_RBIAS: length 7.3
  TOP w0.089: v2(199.04,44.93) 199.04,44.94 199.13,45.03 v1(201,45.03) RH171.2 203.31,45.95 RH435.2
  BOTTOM w0.089: v2(199.04,44.93) 199.72,43.24 199.92,42.63 UH1.T3
XDP_DBRESET#: length 223.1
  TOP w0.102: v2(44.89,54.52) 44.89,53.86 44.65,53.62 44.65,52.63 44.07,52.04 44.07,51.38 43.33,50.65 v1(43.33,50.33) 43.33,48.39 43.57,48.15 RC137.1 ; CC32.1 RC137.1 ; RC137.1 43.84,47.72 44.17,47.39 JXDP1.48
  BOTTOM w0.089: 216.41,49.09 215.91,48.6 RH66.1
  BOTTOM w0.102: v2(44.89,54.52) 45.54,55.17 51.52,55.17 53.99,52.7 53.99,48.57 60.35,42.21 151,42.21 162.49,53.7 162.49,55.29 171.81,64.61 171.81,67.5 172.6,68.29 193.54,68.29 196.95,64.89 196.95,62.92 198.18,61.68 204.58,61.68 208.7,57.56 208.7,57 212.07,53.63 218.47,53.63 219.57,52.53 219.57,51.08 219.39,50.9 UC3.1 218.02,50.9 217.77,50.65 217.77,49.46 217.43,49.12 216.44,49.12 216.41,49.09
XDP_OBS0: length 8.6
  BOTTOM w0.076: 76.65,71.17 77.48,72 v1(78.15,72) 79,72 79.17,72.16 79.68,72.16 80.02,72.5 80.6,72.5 80.88,72.23 UC1.BR27
  BOTTOM w0.102: RC239.1 75.36,68.6 76.65,69.9 76.65,71.17
XDP_OBS0_R: length 65.4
  TOP w0.102: v2(42.21,53.21) 42.19,53.24 41.7,53.24 v1(41.19,52.73) 40.89,52.43 36.6,52.43 34.11,49.94 33.22,49.94 31.14,47.85 31.14,43.84 31.9,43.08 35.91,43.08 36.5,42.49 36.5,42.19 37.67,41.02 JXDP1.21
  IN1 w0.099: v2(72.26,68.58) 71.48,68.58 61.51,58.62 58.82,55.93 55.67,55.93 52.78,53.04 42.39,53.04 v2(42.21,53.21)
  BOTTOM w0.102: RC239.2 73.99,68.63 72.3,68.63 v2(72.26,68.58)
XDP_OBS1: length 8.3
  BOTTOM w0.076: 77,71.01 77.66,71.67 78.93,71.67 79.17,71.91 80.04,71.91 UC1.BT27
  BOTTOM w0.102: 77,71.01 v1(77,70.48) 77,69.87 76.18,69.05 76.18,68.54 75.23,67.59 RC240.1
XDP_OBS1_R: length 64.5
  TOP w0.102: v2(41.91,52.6) 41.78,52.48 41.75,52.48 41.21,51.93 40.14,51.93 v1(39.28,51.07) 39.06,50.85 35.68,50.85 34.26,49.43 33.55,49.43 31.59,47.47 31.59,44.2 32.28,43.51 36.37,43.51 37,42.87 37,42.32 38.17,41.15 JXDP1.23
  IN1 w0.099: v2(41.91,52.6) 56.08,52.6 71.07,67.59 71.87,67.59 v2(72.28,68)
  BOTTOM w0.102: RC240.2 72.69,67.59 v2(72.28,68)
XDP_PRSNT_PIN1: length 8.6
  TOP w0.102: JXDP1.1 RC122.1 32.94,36.87 33.19,36.62 33.19,35.5 33.94,34.75 v1(34.74,34.75) 35.91,34.75 36.61,35.44 RC121.1
XTAL24_IN_R: length 4.3
  BOTTOM w0.089: YH2.3 201.27,48.43 201.27,48.12 CH13.1 200.6,47.45 200.02,47.45 199.79,47.22 RH153.1 199.79,46.79 200.44,46.14 RH436.2
XTAL24_IN_R1: length 10.7
  BOTTOM w0.089: RH436.1 199.53,45.91 200.02,45.41 201.79,45.41 201.89,45.31 201.89,45.11 201.8,45.02 200.78,45.02 200.32,44.56 200.32,44.08 200.79,43.61 200.79,43.36 200.91,43.24 200.91,42.62 200.94,42.6 200.94,42.23 200.83,42.12 200.83,41.53 200.73,41.43 200.73,40.19 200.94,39.98 200.94,39.08 UH1.U10
XTAL24_OUT: length 3.4
  BOTTOM w0.089: YH2.1 199.68,49.52 199.68,47.81 199.59,47.73 RH437.2
XTAL24_OUT_R: length 3
  BOTTOM w0.089: RH152.2 198.01,46.16 198.01,46.35 198.05,46.39 CH14.1 198.44,46.94 198.55,46.82 198.87,46.82 RH153.2 198.97,46.9 198.97,47.24 198.92,47.29 RH437.1
XTAL24_OUT_R1: length 8.2
  BOTTOM w0.089: UH1.U9 200.59,39.63 200.5,39.54 200.34,39.54 200.25,39.63 200.25,40.01 200.54,40.3 200.54,41.51 200.61,41.58 200.61,42.17 200.46,42.33 200.46,43.1 200.62,43.26 200.62,43.54 200.3,43.86 200.29,43.86 200.15,44 200.15,44.79 199.42,45.52 198.92,45.52 198.7,45.74 RH152.1
XTALI: length 6.7
  TOP w0.102: UL1.10 324.88,87.7 324.97,87.79 325.3,87.79 325.67,88.16 325.67,88.59 325.59,88.68 v1(325.59,88.86) 325.74,89.02 RL11.2 327.09,89.56 328.15,89.56 CL14.1 329.02,89.81 329.29,90.08 YL1.1
XTALO: length 3.5
  TOP w0.102: RL34.2 327.41,88.1 RL11.1 325.97,87.53 v1(325.62,87.53) 325.21,87.53 324.98,87.3 UL1.9
XTALO_R: length 3.5
  TOP w0.102: RL34.1 327.48,88.94 CL13.1 328.64,88.94 329.06,89.36 329.86,89.36 YL1.3
Z2805: length 3.6
  TOP w0.102: RL18.1 v1(334.7,119.25)
  TOP w0.508: v2(336.08,119.91) 336.06,119.9 RL18.1
  BOTTOM w0.508: TL1.24 v2(336.08,119.91)
Z2806: length 3.6
  TOP w0.102: RL16.1 v1(328.71,119.25)
  TOP w0.508: RL16.1 330.07,119.93 v2(330.08,119.94)
  BOTTOM w0.508: TL1.18 v2(330.08,119.94)
Z2807: length 3.6
  TOP w0.102: RL17.1 v1(331.71,119.25)
  TOP w0.508: RL17.1 333.07,119.9 v2(333.08,119.91)
  BOTTOM w0.508: TL1.21 v2(333.08,119.91)
Z2808: length 3.6
  TOP w0.102: RL15.1 v1(325.71,119.25)
  TOP w0.508: RL15.1 327.07,119.91 v2(327.08,119.91)
  BOTTOM w0.508: TL1.15 v2(327.08,119.91)
N04748: length 4.9
  TOP w0.203: PR929.1 8.28,29.88 v2(8.53,30.12) 8.53,30.56 8.94,30.97 8.94,30.97 9.21,31.24 PU901.3
  BOTTOM w0.102: v1(9.29,29.55) 8.72,30.12 v2(8.53,30.12)
  BOTTOM w0.508: v2(8.53,30.12) 9.17,30.77 PC939.1
N13770063: length 2.4
  TOP w0.102: T51.1 71.5,20.93 v2(71.22,20.65)
  BOTTOM w0.104: v2(71.22,20.65) JDIMM1.165
N13800829: length 0.9
  TOP w0.104: RD18.1 CD31.2
N13826355: length 2.5
  TOP w0.104: T53.1 v2(152.81,23.74)
  BOTTOM w0.104: JDIMM2.165 152.22,23.15 v2(152.81,23.74)
N13829184: length 3.3
  TOP w0.102: v1(145.72,15.07) 145.72,15.52 146.03,15.84 146.85,15.84 147.37,15.32 RD31.1 CD62.2
N14169789: length 4.7
  BOTTOM w0.102: QN1.6 268.89,18.6 267.7,19.8 267.44,19.8 ; v1(266.39,19.8) RN2.2 267.44,19.8 ; 267.44,19.8 267.44,19.54 268.24,18.75 QN1.5
N14170537: length 2.3
  TOP w0.102: CZ130.1 v1(265.22,9.73)
  TOP w0.254: CZ130.1 264.21,9.16 264.3,9.06 UZ23.6
N16400770: length 2.4
  TOP w0.254: PR901.3 12.39,55.54 12.24,55.38 12.24,54.39 12.67,53.96 PR910.1
N16624469: length 5.1
  BOTTOM w0.102: v1(37.46,101.31) RT111.2 CT90.1 36.3,99.91 36.19,99.8 34.61,99.8 34.54,99.72 UT7.3
N16775301: length 3.4
  BOTTOM w0.254: PU200.16 46.06,5.5 45.79,5.23 PR204.2 PC208.2 46.63,3.64 PR206.1
N16775385: length 3.2
  BOTTOM w0.102: PC218.1 44.12,11.08 v1(44.12,11.44)
  BOTTOM w0.254: PC218.1 45.61,9.58 PU200.3
N16775433: length 1.5
  TOP w0.102: PC204.1 v1(54.46,10.08)
N16775513: length 1.1
  TOP w0.102: PC205.1 v1(52.01,4.4)
N16775517: length 0.6
  TOP w0.102: v2(48.35,6.17) v1(47.75,6.17)
  vias: v2(48.54,5.58)
N16776853: length 2.8
  BOTTOM w0.102: PC207.1 48.2,4.56 v1(48.54,4.22)
  BOTTOM w0.254: PC207.1 47.59,4.58 46.96,5.2 PU200.14
N17114118: length 3.1
  TOP w0.102: QV2.1 124.1,109.7 v1(124.1,111.06) RV5.2
N17115081: length 3
  BOTTOM w0.102: JEDP1.21 113.65,106.42 113.65,104.55 113.19,104.09 LV1.1
N17142422: length 3.4
  TOP w0.102: UI3.16 336.92,68.2 RI14.2 336.3,68.82 336.3,69.01 v1(335.92,69.39)
N17150215: length 2.2
  BOTTOM w0.102: v1(348.31,49.63) 348.51,49.43 348.51,48.49 RZ334.1 CZ38.2
N17185089: length 3.1
  TOP w0.254: PQ1204.5 67.84,104.47 68.54,105.18 68.54,105.39 v1(68.51,105.43) 68.45,105.48 67.07,105.48 PR1218.2
N17185092: length 5.5
  TOP w0.102: v1(67.53,106.39) 66.95,105.8 66.26,105.8 65.97,105.51 PR1218.1
  TOP w0.254: PR1218.1 65.97,104.44 65.97,104.44 65.97,104.28 65.87,104.18 PR1214.2 66.6,103.67 67.19,104.26 PQ1204.6
N17185371: length 3.8
  TOP w0.102: PR1223.2 70.69,103.2 v1(71,103.52)
  TOP w0.254: PR1223.2 68.33,103.2 67.84,102.7 PQ1204.2
N17370862: length 7.3
  TOP w0.102: v2(58.97,108.95) v1(59.55,108.95)
  TOP w0.381: v2(58.97,108.95) 58.97,109.19 PR11.2 PR16.1 59.21,110.62 PC4.2 58.96,111.06 60.19,112.28 PQ4.4
  BOTTOM w0.381: v2(58.97,108.95) 59.47,108.95 PQ5.1
N17370917: length 11.1
  TOP w0.254: v2(61.64,108.48) 61.95,108.18 v1(63.22,108.18) 64.11,109.07 64.11,109.52 64.21,109.63 PR15.1
  BOTTOM w0.254: v2(61.64,108.48) 61.64,107.81 61.25,107.42 58.21,107.42 58.15,107.48 PQ5.2 56.56,107.48 55.75,108.29 PR10.2
N17370921: length 1.5
  TOP w0.254: PR15.2 66.09,109.63 66.27,109.44 PQ1.6
N17370927: length 2.3
  TOP w0.102: v1(60.44,110.91) 60.13,110.6 PR16.2
  TOP w0.381: PR16.2 PQ7.1
N17370961: length 10.1
  TOP w0.102: v1(66.2,128.11) PL3.1
  TOP w0.254: PR6.2 67.74,122.96 67.09,123.61 PQ2.1 67.09,125.9 67.21,126.02 PR3.1 PL3.1
N17370983: length 3.4
  TOP w0.102: PR3.2 v1(68.13,128.1)
  TOP w0.254: PQ2.3 69.17,126.38 68.99,126.56 PR5.1 PR3.2
N17370995: length 4.2
  TOP w0.102: v1(75.08,122.28) 73.81,122.28 PR8.2
  TOP w0.254: PQ3.2 73.26,123.1 PR8.2 PR6.1
N17370999: length 6.8
  TOP w0.102: PR7.2 v1(73.3,126.56)
  TOP w0.254: PQ2.2 69.17,124.48 69.34,124.65 PQ3.1 72.09,124.65 72.24,124.8 PR7.2
N17371043: length 2.6
  TOP w0.381: PR18.2 71.35,122.26 v1(71.64,121.98) 72.05,121.57 PQ6.1
N17371125: length 4.7
  TOP w0.102: v1(60.96,108.8) 61.45,109.3 PQ7.2
  TOP w0.254: PR20.1 64.18,110.51 63.62,109.96 63.45,109.96 63.27,109.78 PQ7.2
N17371182: length 4.8
  TOP w0.102: PR30.1 75.47,120.33 v1(76.13,120.99)
  TOP w0.254: PR30.1 74.05,120.33 PQ6.2 73.45,120.23 73.21,119.98 PR23.1
N17371184: length 3.2
  TOP w0.102: PR23.2 72.29,118.91 v1(71.61,119.6)
  TOP w0.254: PU1.4 72.94,117.44 72.75,117.63 72.75,117.95 72.29,118.41 PR23.2
N17371196: length 2.9
  TOP w0.102: PR21.2 v1(73.41,115.03)
  TOP w0.254: PU1.1 74.79,116.14 74.47,115.82 74.47,115.06 PR21.2
N17371202: length 4.6
  TOP w0.102: v1(76.04,119.6) 75.36,119.6 74.45,118.69 PR22.2
  TOP w0.254: PR22.2 74.45,116.93 74.59,116.79 PU1.2
N17371207: length 4.2
  TOP w0.102: PQ8.1 77.44,117.19 v1(78.22,117.98)
  TOP w0.254: PR22.1 75.45,118.64 PR27.1 76.3,118.01 77.11,117.19 PQ8.1
N17372063: length 4
  TOP w0.102: v1(71.24,110.65) 71.06,110.83 PR19.1
  TOP w0.254: PR19.1 68.96,110.83 PQ1.3 68.2,111.4 PR17.2
N17372074: length 3.7
  TOP w0.254: PR25.2 67.36,108.74 67.61,108.99 67.61,109.75 67.28,110.09 PQ1.5
N17372283: length 2.7
  TOP w0.102: v1(71.27,109.32) 70.67,109.92 PR19.2
  TOP w0.254: PR19.2 69.97,110.09 PQ1.2
N17372833: length 9.1
  BOTTOM w0.102: v1(50.17,100.76) 50.1,100.69 PC1206.1
  BOTTOM w0.254: PR1203.1 45.16,103.77 45.16,102.23 45.6,101.79 PU1201.3 48.07,101.79 PR1201.2 48.23,100.76 PR1219.1 PC1206.1
N17494434: length 40.5
  TOP w0.254: v2(31.49,114.66) 31.1,115.05 31.1,115.86 v1(28.75,118.21) 28.75,118.73 28.24,119.23 PR1255.2
  IN2 w0.254: v2(44.5,106.96) 44.5,106.98 40.55,110.93 32.93,110.93 31.49,112.37 v2(31.49,114.66)
  BOTTOM w0.254: v2(44.5,106.96) 44.5,106.87 44.27,106.64 PR1238.1 43.84,105.75 PD1205.1 44.42,105.18 44.42,101.78 43.78,101.14 PU1201.5 41.06,101.14 40.86,100.94 40.86,99.8 41.12,99.54 PR1239.2 PC1211.1 PR1246.1 43.6,99.66 PQ1212.1
N17509431: length 6.3
  BOTTOM w0.254: PR935.1 PR947.1 v1(5.38,37.5) 5.38,37.15 5.8,36.73 5.8,34.92 5.63,34.75 PC947.1 5.25,33.86 PR949.2
N17965667: length 3.7
  TOP w0.102: v1(80.44,116.05) 79.32,116.05 PR28.1
  TOP w0.254: PR26.2 79.31,116.93 PR28.1 78.74,116.06 78.05,115.38 PQ8.3
N17965677: length 2.3
  TOP w0.102: v1(76.46,113.09) 76.72,113.35 PR29.2
  TOP w0.254: PR29.2 76.75,114.13 PQ8.2
N18291828: length 8
  BOTTOM w0.076: UT5.F10 34.98,88.19 35.23,88.44 36.83,88.44
  BOTTOM w0.102: RT99.1 39.59,88.86 39.04,88.31 ; RT97.2 40.14,90.48 v1(40.39,90.74)
  BOTTOM w0.104: 39.04,88.31 38.31,88.31 RT98.1 37.45,88.86 37.03,88.44 36.83,88.44 ; RT99.1 40.16,89.73 RT97.2
N18292036: length 2.6
  TOP w0.102: v1(31.92,88.72) 31.92,88.36 v2(31.38,87.81)
  TOP w0.104: v2(31.38,87.81) 30.67,87.81 RT84.1
  BOTTOM w0.076: v2(31.38,87.81) 31.38,87.79 31.77,88.19 UT5.F4
N18292038: length 2.5
  TOP w0.102: RT85.1 30.64,89.47 v1(30.83,89.66)
  TOP w0.104: RT85.1 31.04,88.74 v2(31.38,88.4)
  BOTTOM w0.076: v2(31.38,88.4) 31.66,88.69 UT5.G4
N18292318: length 4.1
  BOTTOM w0.076: UT5.K9 34.38,90.33 34.64,90.58 34.64,91.57 34.89,91.81 34.89,91.85 v1(35.35,92.31) 36.15,93.12 RT104.1
N18292320: length 4.3
  BOTTOM w0.076: 35.19,91.06 35.17,91.04 35.17,90.84 35.13,90.8 35.13,90.58 34.88,90.33 UT5.K10 ; RT105.1 37.58,92.94 36.81,92.18 v1(36.65,92.18) 36.41,92.18 36.22,91.99 36.12,91.99 35.21,91.08
  BOTTOM w0.102: 35.19,91.06 35.21,91.08
N18292328: length 5.3
  BOTTOM w0.076: 37.86,92.71 37.57,92.71 36.97,92.1 36.97,92.04 36.79,91.86 36.38,91.86 35.38,90.86 UT5.L11
  BOTTOM w0.102: v1(39.48,93.2) 38.55,93.2 RT103.1 ; 37.86,92.71 37.92,92.71
  BOTTOM w0.104: RT103.1 38.06,92.71 37.92,92.71
