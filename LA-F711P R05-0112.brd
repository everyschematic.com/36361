# Allegro board LA-F711P R05-0112.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
CNP-H_BGA_874P-T
  round 0.305 smd: A2(0.354,0) A3(0.855,0) A4(1.355,0) A46(22.273,0) A47(22.773,0) A48(23.274,0) AA19(8.715,-9.765) AA20(9.49,-9.765) AA22(10.265,-9.765) AA23(11.039,-9.765) AA25(11.814,-9.765) AA27(12.589,-9.765) AA28(13.363,-9.765) AA30(14.138,-9.765) AA31(14.913,-9.765) AB19(8.715,-10.539) AB20(9.49,-10.539) AB22(10.265,-10.539) AB23(11.039,-10.539) AB25(11.814,-10.539) AB27(12.589,-10.539) AB28(13.363,-10.539) AB30(14.138,-10.539) AB31(14.913,-10.539) AC6(2.44,-10.735) AC7(3.202,-10.735) AC9(3.964,-10.735) AC11(4.726,-10.735) AC12(5.488,-10.735) AC14(6.25,-10.735) AC15(7.012,-10.735) AC17(7.774,-10.735) AC33(15.854,-10.735) AC35(16.616,-10.735) AC36(17.378,-10.735) AC38(18.14,-10.735) AC39(18.902,-10.735) AC41(19.664,-10.735) AC43(20.426,-10.735) AC44(21.188,-10.735) AD19(8.715,-11.314) AD20(9.49,-11.314) AD22(10.265,-11.314) AD23(11.039,-11.314) AD25(11.814,-11.314) AD27(12.589,-11.314) AD28(13.363,-11.314) AD30(14.138,-11.314) AD31(14.913,-11.314) AE6(2.44,-11.893) AE7(3.202,-11.893) AE9(3.964,-11.893) AE11(4.726,-11.893) AE12(5.488,-11.893) AE14(6.25,-11.893) AE15(7.012,-11.893) AE17(7.774,-11.893) AE33(15.854,-11.893) AE35(16.616,-11.893) AE36(17.378,-11.893) AE38(18.14,-11.893) AE39(18.902,-11.893) AE41(19.664,-11.893) AE43(20.426,-11.893) AE44(21.188,-11.893) AF19(8.715,-12.089) AF20(9.49,-12.089) AF22(10.265,-12.089) AF23(11.039,-12.089) AF25(11.814,-12.089) AF27(12.589,-12.089) AF28(13.363,-12.089) AF30(14.138,-12.089) AF31(14.913,-12.089) AG19(8.715,-12.863) AG20(9.49,-12.863) AG22(10.265,-12.863) AG23(11.039,-12.863) AG25(11.814,-12.863) AG27(12.589,-12.863) AG28(13.363,-12.863) AG30(14.138,-12.863) AG31(14.913,-12.863) AH9(3.895,-13.519) AH10(4.634,-13.328) AH12(5.412,-13.328) AH14(6.25,-13.328) AH15(7.025,-13.328) AH17(7.787,-13.328) AH33(15.841,-13.328) AH35(16.603,-13.328) AH36(17.378,-13.328) AH38(18.216,-13.328) AH40(18.994,-13.328) AH41(19.733,-13.519) AJ6(2.417,-13.9) AJ7(3.156,-13.709) AJ19(8.715,-13.638) AJ20(9.49,-13.638) AJ22(10.265,-13.638) AJ23(11.039,-13.638) AJ25(11.814,-13.638) AJ27(12.589,-13.638) AJ28(13.363,-13.638) AJ30(14.138,-13.638) AJ31(14.913,-13.638) AJ43(20.472,-13.709) AJ44(21.211,-13.9) AK19(8.715,-14.413) AK20(9.49,-14.413) AK22(10.265,-14.413) AK23(11.039,-14.413) AK25(11.814,-14.413) AK27(12.589,-14.413) AK28(13.363,-14.413) AK30(14.138,-14.413) AK31(14.913,-14.413) AL9(3.9,-14.809) AL10(4.633,-14.573) AL12(5.395,-14.573) AL13(6.157,-14.573) AL15(6.919,-14.573) AL17(7.681,-14.573) AL21(9.8,-14.892) AL24(11.235,-14.905) AL26(12.393,-14.905) AL29(13.828,-14.892) AL33(15.947,-14.573) AL35(16.709,-14.573) AL37(17.471,-14.573) AL38(18.233,-14.573) AL40(18.995,-14.573) AL41(19.728,-14.809) AM7(3.179,-15.157) AM18(8.555,-14.997) AM32(15.073,-14.997) AM43(20.449,-15.157) AN6(2.519,-15.538) AN10(4.633,-15.97) AN12(5.37,-15.665) AN13(6.132,-15.665) AN15(6.894,-15.665) AN16(7.463,-15.708) AN18(8.555,-15.708) AN21(9.8,-15.603) AN24(11.235,-15.616) AN26(12.393,-15.616) AN29(13.828,-15.603) AN32(15.073,-15.708) AN34(16.165,-15.708) AN35(16.734,-15.665) AN37(17.496,-15.665) AN38(18.258,-15.665) AN40(18.995,-15.97) AN44(21.109,-15.538) AP9(3.9,-16.282) AP21(9.8,-16.378) AP24(11.235,-16.378) AP26(12.393,-16.378) AP29(13.828,-16.378) AP41(19.728,-16.282) AR8(3.306,-16.783) AR12(5.37,-16.757) AR13(6.132,-16.757) AR15(6.894,-16.757) AR16(7.463,-16.496) AR18(8.555,-16.47) AR32(15.073,-16.47) AR34(16.165,-16.496) AR35(16.734,-16.757) AR37(17.496,-16.757) AR38(18.258,-16.757) AR42(20.322,-16.783) AT6(2.519,-16.973) AT10(4.633,-17.087) AT16(7.463,-17.258) AT18(8.555,-17.232) AT21(9.8,-17.216) AT24(11.235,-17.14) AT26(12.393,-17.14) AT29(13.828,-17.216) AT32(15.073,-17.232) AT34(16.165,-17.258) AT40(18.995,-17.087) AT44(21.109,-16.973) AU9(3.9,-17.73) AU24(11.235,-17.902) AU26(12.393,-17.902) AU41(19.728,-17.73) AV6(2.519,-18.408) AV7(3.217,-18.078) AV11(4.735,-18.289) AV13(6.066,-18.071) AV16(7.158,-18.032) AV18(8.555,-17.994) AV21(9.8,-17.993) AV29(13.828,-17.993) AV32(15.073,-17.994) AV34(16.47,-18.032) AV37(17.562,-18.071) AV39(18.893,-18.289) AV43(20.411,-18.078) AV44(21.109,-18.408) AW9(3.99,-18.891) AW10(4.552,-18.823) AW13(5.804,-18.804) AW15(6.922,-18.766) AW18(8.319,-18.727) AW21(9.609,-18.733) AW24(11.235,-18.664) AW26(12.393,-18.664) AW29(14.019,-18.733) AW32(15.309,-18.727) AW35(16.706,-18.766) AW37(17.824,-18.804) AW40(19.076,-18.823) AW41(19.638,-18.891) AY8(3.281,-19.212) AY42(20.347,-19.212) B1(0,-0.354) B2(0.484,-0.484) B3(1.105,-0.436) B47(22.523,-0.436) B48(23.144,-0.484) B49(23.628,-0.354) BA6(2.684,-19.517) BA12(5.329,-19.449) BA14(6.574,-19.449) BA17(7.971,-19.449) BA20(9.419,-19.472) BA24(11.235,-19.426) BA26(12.393,-19.426) BA30(14.209,-19.472) BA33(15.657,-19.449) BA36(17.054,-19.449) BA38(18.299,-19.449) BA44(20.944,-19.517) BB6(2.726,-20.02) BB7(3.225,-20.314) BB9(3.79,-20.088) BB11(4.948,-20.109) BB14(6.193,-20.109) BB16(7.59,-20.109) BB20(9.228,-20.211) BB24(11.235,-20.188) BB26(12.393,-20.188) BB30(14.4,-20.211) BB34(16.038,-20.109) BB36(17.435,-20.109) BB39(18.68,-20.109) BB41(19.838,-20.088) BB43(20.403,-20.314) BB44(20.902,-20.02) BC5(2.18,-20.568) BC45(21.448,-20.568) BD1(0,-21.273) BD4(1.34,-21.297) BD46(22.288,-21.297) BD49(23.628,-21.273) BE1(0,-21.773) BE2(0.441,-21.51) BE3(0.954,-21.625) BE4(1.423,-21.801) BE5(1.849,-21.526) BE45(21.779,-21.526) BE46(22.205,-21.801) BE47(22.674,-21.625) BE48(23.187,-21.51) BE49(23.628,-21.773) BF1(0,-22.274) BF2(0.484,-22.144) BF3(1.105,-22.192) BF47(22.523,-22.192) BF48(23.144,-22.144) BF49(23.628,-22.274) BG2(0.354,-22.628) BG3(0.855,-22.628) BG4(1.355,-22.628) BG46(22.273,-22.628) BG47(22.773,-22.628) BG48(23.274,-22.628) C1(0,-0.855) C2(0.441,-1.118) C3(0.954,-1.003) C4(1.423,-0.827) C5(1.849,-1.102) C45(21.779,-1.102) C46(22.205,-0.827) C47(22.674,-1.003) C48(23.187,-1.118) C49(23.628,-0.855) D1(0,-1.355) D4(1.34,-1.331) D46(22.288,-1.331) D49(23.628,-1.355) E5(2.18,-2.06) E45(21.448,-2.06) F6(2.726,-2.608) F7(3.225,-2.314) F9(3.79,-2.539) F11(4.948,-2.519) F14(6.193,-2.519) F16(7.59,-2.519) F20(9.228,-2.417) F24(11.235,-2.44) F26(12.393,-2.44) F30(14.4,-2.417) F34(16.038,-2.519) F36(17.435,-2.519) F39(18.68,-2.519) F41(19.838,-2.539) F43(20.403,-2.314) F44(20.902,-2.608) G6(2.684,-3.111) G12(5.329,-3.179) G14(6.574,-3.179) G17(7.971,-3.179) G20(9.419,-3.156) G24(11.235,-3.202) G26(12.393,-3.202) G30(14.209,-3.156) G33(15.657,-3.179) G36(17.054,-3.179) G38(18.299,-3.179) G44(20.944,-3.111) H8(3.281,-3.416) H42(20.347,-3.416) J9(3.99,-3.737) J10(4.552,-3.805) J13(5.804,-3.824) J15(6.922,-3.862) J18(8.319,-3.9) J21(9.609,-3.895) J24(11.235,-3.964) J26(12.393,-3.964) J29(14.019,-3.895) J32(15.309,-3.9) J35(16.706,-3.862) J37(17.824,-3.824) J40(19.076,-3.805) J41(19.638,-3.737) K6(2.519,-4.22) K7(3.217,-4.55) K11(4.735,-4.339) K13(6.066,-4.557) K16(7.158,-4.595) K18(8.555,-4.633) K21(9.8,-4.634) K29(13.828,-4.634) K32(15.073,-4.633) K34(16.47,-4.595) K37(17.562,-4.557) K39(18.893,-4.339) K43(20.411,-4.55) K44(21.109,-4.22) L9(3.9,-4.898) L24(11.235,-4.726) L26(12.393,-4.726) L41(19.728,-4.898) M6(2.519,-5.655) M10(4.633,-5.541) M16(7.463,-5.37) M18(8.555,-5.395) M21(9.8,-5.412) M24(11.235,-5.488) M26(12.393,-5.488) M29(13.828,-5.412) M32(15.073,-5.395) M34(16.165,-5.37) M40(18.995,-5.541) M44(21.109,-5.655) N8(3.306,-5.845) N12(5.37,-5.871) N13(6.132,-5.871) N15(6.894,-5.871) N16(7.463,-6.132) N18(8.555,-6.157) N32(15.073,-6.157) N34(16.165,-6.132) N35(16.734,-5.871) N37(17.496,-5.871) N38(18.258,-5.871) N42(20.322,-5.845) P9(3.9,-6.346) P21(9.8,-6.25) P24(11.235,-6.25) P26(12.393,-6.25) P29(13.828,-6.25) P41(19.728,-6.346) R6(2.519,-7.09) R10(4.633,-6.658) R12(5.37,-6.963) R13(6.132,-6.963) R15(6.894,-6.963) R16(7.463,-6.919) R18(8.555,-6.919) R21(9.8,-7.025) R24(11.235,-7.012) R26(12.393,-7.012) R29(13.828,-7.025) R32(15.073,-6.919) R34(16.165,-6.919) R35(16.734,-6.963) R37(17.496,-6.963) R38(18.258,-6.963) R40(18.995,-6.658) R44(21.109,-7.09) T7(3.179,-7.471) T17(8.003,-7.631) T18(8.555,-7.631) T32(15.073,-7.631) T43(20.449,-7.471) U9(3.9,-7.819) U10(4.633,-8.055) U12(5.395,-8.055) U13(6.157,-8.055) U15(6.919,-8.055) U17(7.681,-8.055) U21(9.8,-7.736) U24(11.235,-7.723) U26(12.393,-7.723) U29(13.828,-7.736) U33(15.947,-8.055) U35(16.709,-8.055) U37(17.471,-8.055) U38(18.233,-8.055) U40(18.995,-8.055) U41(19.728,-7.819) V19(8.715,-8.215) V20(9.49,-8.215) V22(10.265,-8.215) V23(11.039,-8.215) V25(11.814,-8.215) V27(12.589,-8.215) V28(13.363,-8.215) V30(14.138,-8.215) V31(14.913,-8.215) W6(2.417,-8.728) W7(3.156,-8.919) W19(8.715,-8.99) W20(9.49,-8.99) W22(10.265,-8.99) W23(11.039,-8.99) W25(11.814,-8.99) W27(12.589,-8.99) W28(13.363,-8.99) W30(14.138,-8.99) W31(14.913,-8.99) W43(20.472,-8.919) W44(21.211,-8.728) Y9(3.895,-9.109) Y10(4.634,-9.3) Y12(5.412,-9.3) Y14(6.25,-9.3) Y15(7.025,-9.3) Y17(7.787,-9.3) Y33(15.841,-9.3) Y35(16.603,-9.3) Y36(17.378,-9.3) Y38(18.216,-9.3) Y40(18.994,-9.3) Y41(19.733,-9.109)
  round 0.279 smd: A5(1.856,0) A45(21.772,0) BC1(0,-20.772) BC49(23.628,-20.772) BG5(1.856,-22.628) BG45(21.772,-22.628) E1(0,-1.856) E49(23.628,-1.856)
  oval 0.203x0.254 smd: A6(2.415,0) A8(3.52,0) A42(20.108,0) A44(21.213,0) BD8(3.403,-21.127) BD12(5.6,-21.127) BD17(7.797,-21.127) BD21(9.994,-21.127) BD29(13.634,-21.127) BD33(15.831,-21.127) BD38(18.028,-21.127) BD42(20.225,-21.127) BE9(4.03,-21.5) BE10(4.531,-21.373) BE14(6.227,-21.5) BE15(6.728,-21.373) BE18(8.424,-21.5) BE19(8.925,-21.373) BE23(10.621,-21.5) BE24(11.122,-21.373) BE26(12.506,-21.373) BE27(13.007,-21.5) BE31(14.703,-21.373) BE32(15.204,-21.5) BE35(16.9,-21.373) BE36(17.401,-21.5) BE40(19.097,-21.373) BE41(19.598,-21.5) BG6(2.415,-22.628) BG8(3.52,-22.628) BG42(20.108,-22.628) BG44(21.213,-22.628) C9(4.03,-1.128) C10(4.531,-1.255) C14(6.227,-1.128) C15(6.728,-1.255) C18(8.424,-1.128) C19(8.925,-1.255) C23(10.621,-1.128) C24(11.122,-1.255) C26(12.506,-1.255) C27(13.007,-1.128) C31(14.703,-1.255) C32(15.204,-1.128) C35(16.9,-1.255) C36(17.401,-1.128) C40(19.097,-1.255) C41(19.598,-1.128) D8(3.403,-1.501) D12(5.6,-1.501) D17(7.797,-1.501) D21(9.994,-1.501) D29(13.634,-1.501) D33(15.831,-1.501) D38(18.028,-1.501) D42(20.225,-1.501)
  oval 0.178x0.254 smd: A13(5.742,0) A17(7.939,0) A22(10.136,0) A25(11.814,0) A28(13.492,0) A33(15.689,0) A37(17.886,0) B10(4.691,-0.711) B12(5.549,-0.498) B14(6.227,-0.627) B15(6.888,-0.711) B17(7.746,-0.498) B18(8.424,-0.627) B19(9.085,-0.711) B21(9.943,-0.498) B23(10.621,-0.627) B24(11.282,-0.711) B25(11.814,-0.508) B26(12.346,-0.711) B27(13.007,-0.627) B29(13.685,-0.498) B31(14.543,-0.711) B32(15.204,-0.627) B33(15.882,-0.498) B35(16.74,-0.711) B36(17.401,-0.627) B38(18.079,-0.498) B40(18.937,-0.711) BE11(5.054,-21.432) BE12(5.519,-21.627) BE16(7.251,-21.432) BE17(7.716,-21.627) BE20(9.448,-21.432) BE21(9.913,-21.627) BE25(11.814,-21.612) BE29(13.715,-21.627) BE30(14.18,-21.432) BE33(15.912,-21.627) BE34(16.377,-21.432) BE38(18.109,-21.627) BE39(18.575,-21.432) BF10(4.691,-21.917) BF12(5.549,-22.129) BF14(6.227,-22) BF15(6.888,-21.917) BF17(7.746,-22.129) BF18(8.424,-22) BF19(9.085,-21.917) BF21(9.943,-22.129) BF23(10.621,-22) BF24(11.282,-21.917) BF25(11.814,-22.12) BF26(12.346,-21.917) BF27(13.007,-22) BF29(13.685,-22.129) BF31(14.543,-21.917) BF32(15.204,-22) BF33(15.882,-22.129) BF35(16.74,-21.917) BF36(17.401,-22) BF38(18.079,-22.129) BF40(18.937,-21.917) BG13(5.742,-22.628) BG17(7.939,-22.628) BG22(10.136,-22.628) BG25(11.814,-22.628) BG28(13.492,-22.628) BG33(15.689,-22.628) BG37(17.886,-22.628) C11(5.054,-1.196) C12(5.519,-1.001) C16(7.251,-1.196) C17(7.716,-1.001) C20(9.448,-1.196) C21(9.913,-1.001) C25(11.814,-1.016) C29(13.715,-1.001) C30(14.18,-1.196) C33(15.912,-1.001) C34(16.377,-1.196) C38(18.109,-1.001) C39(18.575,-1.196)
  oval 0.254x0.178 smd: AA1(0,-9.636) AA49(23.628,-9.636) AB2(0.627,-10.121) AB48(23.001,-10.121) AC2(0.711,-10.782) AC48(22.917,-10.782) AD1(0,-11.314) AD2(0.508,-11.314) AD3(1.016,-11.314) AD47(22.612,-11.314) AD48(23.12,-11.314) AD49(23.628,-11.314) AE2(0.711,-11.846) AE48(22.917,-11.846) AF2(0.627,-12.507) AF48(23.001,-12.507) AG1(0,-12.992) AG49(23.628,-12.992) AH2(0.498,-13.185) AH3(1.001,-13.215) AH47(22.627,-13.215) AH48(23.13,-13.185) AJ3(1.196,-13.68) AJ47(22.432,-13.68) AK2(0.711,-14.043) AK48(22.917,-14.043) AL2(0.627,-14.704) AL48(23.001,-14.704) AM1(0,-15.189) AM2(0.498,-15.382) AM3(1.001,-15.412) AM47(22.627,-15.412) AM48(23.13,-15.382) AM49(23.628,-15.189) AN3(1.196,-15.877) AN47(22.432,-15.877) AP2(0.711,-16.24) AP48(22.917,-16.24) P2(0.711,-6.388) P48(22.917,-6.388) R3(1.196,-6.751) R47(22.432,-6.751) T1(0,-7.439) T2(0.498,-7.246) T3(1.001,-7.216) T47(22.627,-7.216) T48(23.13,-7.246) T49(23.628,-7.439) U2(0.627,-7.924) U48(23.001,-7.924) V2(0.711,-8.585) V48(22.917,-8.585) W3(1.196,-8.948) W47(22.432,-8.948) Y2(0.498,-9.443) Y3(1.001,-9.413) Y47(22.627,-9.413) Y48(23.13,-9.443)
  round 0.254 smd: AA5(1.958,-9.712) AA45(21.67,-9.712) AC4(1.754,-10.735) AC46(21.874,-10.735) AE4(1.754,-11.893) AE46(21.874,-11.893) AG5(1.958,-12.915) AG45(21.67,-12.915) AJ4(1.716,-13.588) AJ46(21.912,-13.588) AK4(1.754,-14.09) AK46(21.874,-14.09) AM5(1.958,-15.112) AM45(21.67,-15.112) AN4(1.716,-15.785) AN46(21.912,-15.785) AP4(1.754,-16.287) AP46(21.874,-16.287) AT5(1.958,-17.31) AT45(21.67,-17.31) AV4(1.716,-17.982) AV46(21.912,-17.982) AW4(1.754,-18.484) AW46(21.874,-18.484) B6(2.417,-0.503) B44(21.211,-0.503) BA2(0.498,-19.84) BA3(1.005,-19.908) BA4(1.51,-19.782) BA5(1.958,-19.507) BA45(21.67,-19.507) BA46(22.118,-19.782) BA47(22.623,-19.908) BA48(23.13,-19.84) BB3(0.496,-20.629) BB4(0.989,-20.44) BB46(22.64,-20.44) BB47(23.132,-20.629) BC8(3.621,-20.67) BC10(4.644,-20.874) BC13(5.818,-20.67) BC15(6.841,-20.874) BC17(8.015,-20.67) BC19(9.038,-20.874) BC22(10.213,-20.67) BC24(11.235,-20.874) BC26(12.393,-20.874) BC28(13.416,-20.67) BC31(14.59,-20.874) BC33(15.613,-20.67) BC35(16.787,-20.874) BC37(17.81,-20.67) BC40(18.984,-20.874) BC42(20.007,-20.67) BD7(2.9,-21.186) BD11(5.146,-20.912) BD16(7.343,-20.912) BD20(9.54,-20.912) BD30(14.088,-20.912) BD34(16.285,-20.912) BD39(18.483,-20.912) BD43(20.728,-21.186) BE6(2.723,-21.671) BE44(20.905,-21.671) BF6(2.417,-22.125) BF44(21.211,-22.125) C6(2.723,-0.957) C44(20.905,-0.957) D7(2.9,-1.441) D11(5.146,-1.716) D16(7.343,-1.716) D20(9.54,-1.716) D30(14.088,-1.716) D34(16.285,-1.716) D39(18.483,-1.716) D43(20.728,-1.441) E8(3.621,-1.958) E10(4.644,-1.754) E13(5.818,-1.958) E15(6.841,-1.754) E17(8.015,-1.958) E19(9.038,-1.754) E22(10.213,-1.958) E24(11.235,-1.754) E26(12.393,-1.754) E28(13.416,-1.958) E31(14.59,-1.754) E33(15.613,-1.958) E35(16.787,-1.754) E37(17.81,-1.958) E40(18.984,-1.754) E42(20.007,-1.958) F3(0.496,-1.999) F4(0.989,-2.187) F46(22.64,-2.187) F47(23.132,-1.999) G2(0.498,-2.788) G3(1.005,-2.72) G4(1.51,-2.846) G5(1.958,-3.121) G45(21.67,-3.121) G46(22.118,-2.846) G47(22.623,-2.72) G48(23.13,-2.788) J4(1.754,-4.144) J46(21.874,-4.144) K4(1.716,-4.645) K46(21.912,-4.645) M5(1.958,-5.318) M45(21.67,-5.318) P4(1.754,-6.341) P46(21.874,-6.341) R4(1.716,-6.843) R46(21.912,-6.843) T5(1.958,-7.515) T45(21.67,-7.515) V4(1.754,-8.538) V46(21.874,-8.538) W4(1.716,-9.04) W46(21.912,-9.04)
  oval 0.254x0.203 smd: AB3(1.128,-10.121) AB47(22.5,-10.121) AC3(1.255,-10.622) AC47(22.373,-10.622) AE3(1.255,-12.006) AE47(22.373,-12.006) AF3(1.128,-12.507) AF47(22.5,-12.507) AH4(1.501,-13.134) AH46(22.127,-13.134) AK3(1.255,-14.197) AK47(22.373,-14.197) AL3(1.128,-14.704) AL47(22.5,-14.704) AM4(1.501,-15.331) AM46(22.127,-15.331) AP3(1.255,-16.394) AP47(22.373,-16.394) AR3(1.128,-16.901) AR47(22.5,-16.901) AT1(0,-17.411) AT49(23.628,-17.411) AU4(1.501,-17.528) AU46(22.127,-17.528) AW3(1.255,-18.591) AW47(22.373,-18.591) AY3(1.128,-19.098) AY47(22.5,-19.098) BA1(0,-19.634) BA49(23.628,-19.634) G1(0,-2.994) G49(23.628,-2.994) H3(1.128,-3.53) H47(22.5,-3.53) J3(1.255,-4.037) J47(22.373,-4.037) L4(1.501,-5.1) L46(22.127,-5.1) M1(0,-5.217) M49(23.628,-5.217) N3(1.128,-5.727) N47(22.5,-5.727) P3(1.255,-6.234) P47(22.373,-6.234) T4(1.501,-7.297) T46(22.127,-7.297) U3(1.128,-7.924) U47(22.5,-7.924) V3(1.255,-8.431) V47(22.373,-8.431) Y4(1.501,-9.494) Y46(22.127,-9.494)
  oval 0.305x0.152 smd: AR2(0.627,-16.901) AR48(23.001,-16.901) AU2(0.498,-17.579) AU3(1.001,-17.609) AU47(22.627,-17.609) AU48(23.13,-17.579) AV3(1.196,-18.074) AV47(22.432,-18.074) AW2(0.711,-18.437) AW48(22.917,-18.437) AY2(0.627,-19.098) AY48(23.001,-19.098) H2(0.627,-3.53) H48(23.001,-3.53) J2(0.711,-4.19) J48(22.917,-4.19) K3(1.196,-4.553) K47(22.432,-4.553) L2(0.498,-5.049) L3(1.001,-5.019) L47(22.627,-5.019) L48(23.13,-5.049) N2(0.627,-5.727) N48(23.001,-5.727)
  oval 0.152x0.305 smd: B8(3.352,-0.498) B9(4.03,-0.627) B41(19.598,-0.627) B42(20.276,-0.498) BE8(3.322,-21.627) BE42(20.307,-21.627) BF8(3.352,-22.129) BF9(4.03,-22) BF41(19.598,-22) BF42(20.276,-22.129) C8(3.322,-1.001) C42(20.307,-1.001)
CONCR_099BKAC19YBLCNF_19P
  round 0.813 hole 0.508: 1(0,0) 2(0.5,1.5) 3(1,0) 4(1.5,1.5) 5(2,0) 6(2.5,1.5) 7(3,0) 8(3.5,1.5) 9(4,0) 10(4.5,1.5) 11(5,0) 12(5.5,1.5) 13(6,0) 14(6.5,1.5) 15(7,0) 16(7.5,1.5) 17(8,0) 18(8.5,1.5) 19(9,0)
  oval 1.397x3.15 hole 0.787x2.54: 20(-2.75,0.9) 21(11.75,0.9)
  oval 1.803x2.794 hole 0.787x1.803: 22(-4.75,-6.08) 23(13.75,-6.08)
CONCR_213BAAA42FA_75P
  round 1.092 hole 1.092 unplated: (-0.75,-5.275)
  round 1.6 hole 1.6 unplated: (19.25,-5.275)
  oval 0.305x1.549 smd: 1(0,0) 2(0.25,-7.55) 3(0.5,0) 4(0.75,-7.55) 5(1,0) 6(1.25,-7.55) 7(1.5,0) 8(1.75,-7.55) 9(2,0) 10(2.25,-7.55) 11(2.5,0) 20(4.75,-7.55) 21(5,0) 22(5.25,-7.55) 23(5.5,0) 24(5.75,-7.55) 25(6,0) 26(6.25,-7.55) 27(6.5,0) 28(6.75,-7.55) 29(7,0) 30(7.25,-7.55) 31(7.5,0) 32(7.75,-7.55) 33(8,0) 34(8.25,-7.55) 35(8.5,0) 36(8.75,-7.55) 37(9,0) 38(9.25,-7.55) 39(9.5,0) 40(9.75,-7.55) 41(10,0) 42(10.25,-7.55) 43(10.5,0) 44(10.75,-7.55) 45(11,0) 46(11.25,-7.55) 47(11.5,0) 48(11.75,-7.55) 49(12,0) 50(12.25,-7.55) 51(12.5,0) 52(12.75,-7.55) 53(13,0) 54(13.25,-7.55) 55(13.5,0) 56(13.75,-7.55) 57(14,0) 58(14.25,-7.55) 59(14.5,0) 60(14.75,-7.55) 61(15,0) 62(15.25,-7.55) 63(15.5,0) 64(15.75,-7.55) 65(16,0) 66(16.25,-7.55) 67(16.5,0) 68(16.75,-7.55) 69(17,0) 70(17.25,-7.55) 71(17.5,0) 72(17.75,-7.55) 73(18,0) 74(18.25,-7.55) 75(18.5,0)
  rect 1.194x2.743 smd: 76(-1.1,-0.775) 77(19.6,-0.775)
CVILU_CF5006FD0R0-05-NH_6P
  oval 0.305x1.092 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0)
  rect 0.991x2.007 smd: 7(-2.1,-3.15) 8(4.6,-3.15)
CVILU_CF5020FD0RK-05-NH_20P-T
  oval 0.305x0.94 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0) 19(9,0) 20(9.5,0)
  rect 1.651x1.397 smd: 21(-2.325,-3.375) 22(11.825,-3.375)
CVILU_CF5026FD0RK-05-NH_26P-T
  oval 0.305x0.94 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0) 19(9,0) 20(9.5,0) 21(10,0) 22(10.5,0) 23(11,0) 24(11.5,0) 25(12,0) 26(12.5,0)
  rect 1.651x1.397 smd: 27(14.825,-3.375) 28(-2.325,-3.375)
CVILU_CI0805M1HRC-NH_5P-T
  round 1.803 hole 1.803 unplated: (-0.2,5.2) (8.2,5.2)
  oval 0.889x2.388 smd: 1(0,0) 2(2,0) 3(4,0) 4(6,0) 5(8,0)
  rect 1.6x2.489 smd: 6(11.15,9.05) 7(-3.15,9.05)
CYNTE_PCMB042T-1R0MS_2P
  rect 1.499x2.489 smd: 1(0,0) 2(3.7,0)
CYNTE_PCMC063T-1R5MN_2P
  rect 2.159x3.505 smd: 1(0,0) 2(5.85,0)
D_SOD323-2
  rect 0.787x0.889 smd: 1(0,0) 2(2.14,0)
DB3J315E0L_SMINI3-F2-B3
  oval 0.889x0.787 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
DDTA144VCA-7-F_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
DEREN_40-42251-01001RHF_10P-T
  oval 0.838x2.21 smd: 1(0,0.1) 2(1.5,0.1) 3(3,0.1) 4(4.5,0.1) 5(6,0.1) 6(7.5,0.1) 7(9,0.1) 8(10.5,0.1) 9(12,0.1) 10(13.5,0.1)
  custom 0.75x0.75 smd: 11(-3.4,-3.15) 12(16.9,-3.15)
DFLS160-7_POWERDI123-2
  rect 2.21x1.397 smd: 1(0,0)
  rect 0.889x1.397 smd: 2(-2.55,0)
DMN65D8LDW-7_SOT363-6
  oval 0.432x0.61 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0.65,1.9) 6(0,1.9)
DMN65D8LW-7_SOT323-3
  oval 0.711x0.889 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
DMN66D0LDW-7_SOT363-6
  oval 0.432x0.61 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0.65,1.9) 6(0,1.9)
EM1109V-AD_DFN3308-8_3X3
  oval 0.381x0.889 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(1.95,3.1) 6(1.3,3.1) 7(0.65,3.1) 8(0,3.1)
  rect 2.388x1.6 smd: 9(0.975,1.55)
EM5209VF_DFN14_3X2
  oval 0.203x0.711 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.4,2) 9(2,2) 10(1.6,2) 11(1.2,2) 12(0.8,2) 13(0.4,2) 14(0,2)
  rect 2.591x0.991 smd: 15(1.2,1)
ESD101-B1-02ELS_TSSLP-2-4-2
  rect 0.279x0.381 smd: 1(0,0) 2(0.38,0)
FDV301N-G_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
FIDUCIAL_C40M80
  round 1.016 smd: 1(0,0)
G524B1T11U_SOT23-5
  oval 0.533x1.194 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,3) 5(0,3)
H_0P7N
  round 0.711 hole 0.711 unplated: (0,0)
H_0P9N
  round 0.889 hole 0.889 unplated: (0,0)
H_1P0N
  round 0.991 hole 0.991 unplated: (0,0)
H_2P4-G
  round 2.896 hole 2.388: 1(0,0)
H_2P4N
  round 2.388 hole 2.388 unplated: (0,0)
H_2P4X1P8N
  oval 2.388x1.803 hole 2.388x1.803 unplated: (0,0)
H_2P6-G
  round 3.099 hole 2.591: 1(0,0)
H_3P2
  round 3.708 hole 3.2: 1(0,0)
H_3P2N
  round 3.2 hole 3.2 unplated: (0,0)
H_3P3
  round 3.81 hole 3.302: 1(0,0)
H_3P8
  round 4.318 hole 3.81: 1(0,0)
H_4P6-G
  round 5.105 hole 4.597: 1(0,0)
H_5P0X4P0N
  oval 5.004x3.988 hole 5.004x3.988 unplated: (0,0)
H_5P1-G
  round 5.613 hole 5.105: 1(0,0)
H_5P2-G
  round 5.715 hole 5.207: 1(0,0)
INPAQ_HCM1012GH900BP_4P
  rect 0.711x0.305 smd: 1(0,0) 2(1.25,0) 3(1.25,-0.5) 4(0,-0.5)
INPAQ_MCM1012B900F06BP_4P
  rect 0.711x0.305 smd: 1(0,0) 2(1.25,0) 3(1.25,-0.5) 4(0,-0.5)
ISL9538HRTZTS277_TQFN32_4X4
  oval 0.787x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 17(4.2,-2.8) 18(4.2,-2.4) 19(4.2,-2) 20(4.2,-1.6) 21(4.2,-1.2) 22(4.2,-0.8) 23(4.2,-0.4) 24(4.2,0)
  oval 0.203x0.787 smd: 9(0.7,-3.5) 10(1.1,-3.5) 11(1.5,-3.5) 12(1.9,-3.5) 13(2.3,-3.5) 14(2.7,-3.5) 15(3.1,-3.5) 16(3.5,-3.5) 25(3.5,0.7) 26(3.1,0.7) 27(2.7,0.7) 28(2.3,0.7) 29(1.9,0.7) 30(1.5,0.7) 31(1.1,0.7) 32(0.7,0.7)
  rect 2.692x2.692 smd: 33(2.1,-1.4)
J-L_TNBNRAC70030009_9P
  round 1.295 hole 0.711: 1(0,0) 2(-2.5,0) 3(-4.5,0) 4(-7,0) 5(-7.5,-1.5) 6(-5.5,-1.5) 7(-3.5,-1.5) 8(-1.5,-1.5) 9(0.5,-1.5)
  oval 1.397x3.2 hole 0.787x2.591: 10(4.35,-2.43) 11(-11.35,-2.43)
  oval 1.397x2.311 hole 0.787x1.702: 12(-11.35,-9.23) 13(4.35,-9.23)
JAE_DX07BD24JJ2_24P-T
  oval 1.194x2.311 hole 0.61x1.905: 1(-1.695,-0.7) 2(6.945,-0.7)
  oval 1.651x1.092 hole 1.245x0.711: 3(-1.37,-1.3) 4(6.62,-1.3)
  custom 0.325x0.325 hole 0.711x1.499: 5(-3.225,-6) 6(8.475,-6)
  oval 0.279x0.889 smd: A1(0,0) A2(0.5,0) A3(1,0) A4(1.5,0) A5(2,0) A6(2.5,0) A7(3,0) A8(3.5,0) A9(4,0) A10(4.5,0) A11(5,0) A12(5.5,0)
  oval 0.279x0.787 smd: B1(5.25,-1.6) B2(4.75,-1.6) B3(4.25,-1.6) B4(3.75,-1.6) B5(3.25,-1.6) B6(2.75,-1.6) B7(2.25,-1.6) B8(1.75,-1.6) B9(1.25,-1.6) B10(0.75,-1.6) B11(0.25,-1.6) B12(-0.25,-1.6)
JUMP_43X39
  custom 0.191x0.191 smd: 1(0,0) 2(0.914,0)
JUMP_43X79
  custom 0.188x0.188 smd: 1(0,0) 2(1.1,0)
JUMP_43X118
  custom 0.187x0.187 smd: 1(0,0) 2(1.1,0)
JUMP_43X118-NPM
  custom 0.187x0.187 smd: 1(0,0) 2(1.1,0)
JXT_FP241AH-006GAAM_6P
  oval 0.305x0.965 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0)
  rect 0.305x1.143 smd: 7(-0.885,-2.965) 8(3.385,-2.965)
JXT_FP241AH-010GAAM_10P
  oval 0.305x1.092 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0)
  rect 0.406x0.787 smd: 11(-1,-2.65) 12(5.5,-2.65)
L2N7002WT1G_SC-70-3
  oval 0.711x0.889 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
L03ESDL5V0CC3-2_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
L05ESDL5V0NA-4_SLP2510P8-10-9
  rect 0.203x0.686 smd: 1(0,0) 2(-0.5,0) 4(-1.5,0) 5(-2,0) 6(-2,-0.875) 7(-1.5,-0.875) 8(-0.5,-0.875) 9(0,-0.875)
  rect 0.406x1.549 smd: 3(-1,-0.437)
L30ESD24VC3-2_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
L_5X5X3_M_2P
  rect 2.159x2.794 smd: 1(0,0) 2(4.35,0)
L_7X7X3_M
  custom 0.591x0.591 smd: 1(0,0) 4(6.05,0)
  rect 0.762x0.508 smd: 2(0.8,0) 3(5.25,0)
L_7X7X3_M_2P
  rect 2.362x3.505 smd: 1(0,0) 2(6.05,0)
LCN_DAN05-67356-0103_75P
  round 1.092 hole 1.092 unplated: (-0.75,-5.275)
  round 1.6 hole 1.6 unplated: (19.25,-5.275)
  oval 0.305x1.549 smd: 1(0,0) 2(0.25,-7.55) 3(0.5,0) 4(0.75,-7.55) 5(1,0) 6(1.25,-7.55) 7(1.5,0) 8(1.75,-7.55) 9(2,0) 10(2.25,-7.55) 11(2.5,0) 12(2.75,-7.55) 13(3,0) 14(3.25,-7.55) 15(3.5,0) 16(3.75,-7.55) 17(4,0) 18(4.25,-7.55) 19(4.5,0) 20(4.75,-7.55) 21(5,0) 22(5.25,-7.55) 23(5.5,0) 24(5.75,-7.55) 25(6,0) 26(6.25,-7.55) 27(6.5,0) 28(6.75,-7.55) 29(7,0) 30(7.25,-7.55) 31(7.5,0) 32(7.75,-7.55) 33(8,0) 34(8.25,-7.55) 35(8.5,0) 36(8.75,-7.55) 37(9,0) 38(9.25,-7.55) 39(9.5,0) 40(9.75,-7.55) 41(10,0) 42(10.25,-7.55) 43(10.5,0) 44(10.75,-7.55) 45(11,0) 46(11.25,-7.55) 47(11.5,0) 48(11.75,-7.55) 49(12,0) 50(12.25,-7.55) 51(12.5,0) 52(12.75,-7.55) 53(13,0) 54(13.25,-7.55) 55(13.5,0) 56(13.75,-7.55) 57(14,0) 58(14.25,-7.55) 67(16.5,0) 68(16.75,-7.55) 69(17,0) 70(17.25,-7.55) 71(17.5,0) 72(17.75,-7.55) 73(18,0) 74(18.25,-7.55) 75(18.5,0)
  rect 1.194x2.743 smd: 76(19.6,-0.775) 77(-1.1,-0.775)
LCN_DAN05-67406-0102_75P-T
  round 1.092 hole 1.092 unplated: (-0.75,-5.275)
  round 1.6 hole 1.6 unplated: (19.25,-5.275)
  oval 0.305x1.549 smd: 1(0,0) 2(0.25,-7.55) 3(0.5,0) 4(0.75,-7.55) 5(1,0) 6(1.25,-7.55) 7(1.5,0) 8(1.75,-7.55) 9(2,0) 10(2.25,-7.55) 11(2.5,0) 12(2.75,-7.55) 13(3,0) 14(3.25,-7.55) 15(3.5,0) 16(3.75,-7.55) 17(4,0) 18(4.25,-7.55) 19(4.5,0) 20(4.75,-7.55) 21(5,0) 22(5.25,-7.55) 23(5.5,0) 32(7.75,-7.55) 33(8,0) 34(8.25,-7.55) 35(8.5,0) 36(8.75,-7.55) 37(9,0) 38(9.25,-7.55) 39(9.5,0) 40(9.75,-7.55) 41(10,0) 42(10.25,-7.55) 43(10.5,0) 44(10.75,-7.55) 45(11,0) 46(11.25,-7.55) 47(11.5,0) 48(11.75,-7.55) 49(12,0) 50(12.25,-7.55) 51(12.5,0) 52(12.75,-7.55) 53(13,0) 54(13.25,-7.55) 55(13.5,0) 56(13.75,-7.55) 57(14,0) 58(14.25,-7.55) 59(14.5,0) 60(14.75,-7.55) 61(15,0) 62(15.25,-7.55) 63(15.5,0) 64(15.75,-7.55) 65(16,0) 66(16.25,-7.55) 67(16.5,0) 68(16.75,-7.55) 69(17,0) 70(17.25,-7.55) 71(17.5,0) 72(17.75,-7.55) 73(18,0) 74(18.25,-7.55) 75(18.5,0)
  rect 1.194x2.743 smd: 76(-1.1,-0.775) 77(19.6,-0.775)
LCN_DAN05-Q0406-0103_260P
  round 1.092 hole 1.092 unplated: (-67.775,-4.1)
  round 1.6 hole 1.6 unplated: (1.025,-4.1)
  oval 0.305x1.753 smd: 1(0,0) 2(-0.25,-8.2) 3(-0.5,0) 4(-0.75,-8.2) 5(-1,0) 6(-1.25,-8.2) 7(-1.5,0) 8(-1.75,-8.2) 9(-2,0) 10(-2.25,-8.2) 11(-2.5,0) 12(-2.75,-8.2) 13(-3,0) 14(-3.25,-8.2) 15(-3.5,0) 16(-3.75,-8.2) 17(-4,0) 18(-4.25,-8.2) 19(-4.5,0) 20(-4.75,-8.2) 21(-5,0) 22(-5.25,-8.2) 23(-5.5,0) 24(-5.75,-8.2) 25(-6,0) 26(-6.25,-8.2) 27(-6.5,0) 28(-6.75,-8.2) 29(-7,0) 30(-7.25,-8.2) 31(-7.5,0) 32(-7.75,-8.2) 33(-8,0) 34(-8.25,-8.2) 35(-8.5,0) 36(-8.75,-8.2) 37(-9,0) 38(-9.25,-8.2) 39(-9.5,0) 40(-9.75,-8.2) 41(-10,0) 42(-10.25,-8.2) 43(-10.5,0) 44(-10.75,-8.2) 45(-11,0) 46(-11.25,-8.2) 47(-11.5,0) 48(-11.75,-8.2) 49(-12,0) 50(-12.25,-8.2) 51(-12.5,0) 52(-12.75,-8.2) 53(-13,0) 54(-13.25,-8.2) 55(-13.5,0) 56(-13.75,-8.2) 57(-14,0) 58(-14.25,-8.2) 59(-14.5,0) 60(-14.75,-8.2) 61(-15,0) 62(-15.25,-8.2) 63(-15.5,0) 64(-15.75,-8.2) 65(-16,0) 66(-16.25,-8.2) 67(-16.5,0) 68(-16.75,-8.2) 69(-17,0) 70(-17.25,-8.2) 71(-17.5,0) 72(-17.75,-8.2) 73(-18,0) 74(-18.25,-8.2) 75(-18.5,0) 76(-18.75,-8.2) 77(-19,0) 78(-19.25,-8.2) 79(-19.5,0) 80(-19.75,-8.2) 81(-20,0) 82(-20.25,-8.2) 83(-20.5,0) 84(-20.75,-8.2) 85(-21,0) 86(-21.25,-8.2) 87(-21.5,0) 88(-21.75,-8.2) 89(-22,0) 90(-22.25,-8.2) 91(-22.5,0) 92(-22.75,-8.2) 93(-23,0) 94(-23.25,-8.2) 95(-23.5,0) 96(-23.75,-8.2) 97(-24,0) 98(-24.25,-8.2) 99(-24.5,0) 100(-24.75,-8.2) 101(-25,0) 102(-25.25,-8.2) 103(-25.5,0) 104(-25.75,-8.2) 105(-26,0) 106(-26.25,-8.2) 107(-26.5,0) 108(-26.75,-8.2) 109(-27,0) 110(-27.25,-8.2) 111(-27.5,0) 112(-27.75,-8.2) 113(-28,0) 114(-28.25,-8.2) 115(-28.5,0) 116(-28.75,-8.2) 117(-29,0) 118(-29.25,-8.2) 119(-29.5,0) 120(-29.75,-8.2) 121(-30,0) 122(-30.25,-8.2) 123(-30.5,0) 124(-30.75,-8.2) 125(-31,0) 126(-31.25,-8.2) 127(-31.5,0) 128(-31.75,-8.2) 129(-32,0) 130(-32.25,-8.2) 131(-32.5,0) 132(-32.75,-8.2) 133(-33,0) 134(-33.25,-8.2) 135(-33.5,0) 136(-33.75,-8.2) 137(-34,0) 138(-34.25,-8.2) 139(-34.5,0) 140(-34.75,-8.2) 141(-35,0) 142(-35.25,-8.2) 143(-35.5,0) 144(-35.75,-8.2) 145(-38,0) 146(-38.25,-8.2) 147(-38.5,0) 148(-38.75,-8.2) 149(-39,0) 150(-39.25,-8.2) 151(-39.5,0) 152(-39.75,-8.2) 153(-40,0) 154(-40.25,-8.2) 155(-40.5,0) 156(-40.75,-8.2) 157(-41,0) 158(-41.25,-8.2) 159(-41.5,0) 160(-41.75,-8.2) 161(-42,0) 162(-42.25,-8.2) 163(-42.5,0) 164(-42.75,-8.2) 165(-43,0) 166(-43.25,-8.2) 167(-43.5,0) 168(-43.75,-8.2) 169(-44,0) 170(-44.25,-8.2) 171(-44.5,0) 172(-44.75,-8.2) 173(-45,0) 174(-45.25,-8.2) 175(-45.5,0) 176(-45.75,-8.2) 177(-46,0) 178(-46.25,-8.2) 179(-46.5,0) 180(-46.75,-8.2) 181(-47,0) 182(-47.25,-8.2) 183(-47.5,0) 184(-47.75,-8.2) 185(-48,0) 186(-48.25,-8.2) 187(-48.5,0) 188(-48.75,-8.2) 189(-49,0) 190(-49.25,-8.2) 191(-49.5,0) 192(-49.75,-8.2) 193(-50,0) 194(-50.25,-8.2) 195(-50.5,0) 196(-50.75,-8.2) 197(-51,0) 198(-51.25,-8.2) 199(-51.5,0) 200(-51.75,-8.2) 201(-52,0) 202(-52.25,-8.2) 203(-52.5,0) 204(-52.75,-8.2) 205(-53,0) 206(-53.25,-8.2) 207(-53.5,0) 208(-53.75,-8.2) 209(-54,0) 210(-54.25,-8.2) 211(-54.5,0) 212(-54.75,-8.2) 213(-55,0) 214(-55.25,-8.2) 215(-55.5,0) 216(-55.75,-8.2) 217(-56,0) 218(-56.25,-8.2) 219(-56.5,0) 220(-56.75,-8.2) 221(-57,0) 222(-57.25,-8.2) 223(-57.5,0) 224(-57.75,-8.2) 225(-58,0) 226(-58.25,-8.2) 227(-58.5,0) 228(-58.75,-8.2) 229(-59,0) 230(-59.25,-8.2) 231(-59.5,0) 232(-59.75,-8.2) 233(-60,0) 234(-60.25,-8.2) 235(-60.5,0) 236(-60.75,-8.2) 237(-61,0) 238(-61.25,-8.2) 239(-61.5,0) 240(-61.75,-8.2) 241(-62,0) 242(-62.25,-8.2) 243(-62.5,0) 244(-62.75,-8.2) 245(-63,0) 246(-63.25,-8.2) 247(-63.5,0) 248(-63.75,-8.2) 249(-64,0) 250(-64.25,-8.2) 251(-64.5,0) 252(-64.75,-8.2) 253(-65,0) 254(-65.25,-8.2) 255(-65.5,0) 256(-65.75,-8.2) 257(-66,0) 258(-66.25,-8.2) 259(-66.5,0) 260(-66.75,-8.2)
  rect 3.505x4.597 smd: 261(0.425,7.9) 262(-67.175,7.9)
LED_LTW-C193DC-C_2P
  rect 0.787x0.787 smd: 1(0,0) 2(1.5,0)
LM393DGKR_VSSOP8
  oval 1.575x0.381 smd: 1(0,0) 2(0,-0.65) 3(0,-1.3) 4(0,-1.95) 5(4.35,-1.95) 6(4.35,-1.3) 7(4.35,-0.65) 8(4.35,0)
LNG2DMTR_LGA12_2X2
  oval 0.406x0.305 smd: 1(0,0) 4(0,-1.5) 7(1.602,-1.5) 10(1.602,0)
  oval 0.508x0.305 smd: 2(0.051,-0.5) 3(0.051,-1) 8(1.551,-1) 9(1.551,-0.5)
  oval 0.305x0.508 smd: 5(0.551,-1.5) 6(1.051,-1.5) 11(1.051,0) 12(0.551,0)
LP2301ALT1G_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
MAG_MLV-FY12N1R0M-O1L_2P
  rect 0.889x2.489 smd: 1(0,0) 2(2.6,0)
MAG_MMD05CZR47M_4P
  custom 0.54x0.54 smd: 1(0,0) 4(4.35,0)
  rect 0.762x0.508 smd: 2(0.699,0) 3(3.652,0)
MAG_MMD-10DZ-1R0M-X1A_2P
  rect 4.242x3.988 smd: 1(0,0) 2(8.75,0)
MAGLA_MMD-05CZ-1R0M-M7L_2P
  rect 1.905x2.794 smd: 1(0,0) 2(4.1,0)
MEC5105_WFBGA_169P
  round 0.343 smd: A1(0,0) A2(0.8,0) A3(1.6,0) A4(2.4,0) A5(3.2,0) A6(4,0) A7(4.801,0) A8(5.601,0) A9(6.401,0) A10(7.201,0) A11(8.001,0) A12(8.801,0) A13(9.601,0) B1(0,-0.8) B2(0.8,-0.8) B3(1.6,-0.8) B4(2.4,-0.8) B5(3.2,-0.8) B6(4,-0.8) B7(4.801,-0.8) B8(5.601,-0.8) B9(6.401,-0.8) B10(7.201,-0.8) B11(8.001,-0.8) B12(8.801,-0.8) B13(9.601,-0.8) C1(0,-1.6) C2(0.8,-1.6) C3(1.6,-1.6) C4(2.4,-1.6) C5(3.2,-1.6) C6(4,-1.6) C7(4.801,-1.6) C8(5.601,-1.6) C9(6.401,-1.6) C10(7.201,-1.6) C11(8.001,-1.6) C12(8.801,-1.6) C13(9.601,-1.6) D1(0,-2.4) D2(0.8,-2.4) D3(1.6,-2.4) D4(2.4,-2.4) D5(3.2,-2.4) D6(4,-2.4) D7(4.801,-2.4) D8(5.601,-2.4) D9(6.401,-2.4) D10(7.201,-2.4) D11(8.001,-2.4) D12(8.801,-2.4) D13(9.601,-2.4) E1(0,-3.2) E2(0.8,-3.2) E3(1.6,-3.2) E4(2.4,-3.2) E5(3.2,-3.2) E6(4,-3.2) E7(4.801,-3.2) E8(5.601,-3.2) E9(6.401,-3.2) E10(7.201,-3.2) E11(8.001,-3.2) E12(8.801,-3.2) E13(9.601,-3.2) F1(0,-4) F2(0.8,-4) F3(1.6,-4) F4(2.4,-4) F5(3.2,-4) F6(4,-4) F7(4.801,-4) F8(5.601,-4) F9(6.401,-4) F10(7.201,-4) F11(8.001,-4) F12(8.801,-4) F13(9.601,-4) G1(0,-4.801) G2(0.8,-4.801) G3(1.6,-4.801) G4(2.4,-4.801) G5(3.2,-4.801) G6(4,-4.801) G7(4.801,-4.801) G8(5.601,-4.801) G9(6.401,-4.801) G10(7.201,-4.801) G11(8.001,-4.801) G12(8.801,-4.801) G13(9.601,-4.801) H1(0,-5.601) H2(0.8,-5.601) H3(1.6,-5.601) H4(2.4,-5.601) H5(3.2,-5.601) H6(4,-5.601) H7(4.801,-5.601) H8(5.601,-5.601) H9(6.401,-5.601) H10(7.201,-5.601) H11(8.001,-5.601) H12(8.801,-5.601) H13(9.601,-5.601) J1(0,-6.401) J2(0.8,-6.401) J3(1.6,-6.401) J4(2.4,-6.401) J5(3.2,-6.401) J6(4,-6.401) J7(4.801,-6.401) J8(5.601,-6.401) J9(6.401,-6.401) J10(7.201,-6.401) J11(8.001,-6.401) J12(8.801,-6.401) J13(9.601,-6.401) K1(0,-7.201) K2(0.8,-7.201) K3(1.6,-7.201) K4(2.4,-7.201) K5(3.2,-7.201) K6(4,-7.201) K7(4.801,-7.201) K8(5.601,-7.201) K9(6.401,-7.201) K10(7.201,-7.201) K11(8.001,-7.201) K12(8.801,-7.201) K13(9.601,-7.201) L1(0,-8.001) L2(0.8,-8.001) L3(1.6,-8.001) L4(2.4,-8.001) L5(3.2,-8.001) L6(4,-8.001) L7(4.801,-8.001) L8(5.601,-8.001) L9(6.401,-8.001) L10(7.201,-8.001) L11(8.001,-8.001) L12(8.801,-8.001) L13(9.601,-8.001) M1(0,-8.801) M2(0.8,-8.801) M3(1.6,-8.801) M4(2.4,-8.801) M5(3.2,-8.801) M6(4,-8.801) M7(4.801,-8.801) M8(5.601,-8.801) M9(6.401,-8.801) M10(7.201,-8.801) M11(8.001,-8.801) M12(8.801,-8.801) M13(9.601,-8.801) N1(0,-9.601) N2(0.8,-9.601) N3(1.6,-9.601) N4(2.4,-9.601) N5(3.2,-9.601) N6(4,-9.601) N7(4.801,-9.601) N8(5.601,-9.601) N9(6.401,-9.601) N10(7.201,-9.601) N11(8.001,-9.601) N12(8.801,-9.601) N13(9.601,-9.601)
MMBT3904WT1G_SC70-3
  oval 0.711x0.889 smd: 1(0,0) 2(0.65,1.9) 3(-0.65,1.9)
MMBT3906H_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
MMST3904-7-F_SOT323-3
  oval 0.711x0.889 smd: 1(0,0) 2(0.65,1.9) 3(-0.65,1.9)
MURAT_BLM15AG102SN1D_2P
  rect 0.457x0.508 smd: 1(0,0) 2(0.85,0)
MURAT_BLM15BB470SN1D_2P
  rect 0.508x0.762 smd: 1(0,0) 2(0.75,0)
MURAT_BLM15GA750SN1D_2P
  rect 0.508x0.762 smd: 1(0,0) 2(0.75,0)
MURAT_BLM15PD800SN1D_2P
  rect 0.457x0.508 smd: 1(0,0) 2(0.85,0)
MURAT_BLM15PX221SN1D_2P
  rect 0.457x0.508 smd: 1(0,0) 2(0.85,0)
MURAT_BLM15PX330SN1D_2P
  rect 0.457x0.508 smd: 1(0,0) 2(0.85,0)
MURAT_BLM15PX600SN1D_2P
  rect 0.457x0.508 smd: 1(0,0) 2(0.85,0)
MURAT_BLM18KG331SN1D_2P
  rect 0.61x0.711 smd: 1(0,0) 2(1.3,0)
MX25L25645GM2I-10G_SO8
  oval 0.635x1.676 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,7.25) 6(2.54,7.25) 7(1.27,7.25) 8(0,7.25)
NCP81215MNTXG_QFN52_6X6
  oval 0.838x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 9(0,-3.2) 10(0,-3.6) 11(0,-4) 12(0,-4.4) 13(0,-4.8) 27(6.15,-4.8) 28(6.15,-4.4) 29(6.15,-4) 30(6.15,-3.6) 31(6.15,-3.2) 32(6.15,-2.8) 33(6.15,-2.4) 34(6.15,-2) 35(6.15,-1.6) 36(6.15,-1.2) 37(6.15,-0.8) 38(6.15,-0.4) 39(6.15,0)
  oval 0.203x0.838 smd: 14(0.675,-5.475) 15(1.075,-5.475) 16(1.475,-5.475) 17(1.875,-5.475) 18(2.275,-5.475) 19(2.675,-5.475) 20(3.075,-5.475) 21(3.475,-5.475) 22(3.875,-5.475) 23(4.275,-5.475) 24(4.675,-5.475) 25(5.075,-5.475) 26(5.475,-5.475) 40(5.475,0.675) 41(5.075,0.675) 42(4.675,0.675) 43(4.275,0.675) 44(3.875,0.675) 45(3.475,0.675) 46(3.075,0.675) 47(2.675,0.675) 48(2.275,0.675) 49(1.875,0.675) 50(1.475,0.675) 51(1.075,0.675) 52(0.675,0.675)
  rect 4.699x4.699 smd: 53(3.075,-2.4)
NCP302045MNTXG_PQFN33_5X5
  oval 0.305x0.711 smd: 1(0,-0.051) 2(0.5,-0.051) 3(1,-0.051) 4(1.5,-0.051) 5(2,-0.051) 6(2.5,-0.051) 7(3,-0.051) 8(3.5,-0.051)
  custom 0.32x0.32 smd: 9(3.135,1.215)
  custom 0.543x0.543 smd: 10(2.225,3.215)
  rect 3.81x0.711 smd: 11(1.75,4.851)
  rect 0.711x1.295 smd: 12(-0.701,3.65)
  oval 0.711x0.305 smd: 13(-0.701,2.65) 14(-0.701,2.15) 15(-0.701,1.65) 16(-0.701,1.15) 17(-0.701,0.65)
  rect 1.422x1.118 smd: 18(0.7,1.215)
  rect 0.584x0.356 smd: 19(0.09,2.625)
NPCT650JB2YX_QFN32_5X5
  oval 0.889x0.254 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(0,-1.5) 5(0,-2) 6(0,-2.5) 7(0,-3) 8(0,-3.5) 17(5.1,-3.5) 18(5.1,-3) 19(5.1,-2.5) 20(5.1,-2) 21(5.1,-1.5) 22(5.1,-1) 23(5.1,-0.5) 24(5.1,0)
  oval 0.254x0.889 smd: 9(0.8,-4.3) 10(1.3,-4.3) 11(1.8,-4.3) 12(2.3,-4.3) 13(2.8,-4.3) 14(3.3,-4.3) 15(3.8,-4.3) 16(4.3,-4.3) 25(4.3,0.8) 26(3.8,0.8) 27(3.3,0.8) 28(2.8,0.8) 29(2.3,0.8) 30(1.8,0.8) 31(1.3,0.8) 32(0.8,0.8)
  rect 3.505x3.505 smd: 33(2.55,-1.75)
PANAS_EXC24CQ900U_4P
  rect 0.356x0.559 smd: 1(0,0) 2(0,-1.25) 3(-0.6,-1.25) 4(-0.6,0)
PDS5100H-13_POWERDI5-3
  rect 4.851x3.353 smd: 1(0,0)
  rect 1.397x1.397 smd: 2(3.982,-0.92) 3(3.982,0.92)
PI3EQX6741STZDEX_TQFN20_4X4-S
  oval 1.041x0.254 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(0,-1.5) 5(0,-2) 11(3.95,-2) 12(3.95,-1.5) 13(3.95,-1) 14(3.95,-0.5) 15(3.95,0)
  oval 0.254x1.041 smd: 6(0.975,-2.975) 7(1.475,-2.975) 8(1.975,-2.975) 9(2.475,-2.975) 10(2.975,-2.975) 16(2.975,0.975) 17(2.475,0.975) 18(1.975,0.975) 19(1.475,0.975) 20(0.975,0.975)
  rect 2.108x2.108 smd: 21(1.975,-1)
PI3PCIE3212ZBEX_TQFN20_2P5X4P5
  oval 0.889x0.254 smd: 1(0,0) 10(4.6,0) 11(4.6,0.5) 20(0,0.5)
  oval 0.254x0.889 smd: 2(0.55,-1.05) 3(1.05,-1.05) 4(1.55,-1.05) 5(2.05,-1.05) 6(2.55,-1.05) 7(3.05,-1.05) 8(3.55,-1.05) 9(4.05,-1.05) 12(4.05,1.55) 13(3.55,1.55) 14(3.05,1.55) 15(2.55,1.55) 16(2.05,1.55) 17(1.55,1.55) 18(1.05,1.55) 19(0.55,1.55)
  rect 2.997x0.991 smd: 21(2.3,0.25)
PJDLC05C_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
PS8330BQFN48GTR2-A0_QFN48_7X7
  oval 0.254x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 25(5.5,7.1) 26(5,7.1) 27(4.5,7.1) 28(4,7.1) 29(3.5,7.1) 30(3,7.1) 31(2.5,7.1) 32(2,7.1) 33(1.5,7.1) 34(1,7.1) 35(0.5,7.1) 36(0,7.1)
  oval 0.889x0.254 smd: 13(6.3,0.8) 14(6.3,1.3) 15(6.3,1.8) 16(6.3,2.3) 17(6.3,2.8) 18(6.3,3.3) 19(6.3,3.8) 20(6.3,4.3) 21(6.3,4.8) 22(6.3,5.3) 23(6.3,5.8) 24(6.3,6.3) 37(-0.8,6.3) 38(-0.8,5.8) 39(-0.8,5.3) 40(-0.8,4.8) 41(-0.8,4.3) 42(-0.8,3.8) 43(-0.8,3.3) 44(-0.8,2.8) 45(-0.8,2.3) 46(-0.8,1.8) 47(-0.8,1.3) 48(-0.8,0.8)
  rect 3.708x3.708 smd: 49(2.75,3.55)
PS8802QFN52GTRA0_QFN52_6P5X4P5
  oval 0.94x0.254 smd: 1(0,0) 2(0,-0.35) 3(0,-0.7) 4(0,-1.05) 5(0,-1.4) 6(0,-1.75) 7(0,-2.1) 8(0,-2.45) 9(0,-2.8) 10(0,-3.15) 27(6.6,-3.15) 28(6.6,-2.8) 29(6.6,-2.45) 30(6.6,-2.1) 31(6.6,-1.75) 32(6.6,-1.4) 33(6.6,-1.05) 34(6.6,-0.7) 35(6.6,-0.35) 36(6.6,0)
  oval 0.254x0.94 smd: 11(0.675,-3.875) 12(1.025,-3.875) 13(1.375,-3.875) 14(1.725,-3.875) 15(2.075,-3.875) 16(2.425,-3.875) 17(2.775,-3.875) 18(3.125,-3.875) 19(3.475,-3.875) 20(3.825,-3.875) 21(4.175,-3.875) 22(4.525,-3.875) 23(4.875,-3.875) 24(5.225,-3.875) 25(5.575,-3.875) 26(5.925,-3.875) 37(5.925,0.725) 38(5.575,0.725) 39(5.225,0.725) 40(4.875,0.725) 41(4.525,0.725) 42(4.175,0.725) 43(3.825,0.725) 44(3.475,0.725) 45(3.125,0.725) 46(2.775,0.725) 47(2.425,0.725) 48(2.075,0.725) 49(1.725,0.725) 50(1.375,0.725) 51(1.025,0.725) 52(0.675,0.725)
  rect 5.105x3.099 smd: 53(3.3,-1.575)
Q_N_DFN56-8-5
  oval 0.61x1.27 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0)
  custom 1.105x1.105 smd: 5(1.905,3.715)
R0402_0OHM
  rect 0.508x0.559 smd: 1(0,0) 2(0.914,0)
R0603_0OHM
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
R_0201
  rect 0.381x0.356 smd: 1(0,0) 2(0.584,0)
R_0402
  rect 0.508x0.559 smd: 1(0,0) 2(0.914,0)
R_0603
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
R_0805
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
R_1206
  rect 1.016x1.651 smd: 1(0,0) 2(2.667,0)
R_1206_4P-D
  custom 0.371x0.371 smd: 1(0,0) 4(3.327,0)
  custom 0.114x0.114 smd: 2(0.775,0) 3(2.553,0)
RB520SM-30T2R_EMD2-2
  rect 0.61x0.787 smd: 1(0,0) 2(1.7,0)
RB751S40T1G_SOD523-2
  rect 0.61x0.787 smd: 1(0,0) 2(1.7,0)
RP_0804_8P4R
  oval 0.66x0.254 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(0,-1.5) 5(1.15,-1.5) 6(1.15,-1) 7(1.15,-0.5) 8(1.15,0)
RT8097ALGE_SOT23-6
  oval 0.711x0.991 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.6) 5(0.95,2.6) 6(0,2.6)
RTD2166-CG_QFN32_4X4
  oval 0.889x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 17(4.1,-2.8) 18(4.1,-2.4) 19(4.1,-2) 20(4.1,-1.6) 21(4.1,-1.2) 22(4.1,-0.8) 23(4.1,-0.4) 24(4.1,0)
  oval 0.203x0.889 smd: 9(0.65,-3.45) 10(1.05,-3.45) 11(1.45,-3.45) 12(1.85,-3.45) 13(2.25,-3.45) 14(2.65,-3.45) 15(3.05,-3.45) 16(3.45,-3.45) 25(3.45,0.65) 26(3.05,0.65) 27(2.65,0.65) 28(2.25,0.65) 29(1.85,0.65) 30(1.45,0.65) 31(1.05,0.65) 32(0.65,0.65)
  rect 2.692x2.692 smd: 33(2.05,-1.4)
RTS5242-GR_QFN32_4X4
  oval 0.889x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 17(4.1,-2.8) 18(4.1,-2.4) 19(4.1,-2) 20(4.1,-1.6) 21(4.1,-1.2) 22(4.1,-0.8) 23(4.1,-0.4) 24(4.1,0)
  oval 0.203x0.889 smd: 9(0.65,-3.45) 10(1.05,-3.45) 11(1.45,-3.45) 12(1.85,-3.45) 13(2.25,-3.45) 14(2.65,-3.45) 15(3.05,-3.45) 16(3.45,-3.45) 25(3.45,0.65) 26(3.05,0.65) 27(2.65,0.65) 28(2.25,0.65) 29(1.85,0.65) 30(1.45,0.65) 31(1.05,0.65) 32(0.65,0.65)
  rect 2.692x2.692 smd: 33(2.05,-1.4)
SAMTE_BSH-030-01-L-D-A_60P
  round 1.016 hole 1.016 unplated: (-2.81,5.53) (17.316,5.53)
  oval 0.279x2.261 smd: 1(0,0) 2(0,5.728) 3(0.5,0) 4(0.5,5.728) 5(1,0) 6(1,5.728) 7(1.5,0) 8(1.5,5.728) 9(2,0) 10(2,5.728) 11(2.5,0) 12(2.5,5.728) 13(3,0) 14(3,5.728) 15(3.5,0) 16(3.5,5.728) 17(4,0) 18(4,5.728) 19(4.5,0) 20(4.5,5.728) 21(5,0) 22(5,5.728) 23(5.5,0) 24(5.5,5.728) 25(6,0) 26(6,5.728) 27(6.5,0) 28(6.5,5.728) 29(7,0) 30(7,5.728) 31(7.5,0) 32(7.5,5.728) 33(8,0) 34(8,5.728) 35(8.5,0) 36(8.5,5.728) 37(9,0) 38(9,5.728) 39(9.5,0) 40(9.5,5.728) 41(10,0) 42(10,5.728) 43(10.5,0) 44(10.5,5.728) 45(11,0) 46(11,5.728) 47(11.5,0) 48(11.5,5.728) 49(12,0) 50(12,5.728) 51(12.5,0) 52(12.5,5.728) 53(13,0) 54(13,5.728) 55(13.5,0) 56(13.5,5.728) 57(14,0) 58(14,5.728) 59(14.5,0) 60(14.5,5.728)
SANTA_130456-831_13P-T
  round 1.295 hole 0.889: 1(0,0) 2(1.02,1.1) 3(2.04,0) 4(3.06,1.1) 5(4.08,0) 6(5.1,1.1) 7(6.12,0) 8(7.14,1.1)
  round 1.397 hole 0.991: 9(-3.395,1.1) 10(-1.105,2.6) 11(8.245,2.6) 12(9.39,1.1) 13(10.535,2.6)
  oval 1.473x3.15 hole 0.711x2.388: 14(-5.955,-6.42) 15(13.095,-6.42)
SHORTPADS
  custom 0.19x0.19 smd: 1(-0.483,0) 2(0.483,0)
SINGA_2SJ3095-059111F_6P
  oval 0.991x1.803 hole 0.61x1.397: 1(0,0) 2(-9.55,5.5) 3(0,7.8) 4(-9.55,8.4) 5(-9.55,0) 6(-9.55,2.75) 7(0,4.1)
SLGC55544CVTR_TQFN16_3X3
  oval 0.254x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 9(1.5,3.1) 10(1,3.1) 11(0.5,3.1) 12(0,3.1)
  oval 0.889x0.254 smd: 5(2.3,0.8) 6(2.3,1.3) 7(2.3,1.8) 8(2.3,2.3) 13(-0.8,2.3) 14(-0.8,1.8) 15(-0.8,1.3) 16(-0.8,0.8)
  rect 1.702x1.702 smd: 17(0.75,1.55)
SMF22A-SOD123FL-2-S
  rect 1.295x1.397 smd: 1(0,0) 2(2.9,0)
SN74AHC1G08DCKR_SC70-5
  oval 0.381x1.295 smd: 1(0,0.15) 2(0.65,0.15) 3(1.3,0.15) 4(1.3,1.89) 5(0,1.89)
SW_SKRBAAE010_4P
  rect 0.889x1.219 smd: 1(0,0) 2(3.9,0) 3(0,4.075) 4(3.9,4.075)
SW_SS3-CMFTQR9_3P
  oval 0.991x2.489 smd: 1(0,0) 2(2,0) 3(4,0)
  round 1.651 hole 0.889: 4(-0.15,-3.75) 5(6.15,-3.75)
SY6288D20AAC_SOT23-5
  oval 0.559x0.787 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.4) 5(0,2.4)
SY8057BQDC_QFN16_3X3
  oval 0.889x0.254 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(0,-1.5) 9(3.1,-1.5) 10(3.1,-1) 11(3.1,-0.5) 12(3.1,0)
  oval 0.254x0.889 smd: 5(0.8,-2.3) 6(1.3,-2.3) 7(1.8,-2.3) 8(2.3,-2.3) 13(2.3,0.8) 14(1.8,0.8) 15(1.3,0.8) 16(0.8,0.8)
  rect 1.6x1.6 smd: 17(1.55,-0.75)
SY8210AQVC_QFN19_4X3
  oval 0.787x0.254 smd: 1(0,0) 2(0,-0.45) 3(0,-0.9) 4(0,-1.35) 5(0,-1.8) 6(0,-2.25) 7(0,-2.7) 8(0,-3.15) 12(2.8,-3.15) 13(2.8,-2.7) 14(2.8,-2.25) 15(2.8,-1.8) 16(2.8,-1.35) 17(2.8,-0.9) 18(2.8,-0.45) 19(2.8,0)
  rect 0.94x2.108 smd: 9(1.07,-0.43)
  rect 0.406x2.108 smd: 10(2,-0.43)
  rect 1.295x2.007 smd: 11(1.25,-2.78)
SY8286RAC_QFN20_3X3
  oval 0.889x0.254 smd: 1(0,0) 2(0,-0.45) 3(0,-0.9) 4(0,-1.35) 5(0,-1.8) 11(3.1,-1.8) 12(3.1,-1.35) 13(3.1,-0.9) 14(3.1,-0.45) 15(3.1,0)
  oval 0.254x0.889 smd: 6(0.65,-2.45) 7(1.1,-2.45) 8(1.55,-2.45) 9(2,-2.45) 10(2.45,-2.45) 16(2.45,0.65) 17(2,0.65) 18(1.55,0.65) 19(1.1,0.65) 20(0.65,0.65)
  rect 0.991x0.991 smd: 21(1.55,-0.9)
SY8288BRAC_QFN20_3X3
  oval 0.889x0.254 smd: 1(0,0) 2(0,-0.45) 3(0,-0.9) 4(0,-1.35) 5(0,-1.8) 11(3.1,-1.8) 12(3.1,-1.35) 13(3.1,-0.9) 14(3.1,-0.45) 15(3.1,0)
  oval 0.254x0.889 smd: 6(0.65,-2.45) 7(1.1,-2.45) 8(1.55,-2.45) 9(2,-2.45) 10(2.45,-2.45) 16(2.45,0.65) 17(2,0.65) 18(1.55,0.65) 19(1.1,0.65) 20(0.65,0.65)
  rect 0.991x0.991 smd: 21(1.55,-0.9)
SY8288CRAC_QFN20_3X3
  oval 0.889x0.254 smd: 1(0,0) 2(0,-0.45) 3(0,-0.9) 4(0,-1.35) 5(0,-1.8) 11(3.1,-1.8) 12(3.1,-1.35) 13(3.1,-0.9) 14(3.1,-0.45) 15(3.1,0)
  oval 0.254x0.889 smd: 6(0.65,-2.45) 7(1.1,-2.45) 8(1.55,-2.45) 9(2,-2.45) 10(2.45,-2.45) 16(2.45,0.65) 17(2,0.65) 18(1.55,0.65) 19(1.1,0.65) 20(0.65,0.65)
  rect 0.991x0.991 smd: 21(1.55,-0.9)
T-SOL_5-991503004000-6_8P-T
  round 0.787 hole 0.787 unplated: (-1.39,-11.52)
  round 1.092 hole 1.092 unplated: (10.31,0.48)
  oval 0.889x1.092 smd: 1(0,0) 2(2.54,0) 3(5.08,0) 4(7.62,0) 5(0,-13.48) 6(2.54,-13.48) 7(5.08,-13.48) 8(7.62,-13.48)
  rect 0.889x0.813 smd: 9(-2.94,3.44)
  rect 1.245x1.803 smd: 10(-3.39,-13.33)
  rect 1.245x1.397 smd: 11(-3.39,-5.33)
  rect 1.295x1.016 smd: 12(-0.715,3.56) 13(9.535,3.56)
  rect 1.041x1.397 smd: 14(12.105,0.87)
  rect 0.94x1.397 smd: 15(12.555,-6.62)
  rect 1.219x1.143 smd: 16(10.8,-13.65)
T-SOL_156-2000302608_19P_NR
  round 0.889 hole 0.889 unplated: (-7.075,-28.925) (13.425,-1.825)
  oval 0.787x1.651 smd: 1(0,0) 2(1.4,0) 3(2.8,0) 4(4.2,0) 5(7.1,0) 6(9.9,0) 7(11.3,0) 8(12.7,0) 9(-1.4,0) 18(8.5,0) 19(14.1,0)
  oval 1.346x0.787 smd: 10(-9.2,-22.975) 11(-9.2,-24.075) 12(-9.2,-25.175) 13(-9.2,-26.275) 14(20.05,-26.275) 15(20.05,-25.175) 16(20.05,-24.075) 17(20.05,-22.975)
  rect 1.397x1.448 smd: 20(17.2,0.6) 21(5.65,0.6) 22(-6.35,0.6)
  rect 1.448x1.397 smd: 23(19.525,-6.575) 24(-8.675,-6.575) 25(19.525,-20.675) 26(-8.675,-18.825)
TAI-T_HCB2012KF-121T50_2P
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
TAIMA_IH-160_24P
  oval 0.61x2.362 smd: 1(0,0) 2(1,0) 3(2,0) 4(3,0) 5(4,0) 6(5,0) 7(6,0) 8(7,0) 9(8,0) 10(9,0) 11(10,0) 12(11,0) 13(11,8.35) 14(10,8.35) 15(9,8.35) 16(8,8.35) 17(7,8.35) 18(6,8.35) 19(5,8.35) 20(4,8.35) 21(3,8.35) 22(2,8.35) 23(1,8.35) 24(0,8.35)
TAIYO_BRC2012T4R7MD_2P
  rect 0.61x1.448 smd: 1(0,0) 2(1.6,0)
TAIYO_FBMJ4516HS720NT_2P
  rect 1.549x1.854 smd: 1(0,0) 2(3.95,0)
TAIYO_MCF12102G900-T_4P
  rect 0.508x0.305 smd: 1(0,0) 2(0,-0.55) 3(1.25,-0.55) 4(1.25,0)
TC7SH08FU_SSOP5
  oval 0.406x0.787 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0,1.9)
TPC12
  round 0.305 smd: 1(0,0)
TPS22961DNYR_WSON8
  oval 0.305x0.508 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(1.95,2.7)
  oval 1.6x0.508 smd: 6(0.65,2.7)
  rect 2.388x1.6 smd: 7(0.975,1.35)
TPS65982_BGA_96P
  round 0.254 smd: A1(0,0) A2(0.5,0) A3(1,0) A4(1.5,0) A5(2.001,0) A6(2.501,0) A7(3.001,0) A8(3.501,0) A9(4.001,0) A10(4.501,0) A11(5.001,0) B1(0,-0.5) B2(0.5,-0.5) B3(1,-0.5) B4(1.5,-0.5) B5(2.001,-0.5) B6(2.501,-0.5) B7(3.001,-0.5) B8(3.501,-0.5) B9(4.001,-0.5) B10(4.501,-0.5) B11(5.001,-0.5) C1(0,-1) C2(0.5,-1) C10(4.501,-1) C11(5.001,-1) D1(0,-1.5) D2(0.5,-1.5) D5(2.001,-1.5) D6(2.501,-1.5) D7(3.001,-1.5) D8(3.501,-1.5) D10(4.501,-1.5) D11(5.001,-1.5) E1(0,-2.001) E2(0.5,-2.001) E4(1.5,-2.001) E5(2.001,-2.001) E6(2.501,-2.001) E7(3.001,-2.001) E8(3.501,-2.001) E10(4.501,-2.001) E11(5.001,-2.001) F1(0,-2.501) F2(0.5,-2.501) F4(1.5,-2.501) F5(2.001,-2.501) F6(2.501,-2.501) F7(3.001,-2.501) F8(3.501,-2.501) F10(4.501,-2.501) F11(5.001,-2.501) G1(0,-3.001) G2(0.5,-3.001) G4(1.5,-3.001) G5(2.001,-3.001) G6(2.501,-3.001) G7(3.001,-3.001) G8(3.501,-3.001) G10(4.501,-3.001) G11(5.001,-3.001) H1(0,-3.501) H2(0.5,-3.501) H4(1.5,-3.501) H5(2.001,-3.501) H6(2.501,-3.501) H7(3.001,-3.501) H8(3.501,-3.501) H10(4.501,-3.501) H11(5.001,-3.501) J1(0,-4.001) J2(0.5,-4.001) J10(4.501,-4.001) J11(5.001,-4.001) K1(0,-4.501) K2(0.5,-4.501) K3(1,-4.501) K4(1.5,-4.501) K5(2.001,-4.501) K6(2.501,-4.501) K7(3.001,-4.501) K8(3.501,-4.501) K9(4.001,-4.501) K10(4.501,-4.501) K11(5.001,-4.501) L1(0,-5.001) L2(0.5,-5.001) L3(1,-5.001) L4(1.5,-5.001) L5(2.001,-5.001) L6(2.501,-5.001) L7(3.001,-5.001) L8(3.501,-5.001) L9(4.001,-5.001) L10(4.501,-5.001) L11(5.001,-5.001)
TVNST52302AB0_SOT523-3
  oval 0.508x0.559 smd: 1(0,0) 2(-0.5,-1.4) 3(0.5,-1.4)
W25Q80DVSSIG_SO8
  oval 0.635x1.676 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,7.25) 6(2.54,7.25) 7(1.27,7.25) 8(0,7.25)
W25Q256FVEIQ_WSON8_8X6
  oval 0.66x0.991 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,8) 6(2.54,8) 7(1.27,8) 8(0,8)
  rect 4.293x3.404 smd: 9(1.905,4)
WGI219LM-SLKJ2-A0_QFN48_6X6
  oval 0.889x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 9(0,-3.2) 10(0,-3.6) 11(0,-4) 12(0,-4.4) 25(6.1,-4.4) 26(6.1,-4) 27(6.1,-3.6) 28(6.1,-3.2) 29(6.1,-2.8) 30(6.1,-2.4) 31(6.1,-2) 32(6.1,-1.6) 33(6.1,-1.2) 34(6.1,-0.8) 35(6.1,-0.4) 36(6.1,0)
  oval 0.203x0.889 smd: 13(0.85,-5.25) 14(1.25,-5.25) 15(1.65,-5.25) 16(2.05,-5.25) 17(2.45,-5.25) 18(2.85,-5.25) 19(3.25,-5.25) 20(3.65,-5.25) 21(4.05,-5.25) 22(4.45,-5.25) 23(4.85,-5.25) 24(5.25,-5.25) 37(5.25,0.85) 38(4.85,0.85) 39(4.45,0.85) 40(4.05,0.85) 41(3.65,0.85) 42(3.25,0.85) 43(2.85,0.85) 44(2.45,0.85) 45(2.05,0.85) 46(1.65,0.85) 47(1.25,0.85) 48(0.85,0.85)
  rect 2.997x2.997 smd: 49(3.05,-2.2)
Y_7M24000055_4P
  rect 1.397x1.194 smd: 1(0,0) 2(2.2,0) 3(2.2,1.7) 4(0,1.7)
Y_9H03200042_2P
  rect 0.991x1.803 smd: 1(0,0) 2(2.5,0)
Y_X1A000141000200_2P
  rect 0.991x1.803 smd: 1(0,0) 2(2.5,0)
Y_XRCGB25M000F2P18R0_4P
  rect 0.762x0.711 smd: 1(0,0) 2(1.35,0) 3(1.35,1) 4(0,1)

## Nets
0.6V_DDR_VTT_ON: PR210.2 RD19.2 UD1.4
1.2VSP: PC509.1 PC511.1 PJP504.1 PR512.1 PU502.1
1.8V_1.0V_PWRGD: PR2011.2 PR2012.2 UE1.L7
2.5VSP: PC515.1 PC516.1 PJP506.1 PR515.1 PU503.1
3.3V_CAM_EN#: RH602.1 RZ1380.1 UH1.BE41
3.3V_CAM_EN#_R: CZ1200.1 QZ1.2 RZ1380.2
3.3V_TS_EN: RE547.1 RV323.1 UE1.J7
3.3V_TS_EN_R: CV1638.1 QV7.2 RV323.2 RV324.2 RV326.2
3.3V_WWAN_EN: RZ40.2 UE1.C6 UZ2.3
3V5V_EN: PC128.1 PD100.1 PR114.2 PR116.1 PU100.12 PU102.12
3V_FB: PC113.1 PU100.13
3V_SN: PC112.1 PR106.2
3V_VIN: PC100.1 PC103.1 PC104.1 PC105.1 PC2048.1 PC2049.1 PJP100.2 PU100.2 PU100.3 PU100.4 PU100.5
5V_FB: PC127.1 PU102.13
5V_SN: PC125.1 PR112.2
5V_VIN: PC115.1 PC116.1 PC117.1 PC118.1 PJP101.2 PU102.2 PU102.3 PU102.4 PU102.5
+0.6V_DDR_VTT: CD22.1 CD23.1 CD24.1 CD54.1 CD55.1 CD56.1 JDIMM1.258 JDIMM2.258 PJP201.2
+0.6VSP: PC219.1 PJP201.1 PU200.5 PU200.6
