# Allegro board LA-F711P R05-0112.brd (continued)
## Nets (continued)
N27182711: PC1721.1 PR1740.2
N27933518: PC1917.2 PU1901.7
N27933520: PR1905.1 PU1901.5
N27933540: PC1916.2 PR1904.2 PU1901.3
N27933602: PC1917.1 PR1905.2
N27933660: PC1919.2 PR1907.1
N28152235: PC1713.2 PC1719.2 PR1730.2 PR1735.1
N28152401: PC1730.2 PR1753.2 PU1700.15
N28152437: PC1718.2 PR1732.2 PU1700.3
N28152465: PC1722.1 PR1733.1 PU1700.36
N28152580: PC1700.1 PC1703.2 PR1708.2 PR1709.1
N28152729: PC1703.1 PR1710.2 PR1711.1 PR1771.1
N28152784: PC1732.1 PR1754.2 PU1700.16
N28152844: PH1704.1 PR1768.2 PR1770.1
N28152958: PH1702.2 PR1744.2 PR1748.1
N28153073: PH1700.2 PR1701.1
N28153459: PH1703.1 PR1767.2 PR1769.1
N28153589: PR1724.1 PU1700.43
N28153954: PC1716.1 PR1737.2
N28154016: PC1711.1 PC1712.1 PR1726.2 PR1727.1
N28154283: PH1701.2 PR1743.2 PR1746.1
N28180064: PC1709.1 PR1720.2
N28185893: PC1720.1 PR1738.2
N28185971: PC1715.1 PR1731.2
N29227301: PC1707.1 PR1771.2
N30206818: PC1203.2 PQ1202.4 PQ1203.1 PR1207.2 PR1213.1
N30206910: PQ1203.2 PR1202.2 PR1209.1
N30207371: PC1202.2 PQ1213.4 PQ1215.1 PR1205.2 PR1212.1
N30393649: PC307.2 PR306.1 PR313.2 PR314.1
N30393661: PR311.2 PR315.1 PR316.1
N30393852: PC307.1 PR2008.1
N35551558: PC1210.1 PQ1206.4 PR1228.2 PR1229.1
N35551572: PC1214.1 PQ1209.5 PR1243.2
N35551576: PQ1209.2 PQ1209.3 PR1236.1
N35551581: PQ1209.6 PR1229.2
N35551584: PC1213.1 PD1205.2 PR1238.2 PR1240.2 PR1243.1 PU1201.7
N35551592: PC1212.1 PR1237.2 PR1247.1 PU1201.6
N35551616: PQ1212.2 PR1248.1 PR1249.1 PR1250.1
N35551655: PC1205.1 PR1208.2 PR1217.1 PU1201.2
N35551713: PQ1201.6 PR1212.2
N35551806: PQ1204.3 PR1209.2
N35551822: PQ1201.3 PR1213.2
N36255106: PQ1201.5 PR1220.1
N36423841: PC102.1 PR100.2
N36423890: PC114.1 PR111.2
N37051879: PC515.2 PR515.2 PR516.1 PU503.3
N37229012: PC119.1 PU102.16 PU102.17
N37327097: PD905.3 PR939.2 PR950.1
N37327116: PR946.1 PU903.4
N37327193: PR942.2 PU903.2
N37327195: PD905.2 PR941.2
N37327368: PR936.1 PR948.1 PU901.30
N37327475: PR949.1 PU901.29
N37345559: PR933.2 PR951.2 PU901.26
N37346094: PQ1210.5 PR1245.2
N37346120: PQ1211.5 PR1233.1 PR1242.2
N37346130: PQ1211.2 PR1235.1 PR1257.2
N37346160: PQ1207.6 PQ1211.4 PR1230.1 PR1258.2
N37346172: PQ1207.2 PQ1207.3 PR1232.1
N37346182: PQ1207.5 PR1241.2
N37346205: PQ1208.6 PQ1211.1 PR1234.1 PR1261.2
N37346217: PQ1208.2 PQ1208.3 PR1259.1
N37346239: PQ1208.5 PR1244.2 PR1260.2 PR1261.1
N37359040: PR414.2 PR415.2 PU401.5
N37410469: PC111.1 PR104.1 PR105.1 PU100.16 PU100.17
N39381572: PC113.2 PR108.1
N39381889: PC127.2 PR117.1
N42077965: PC1813.2 PU1800.7
N42077969: PR1801.1 PU1800.5
N42077993: PC1812.2 PR1800.2 PU1800.3
N42078041: PC1823.2 PU1801.7
N42078055: PR1805.1 PU1801.5
N42078421: PC1813.1 PR1801.2
N42078543: PC1815.2 PR1803.1
N42078657: PC1823.1 PR1805.2
N42078671: PC1822.2 PR1804.2 PU1801.3
N42078715: PC1825.2 PR1807.1
N42079748: PR1901.1 PU1900.5
N42079752: PC1907.2 PU1900.7
N42079902: PC1907.1 PR1901.2
N42079910: PC1900.2 PR1900.2 PU1900.3
N42079960: PC1909.2 PR1903.1
N52218840: PR1745.2 PU1700.27
N119328643: PC938.1 PR930.1 PR931.2 PU901.25
N131988242: PR920.2 PU901.21
N131988252: PR922.2 PU901.22
N132000604: PC934.1 PR921.2

Pads without a net: DV6 3; FD1 1; FD2 1; FD3 1; FD4 1; JAPS1 16 17 18; JDIMM1 87 88 91 92 95 97 100 101 104 105; JDIMM2 87 88 91 92 95 97 100 101 104 105; JEDP1 16 20; JHDMI1 14; JIR1 4; JKBTP1 10 17; JNGFF1 6 8 12 16 20 66 68 70; JNGFF2 20 22 24 28 40 42 44 46 48 56 59 61 63 65 68; JNGFF3 6 8 20 22 24 26 28 30 32 34 36 40 42 44 46 48 56 58 67; JSATA1 8 20; JSIM1 4 6 8; JSPI1 17; JUSH1 2 17; PBATT1 11 12; PD2 2; PRP1 4 5; PU100 10 15; PU102 10; PU200 18 19; PU301 10 12; PU401 4; PU502 2 6 7; PU503 2 6 7; PU901 13; PU1800 6 13 17 19; PU1801 6 13 17 19; PU1900 6 13 17 19; PU1901 6 13 17 19; PU2000 6 13 17 19; PU2001 6 13 17 19; QL2 3 4 5; QZ7 1 2 6; RE525 2; RH99 2; RPE10 3; RT75 2; RT87 1; RT88 1; RT110 1; RT306 1; RT307 1; RT339 2; RV89 1; RZ65 1; RZ326 2; UA1 4 11 12 15 23 24 48; UC1 A11 A13 A15 A17 A19 A21 A23 A25 A29 AD2 AD4 AE1 AE5 AE9 AE10 AE11 AF10 AJ10 AJ11 AK3 AL1 AL2 AL3 AM10 AM11 AT3 AT5 AT7 AT11 AW7 AW8 AW9 AW10 AW11 AY1 AY2 AY3 AY4 AY5 AY7 AY8 AY9 AY10 AY11 B10 B11 B12 B13 B14 B15 B16 B17 B18 B19 B20 B21 B22 B23 B24 B25 B28 B29 BA1 BA2 BA3 BA4 BA5 BM31 BT30 C10 C12 C14 C16 C18 C20 C22 C24 C28 D11 D13 D15 D17 D19 D21 D23 D25 D27 E10 E11 E12 E13 E14 E15 E16 E17 E18 E19 E20 E21 E22 E23 E24 E25 E27 F10 F12 F14 F16 F18 F20 F22 F24; UD1 1; UE1 B8 B9; UE4 1; UE6 1; UH1 A17 A25 A44 AA1 AA45 AB48 AC6 AC7 AC9 AC11 AC14 AC15 AC39 AC41 AC43 AC44 AD47 AD48 AE9 AE11 AE14 AE15 AE39 AE41 AE43 AE44 AE48 AF47 AF48 AG45 AH46 AH47 AH48 AJ46 AJ47 AL15 AM7 AN4 AN13 AN37 AN40 AN46 AP2 AP3 AP29 AP41 AP47 AP48 AR13 AR48 AT10 AT49 AU46 AU47 AV7 AV13 AV16 AV18 AW3 AW18 B17 B18 B19 B24 B25 B26 B27 B38 B41 B44 BA33 BA36 BC17 BD12 BD17 BD34 BD38 BE9 BE12 BE18 BE19 BE29 BE33 BE34 BF8 BF9 BF10 BF18 BF19 BF33 BF36 C16 C17 C18 C19 C20 C24 C26 C27 C38 C39 C41 C44 C45 C46 C47 D20 D29 D39 D43 D46 E28 F14 F16 F24 F26 F46 G1 G2 G14 G17 G24 G26 G45 G46 G47 G48 G49 H47 H48 J18 K18 K29 L2 L3 L4 L26 L41 L46 L47 L48 M1 M26 M29 M40 M44 M45 N2 N3 N18 N42 N47 N48 P21 P24 P47 P48 R18 R21 R24 R35 R37 R44 R46 R47 T1 T2 T43 T45 T46 T47 T48 U2 U3 U40 U41 U47 U48 V2 V3 V47 V48 W3 W4 W6 W7 W43 W44 W46 W47 Y2 Y40 Y41 Y46 Y47 Y48; UI3 9 15; UR1 31; UT5 C1; UT7 4; UT9 4 5; UV6 13 27 28 31; UV9 8 13 14 15 16 17 21 37 43 46; UV24 3; UZ12 2 4 5 6 7 10 11 12 15 25 26 28 30 31; UZ61 1

## Via types
v1: diameter 0.305, hole 0.152, TOP to BOTTOM, 897 vias
v2: diameter 0.457, hole 0.203, TOP to BOTTOM, 7710 vias
v3: diameter 0.406, hole 0.203, TOP to BOTTOM, 185 vias
v4: diameter 0.508, hole 0.254, TOP to BOTTOM, 66 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
0.6V_DDR_VTT_ON: length 219.2
  TOP w0.102: v1(45,12.19) v2(44.37,12.19) 44,11.82 PR210.2
  TOP w0.104: v2(155.67,12.55) 155.67,12.75 155.53,12.89 155.53,14.06 155.1,14.49 RD19.2
  IN3 w0.102: v2(155.67,12.55) 154.66,11.53 138.52,11.53 137.99,11 110.37,11 110.32,11.05 109.18,12.19 106.4,12.19 105.43,13.16 99.46,13.16 98.78,13.84 95.09,13.84 94.59,13.33 89.07,13.33 87.96,12.22 87.09,12.22 86.58,11.71 83.44,11.71 82.66,10.94 69.63,10.94 68.69,10 66.18,10 64.87,11.3 61.47,11.3 61.33,11.44 51.16,11.44 49.47,13.13 45.63,13.13 44.69,12.19 v2(44.37,12.19) 43.4,13.16 26.31,13.16 24.69,14.78 24.69,27.09 30.12,32.52 30.12,42.49 30.78,43.15 30.78,47.76 v2(33.75,50.74)
  BOTTOM w0.102: v2(33.75,50.74) 34.97,50.74 37,52.77 40.86,52.77 41.82,53.72 42.31,53.72 42.69,53.34 43.11,53.34 43.35,53.58 43.35,54.01 43.65,54.3 45.68,56.34 50.26,56.34 53.61,59.69 55.84,59.69 57.62,57.91 63.65,57.91 64.61,58.87 UD1.4
1.2VSP:
  vias: v3(147.62,131.41)
1.8V_1.0V_PWRGD: length 205.5
  TOP w0.102: v2(317.55,6.12) 317.04,6.63 316.27,6.63 316.03,6.86 316.03,19.16 316.45,19.58 v1(316.45,20.22) v2(316.45,25.35)
  TOP w0.104: UE1.L7 v2(318.12,31.95)
  IN1 w0.099: v2(161.42,10.8) 161.78,11.15 170.87,11.15 171.48,11.76 176.65,11.76 177.85,12.96 180.72,12.96 181.92,14.16 183.68,14.16 183.89,13.95 183.89,11.76 186.02,9.63 188.46,9.63 192.65,5.44 195.7,5.44 196.28,4.86 198.51,4.86 199.08,5.44 208.06,5.44 211.28,2.22 212.52,2.22 213.1,2.8 215.16,2.8 216.64,1.32 266.79,1.32 270.83,5.36 275.58,5.36 276.91,4.04 276.91,2.44 278.12,1.22 290.88,1.22 317.02,1.22 318.02,2.22 318.02,5.65 v2(317.55,6.12) ; v2(318.12,31.95) 317.89,31.95 316.57,30.63 316.57,25.46 v2(316.45,25.35)
  BOTTOM w0.102: PR2011.2 PR2012.2 161.42,9.65 v2(161.42,10.8)
2.5VSP: length 1.4
  BOTTOM w0.102: PC516.1 74.64,10.62 v1(74.47,10.79)
3.3V_CAM_EN#: length 193
  TOP w0.102: v2(224.73,51.75) 224.73,51.14 v1(227.32,48.55) 228.58,47.28 228.58,45.61 233.41,40.78 233.41,30.61 234.27,29.75 234.27,25.24 233.94,24.9 233.94,22.58 v2(234.01,22.51)
  IN2 w0.102: v2(221.83,22.62) 221.88,22.67 225.61,22.67 226.13,23.18 229,23.18 229.76,23.95 232.56,23.95 v2(234.01,22.51) ; v2(178.69,81.08) 178.69,79.79 180.56,77.91 180.56,73.16 179.51,72.11 179.51,57.19 181.37,55.33 184.69,55.33 189,59.64 213.01,59.64 217.72,54.93 222.26,54.93 224.73,52.46 v2(224.73,51.75)
  BOTTOM w0.089: UH1.BE41 214.33,24 214.56,24.24 214.92,24.24 215.01,24.32 215.78,24.32 215.97,24.13 218.02,24.13 218.3,23.85 220,23.85 220.22,23.63
  BOTTOM w0.102: RH602.1 222.51,21.93 v2(221.83,22.62) 221.3,23.14 220.71,23.14 220.22,23.63 ; RZ1380.1 127.25,98.45 128.11,99.31 154.21,99.31 170.22,83.31 176.46,83.31 v2(178.69,81.08)
3.3V_CAM_EN#_R: length 4.8
  BOTTOM w0.102: v1(127.44,99.36) RZ1380.2 125.46,99.36 CZ1200.1 124.77,99.35 QZ1.2
3.3V_TS_EN: length 270.1
  TOP w0.102: v2(315.81,25.31) 315.76,25.26 315.76,24.7 RE547.1 ; v2(143.74,98.72) 143.24,98.22 143.24,97.57 140.61,94.94 v1(136.33,94.94) 130.95,94.94 130.44,95.45 RV323.1
  TOP w0.104: v2(318.12,33.49) 318.12,33.55 UE1.J7
  IN1 w0.099: v2(315.81,25.31) 315.74,25.38 315.74,26.73 316.17,27.17 316.17,30.88 316.9,31.61 316.9,32.07 317.16,32.33 317.44,32.33 317.7,32.59 317.7,33.04 318.12,33.46 v2(318.12,33.49)
  IN2 w0.102: v2(143.74,98.72) 146.61,101.59 149.78,101.59 152.51,104.32 158.65,104.32 161.21,101.76 163.31,101.76 177.48,87.59 177.48,79.91 179.99,77.4 179.99,74.13 178.72,72.86 178.72,57.1 180.95,54.87 184.88,54.87 188.69,58.68 192.42,58.68 196.89,54.2 197.47,54.2 198.5,55.23 207.32,55.23 212.96,49.59 212.96,46.87 214.98,44.84 214.98,43.61 215.73,42.86 216.83,42.86 217.07,42.62 217.39,42.62 217.81,42.19 217.81,39.12 218.5,38.43 220.49,38.43 221.56,39.5 225.05,39.5 226.01,38.54 235.39,38.54 237.08,36.85 241.74,36.85 243.89,34.71 251.8,34.71 252.12,34.39 267.92,34.39 269.76,32.55 276.53,32.55 278.41,34.43 278.41,37.93 278.93,38.44 282.17,38.44 282.32,38.29 283.32,38.29 283.61,38.58 288.9,38.58 289.29,38.19 297.21,38.19 298.2,37.2 298.2,35.99 298.8,35.39 301.01,35.39 301.67,36.05 306.71,36.05 308.54,37.89 311.51,37.89 313.98,35.42 317.31,35.42 317.74,34.99 317.74,33.93 318.12,33.55 v2(318.12,33.49)
3.3V_TS_EN_R: length 8.8
  TOP w0.102: RV326.2 126.1,96.39 126.73,95.76 129.05,95.76 QV7.2 129.79,95.83 130.42,96.46 RV323.2 RV324.2 v1(132.41,96.46) 132.44,96.49 132.44,97.18 132.25,97.37 CV1638.1
3.3V_WWAN_EN: length 39
  TOP w0.102: UE1.C6 v2(318.12,39.15) ; v2(321.23,61.73) 320.68,62.28 319.93,62.28 318.05,64.16 v1(318.05,66.97) 318.05,69.09 317.59,69.55 317.11,69.55 317.03,69.64 317.03,69.98 316.93,70.07 RZ40.2 316.1,70.07 316.06,70.11 UZ2.3
  IN3 w0.102: v2(318.12,39.15) 318.12,41.97 320.32,44.17 320.32,46.59 322.39,48.67 322.39,50.5 323.55,51.65 323.55,55.35 322.35,56.55 322.35,60.61 v2(321.23,61.73)
3V5V_EN: length 272.5
  TOP w0.102: v2(181.61,24.93) 181.83,25.16 182.12,25.16 182.46,25.5 182.46,26.58 183.22,27.34 183.22,29.84 183.83,30.45 183.83,33.16 176.45,40.54 173.94,40.54 170,44.48 170,53.13 168.53,54.61 168.53,61.67 169.86,63 169.86,73.92 167.05,76.73 167.05,94.01 167.94,94.9 v1(167.94,101.98) v2(167.94,108.48)
  TOP w0.254: PU102.12 121.62,132.69 v2(121.43,132.87)
  IN1 w0.099: v2(118.41,129.53) 118.67,129.28 118.67,129.02 119.58,128.1 119.58,127 119.92,126.66 121.3,126.66 123.67,124.29 126.27,124.29 127.9,122.66 152.72,122.66 166.89,108.48 v2(167.94,108.48)
  IN2 w0.102: v2(87.3,9.88) 87.3,10.69 88.82,12.22 97.1,12.22 97.68,12.8 109.22,12.8 110.08,11.94 133.95,11.94 134.51,11.39 136.74,11.39 136.97,11.16 138.4,11.16 138.89,11.66 157.55,11.66 159.69,13.79 169.6,13.79 169.78,13.97 174.61,13.97 175.15,14.5 176.5,14.5 176.73,14.73 179.98,14.73 181.53,16.28 181.53,24.86 v2(181.61,24.93)
  IN3 w0.122: v2(121.43,132.87) 121.41,132.84 121.41,131.4 120.11,130.1 118.97,130.1 v2(118.41,129.53)
  BOTTOM w0.102: PD100.1 121.14,132.58 v2(121.43,132.87) ; v2(118.41,129.53) 118.59,129.36 PC128.1 PR116.1 PR114.2
  BOTTOM w0.203: v2(87.3,9.88) 87.56,9.61 PU100.12
3V_FB: length 1.8
  BOTTOM w0.254: PC113.1 87.83,9.97 88.01,9.78 PU100.13
3V_SN: length 1.9
  TOP w0.102: PR106.2 88.95,3.12 v1(88.76,2.93)
3V_VIN:
  vias: v1(86.37,4.29) v2(83.41,4.75) v2(84.21,4.31) v2(84.82,4.31)
5V_FB: length 3.6
  TOP w0.102: v3(119.3,131.47) 119.96,132.13 120.35,132.13 PC127.1
  TOP w0.254: PC127.1 121.11,132.24 PU102.13
5V_SN: length 0.6
  BOTTOM w0.102: 122.13,128.78 v1(121.57,128.78)
5V_VIN:
  vias: v2(126.73,133.41) v2(127.3,133.43) v2(127.91,133.44) v3(130.72,131.57)
+0.6V_DDR_VTT: length 58.3
  IN2 w1.016: 159.18,12.09 157.96,10.87 145,10.87 143.4,9.27 133.32,9.27 132.15,10.44 110.51,10.44 109.85,11.1 109.37,11.58 107.84,11.58 ; 171.98,13.11 170.33,13.11
  BOTTOM w0.305: v2(94.76,15.57) 94.72,15.53 94.72,15.27 94.7,15.24 94.7,15.16 94.47,14.93 JDIMM1.258 ; v2(175.94,15.52) 175.47,15.05 JDIMM2.258
  vias: v2(46.07,12.34) v2(46.67,12.36) v2(47.26,12.35) v2(47.39,11.76) v2(92.37,12.88) v2(93.21,12.9) v2(104.69,12.32) v2(105.3,12.34) v2(178.14,13.61) v2(178.74,13.61) v3(178.65,14.17)
+0.6VSP: length 1.1
  TOP w0.102: v2(47.32,9.7) v3(47.32,8.57)
  vias: v2(46.73,9.83)
+0.9V_LAN: length 11.7
  TOP w0.102: v3(332.79,85.47) v2(330.78,85.47)
  TOP w0.203: UL1.8 325.22,86.9 v2(325.32,86.99) ; v2(325.28,88.36) 325.02,88.1 UL1.11 ; v2(322.33,90.19) 322.25,90.12 UL1.16 ; v2(319.13,82.39) 319.05,82.47 UL1.37 ; v2(321.53,82.4) 321.45,82.47 UL1.43 ; UL1.22 319.85,90.34 v2(319.93,90.42) ; v2(320.33,82.39) 320.25,82.47 UL1.40
  BOTTOM w0.381: CL11.1 325.22,86.9 v2(325.32,86.99) ; CL9.1 325.03,88.11 v2(325.28,88.36) ; CL8.1 320.01,90.33 v2(319.93,90.42) ; CL10.1 320.33,82.39 v2(320.33,82.39)
  vias: v2(323.49,80.21) v2(324.1,80.21) v2(330.78,86.66) v2(330.78,86.08)
+1.0V_ALW_PCH: length 48.9
  TOP w0.508: RH255.1 222.73,19.87 222.06,19.2 222.06,18.5 v2(222.08,18.48)
  IN2 w0.508: v2(204.75,18.83) 205.6,18.83 206.82,17.6 208.23,17.6 209.32,18.7 212.57,18.7 214.09,17.18 220.78,17.18 v2(222.08,18.48)
  IN3 w0.508: v2(204.75,18.83) 204.75,19.13 204.15,19.72 203.36,19.72 202.24,20.84 202.24,21.91 200.57,23.58 200.06,23.58 199.46,24.18 199.46,27.13 199.68,27.35 199.68,28.06 199.17,28.57 198.74,28.57 198.37,28.94 198.37,31.7 200.59,33.92 200.59,34.57 201.13,35.1 202.57,35.1 204.11,36.64 v2(204.11,38.42) 204.11,39.1 v2(204.1,39.12)
  vias: v2(188.34,49.34) v2(188.95,49.33) v2(195.21,19.53) v2(195.21,18.89) v2(195.21,18.26) v2(195.84,19.53) v2(195.84,18.89) v2(195.84,18.26) v2(196.48,19.53) v2(196.48,18.89) v2(196.48,18.26) v2(201.11,44.18) v2(201.77,44.17) v2(202.97,18.83) v3(193.01,34.99)
+1.0V_AMPHYPLL: length 1.5
  BOTTOM w0.102: v3(191.55,15.99) 191.8,16.24 CH267.1
+1.0V_AZPLL: length 8.2
  TOP w0.508: RH241.2 198.05,43.04 CH46.1 CH32.1 195.39,43.04 v3(193.99,44.43) 193.39,45.03 v2(193.27,45.03)
  BOTTOM w0.254: UH1.E1 UH1.D1 194.12,43.79 193.3,44.61 193.3,45 v2(193.27,45.03)
+1.0V_BCLKPLL2: length 4.3
  BOTTOM w0.102: LC2.1 186.71,46.7 186.13,47.28 CC330.1 186.13,48.28 186.74,48.89 RH259.2 v1(186.74,50.37)
+1.0V_BCLKPLL2_R: length 2.7
  BOTTOM w0.102: LC2.2 v1(185.72,45.95)
  BOTTOM w0.254: UH1.B3 UH1.B2 UH1.B1 192.81,43.86
+1.0V_CLPLLEBB: length 0.6
  BOTTOM w0.254: v2(202.21,29.06) 201.83,28.69 UH1.W31
  vias: v3(199.41,22.94)
+1.0V_DSW: length 10.6
  TOP w0.102: v1(223.78,20.46) 223.55,20.69 222.23,20.69 221.82,20.27 RH255.2
  TOP w0.381: v2(219.6,20.12) 219.6,20.28 220.08,20.76 221.28,20.76 RH255.2
  BOTTOM w0.254: UH1.BG45 UH1.BG46
  BOTTOM w0.381: v2(219.6,20.12) 219.6,20.15 219.28,20.46 CH35.1 218.34,20.8 218.2,20.65 216.27,20.65 215.59,21.33 UH1.BG46
+1.0V_DUSB: length 13.2
  TOP w0.089: RH286.2 202.15,39.29 v1(202,39.45)
  TOP w0.381: CH38.1 200.72,32.47 201.25,33 v2(201.4,33)
  TOP w0.508: RH286.2 202.4,38.42 202.82,38.84 v2(202.88,38.84)
  IN2 w0.508: v2(201.4,33) 201.27,32.87 200.44,32.87 199.83,33.48 199.83,34.51 200.82,35.5 201.7,35.5 202.21,36 202.21,38.33 202.71,38.84 v2(202.88,38.84)
  BOTTOM w0.203: UH1.W23 201.76,32.65 v2(201.4,33) 201.73,33.33 UH1.W22
+1.0V_MPHY: length 11.4
  BOTTOM w0.203: UH1.V30 200.62,29.1 v2(200.62,29.05) UH1.V31 v2(201.33,29.03) 201.33,29.11 UH1.V30 ; UH1.V30 UH1.U29 UH1.V28 ; UH1.V30 201.34,29.82 v2(201.34,29.91) 201.31,29.91 UH1.V28 ; UH1.V27 v2(201.34,31.37) 200.98,31.72 UH1.V25 UH1.U26 ; UH1.V28 201.37,30.63 v2(201.37,30.69)
  BOTTOM w0.254: v2(201.37,30.69) 201.3,30.69 UH1.V27 200.7,30.73 v2(200.57,30.73) ; v2(200.57,30.73) 200.01,30.73 v2(199.98,30.71) 199.98,30.56 v2(200.31,30.23) 200.31,29.96 UH1.U29 200.5,29.74 v2(200.17,29.41) ; v2(200.57,30.73) 200.57,30.65 UH1.V28 ; v2(200.57,30.73) 200.49,30.81 UH1.U26
  vias: v2(189.92,26.29) v2(189.89,22) v2(190.28,21.55) v2(190.67,22.97) v2(191.29,23.21) v2(194.51,21.69) v3(193.43,29.82)
+1.0V_OC: length 1.5
  TOP w0.089: RH260.2 v1(198.76,34.7)
  BOTTOM w0.254: v2(201.37,34.5) UH1.V19
+1.0V_OCPLL1: length 4
  BOTTOM w0.102: v1(189.56,48.7) 188.85,48.7 RH240.2
  BOTTOM w0.254: RH240.2 188.92,48.03 189.13,48.03 CH20.1 190.03,47.73 CC332.1 191,47.57 LC3.1
+1.0V_OCPLL1_R: length 5.5
  BOTTOM w0.254: LC3.2 191.16,46.98 CC331.1 191.97,45.33 193.62,43.68 UH1.C1 UH1.C2
+1.0V_PRIM: length 204.7
  TOP w0.254: v2(203.69,34.5) 204.26,35.06 204.86,35.06 205.57,35.78 CH36.1
  TOP w0.508: RC216.1 38.64,49.54 40.4,51.3 41.92,51.3 42.88,52.26 v2(42.88,53.78)
  TOP w1.778: 144.81,56.21 146.14,54.88 146.14,41.36 155.75,31.75 173.36,31.75 178.99,26.12 178.99,23.95 180.76,22.19 180.76,20.34 183.05,18.04 183.05,15.62 184.48,14.2
  IN2 w0.508: v2(42.88,53.78) 42.88,54.25 44,55.37 48.77,55.37 53.26,59.85 55.57,59.85 56.67,58.76 61.09,58.76 61.45,59.12 71.79,59.12 72.56,59.89 76.78,59.89 77.68,60.79 78,60.79 78.53,61.32 79.09,61.32 80.78,63.02 82.09,63.02 83.64,61.47 84.44,61.47 84.81,61.84 86.8,61.84 87.21,61.43 102.76,61.43 103.15,61.05 114.27,61.05 115.51,62.28 116.22,62.28 116.68,61.82 120.48,61.82 121.05,61.25 129.07,61.25 v2(138.43,70.61)
  BOTTOM w0.152: v2(203.7,29.92) 204.08,29.54 UH1.AD30 ; v2(203.7,29.92) 203.62,29.92 UH1.AB28 ; v2(203.7,29.92) 203.77,29.92 UH1.AD28 ; v2(203.7,29.92) 203.7,29.85 UH1.AB30
  BOTTOM w0.203: UH1.AB30 203.25,29.46 202.91,29.8 v2(202.91,29.91) 202.94,29.91 203.27,30.24 UH1.AB28 ; v2(202.92,32.95) UH1.AB22 v2(203.69,32.95) ; v2(202.92,32.95) UH1.AA22 ; v2(202.92,32.95) UH1.AB23 v2(203.69,32.95) ; v2(202.92,32.95) UH1.AA23 ; v2(203.69,32.95) UH1.AD23 204.16,32.56 v2(204.52,32.92) 204.85,32.59 UH1.AF23 v2(205.24,32.95) ; 204.85,29.49 204.85,29.55 v2(204.49,29.92) ; 204.85,29.49 UH1.AF30 ; 204.85,29.49 205.25,29.89 v2(205.25,29.93) ; UH1.AB28 202.92,30.62 v2(202.92,30.69) 202.98,30.69 UH1.AB27 ; UH1.AB28 203.31,30.3 v2(203.68,30.68) ; UH1.AD30 204.49,29.87 v2(204.49,29.92) ; UH1.AB27 203.35,31.01 v2(203.68,30.68) ; UH1.AB27 v2(203.67,31.37) 203.72,31.37 UH1.AD27 ; v2(204.49,29.92) 204.17,30.24 UH1.AD28 204.08,30.28 v2(203.68,30.68) ; v2(205.22,31.37) UH1.AF27 204.8,31.01 204.49,31.32 v2(204.49,31.35) 204.42,31.35 UH1.AD27 ; v2(203.68,30.68) 204.02,31.01 UH1.AD27
  BOTTOM w0.254: v2(203.69,33.72) UH1.AD20
  BOTTOM w0.305: UH1.AB20 v2(203.69,34.5)
  vias: v2(139.01,70.59) v2(139.65,70.56) v2(140.43,56.18) v2(140.92,55.8) v2(141.42,55.3) v2(185.21,12.85) v2(185.21,12.09) v2(185.21,11.33) v2(185.97,12.85) v2(185.97,12.09) v2(185.97,11.33) v2(186.74,12.85) v2(186.74,12.09) v2(186.74,11.33) v2(187.5,12.85) v2(187.5,12.09) v2(187.5,11.33) v2(203.44,17.55) v2(204,17.55) v2(204.55,17.58) v2(205.14,17.55) v2(205.26,30.68) v3(139.11,71.86)
+1.0V_PRIM_CNV_HVLO: length 3.4
  TOP w0.089: v1(205.16,38.8) 204.81,38.44 204.81,38.07 205.09,37.79 205.09,37.03 204.54,36.49 RH257.2
  BOTTOM w0.254: v2(204.07,35.79) UH1.AE17
+1.0V_PRIM_FUSE: length 0.5
  BOTTOM w0.203: UH1.AD31 203.75,29.02 v2(203.68,29.02)
  vias: v3(203.15,24.26)
+1.0V_PRIM_XDP: length 38
  TOP w0.254: 43.11,46.52 43.17,46.46 JXDP1.44 ; JXDP1.43 43.17,37.78
  TOP w0.508: 43.17,37.78 43.17,37.06 42.58,36.47 CC28.1 41.91,36.93 v2(42.21,37.24) ; v2(39.99,47.4) 40.03,47.44 RC216.2 ; RC138.1 34.15,35.96 v2(35.18,36.98) ; RC216.2 40.03,49.69 40.81,50.46 v1(41.26,50.46) 41.43,50.46 41.94,49.95 RC115.2 ; RC216.2 40.16,48.1 CC29.1 41.05,47.93 41.58,47.41 42.62,47.41 43.11,46.92 43.11,46.52
  IN1 w0.508: v2(42.21,37.24) 42.21,37.49 41.7,38 35.89,38 35.18,37.29 ; 35.18,37.29 35.18,38.76 35.99,39.57 35.99,42.7 39.33,46.04 39.33,46.74 v2(39.99,47.4) ; 35.18,37.29 v2(35.18,36.98)
+1.0V_SRC: length 1.1
  BOTTOM w0.203: UH1.W19 v2(202.14,34.5) UH1.W20
  vias: v3(202.79,35.43)
+1.0V_VCCSFR: length 17.8
  TOP w0.356: CC192.2 115.27,72.95 v2(115.24,72.99)
  TOP w0.508: v2(115.24,72.99) 116.38,72.99 116.64,72.73 v1(119.29,72.73) 120.09,72.73 121.61,71.2 125.11,71.2 125.57,70.74 128.01,70.74 RC304.2 128.75,69.57 CC333.2
  BOTTOM w0.203: v2(115.24,72.99) 115.24,73.11 115.36,73.24 UC1.J28 UC1.H28
+1.0V_VCCST: length 509.8
  TOP w0.508: 66.56,79.46 67.28,80.18 67.28,81.97 69.34,84.02 RC157.1 69.34,85.9 RC152.1 69.36,88.9 68.33,89.93 65.66,89.93 62.1,93.48 62.1,97.29 64.59,99.78 64.59,99.94 66.42,101.77 68.19,101.77 69.29,100.67 70.46,100.67 71.92,102.13 71.92,104.57 73.11,105.77 74.28,105.77 76.35,107.84 89.14,107.84 93.67,112.36 99.88,112.36 102.31,109.93 102.31,107.66 103.36,106.6 103.36,102.23 103.87,101.72 103.87,100.67 104.81,99.73 111.9,99.73 112.98,98.65 116.3,98.65 v2(119.27,95.68) ; 66.56,79.46 66.31,79.71 PR1707.1 65.7,79.7 PR1706.1 65.7,78.82 PR1705.2 65.7,77.24 65.66,77.2 65.66,77.13 65.13,76.61 PR1704.1 65.13,76.56 65.66,76.03 69.37,76.03 69.61,75.78 72.97,75.78 73.34,76.15 74.11,76.15 74.59,75.67 74.59,74.95 71.4,71.75 v2(71.04,71.75) 71.04,71.22 71.63,70.63 71.63,66.66 63.08,58.11 v2(53.21,58.11) ; 66.56,79.46 PC1702.2 ; RC71.1 137.42,58.28 v2(136.85,58.28) ; v2(321.14,11.16) 320.44,11.86 320.44,13.13 319.54,14.04 319.54,17 319.77,17.24 RE90.1 ; RC80.1 122.89,86.12 125.02,86.12 125.93,85.22 125.93,83.47 125.29,82.83 125.29,82.37 125.29,82.37 125.29,79.2 127.2,77.29 131.05,77.29 133.03,79.27 135.52,79.27 135.69,79.1 ; v2(53.21,56.59) 53.21,56.13 53.89,55.45 RC218.1
  IN2 w0.508: v2(136.85,58.28) 142.78,52.35 144.06,52.35 148.92,47.49 161.7,47.49 168.07,41.12 168.07,34.19 177.11,25.15 v2(177.11,24.92) ; v2(128.84,74.92) 128.11,74.19 121.94,74.19 121.82,74.31 121.14,74.31 120.79,74.66 ; v2(119.27,95.68) 121.37,93.59 121.37,85.34 120.88,84.86 120.88,78.76 120.61,78.49 120.61,76.2 120.48,76.07 ; v2(318.74,7.54) 318.39,7.19 310.8,7.19 309.59,8.4 298.94,8.4 298.3,9.04 295.28,9.04 294.69,9.64 283.81,9.64 283.07,8.9 279.06,8.9 277.16,10.81 267.67,10.81 266.82,9.96 260.15,9.96 256.07,5.87 219.62,5.87 219.4,5.65 214.85,5.65 213.34,7.16 208.38,7.16 208.3,7.24 204.25,7.24 199.34,12.15 197.17,12.15 191.61,17.71 188.61,17.71 184.08,22.24 v2(183.73,22.24)
  IN3 w0.508: v2(177.11,24.92) 178.02,24 180.36,24 182.1,22.27 183.7,22.27 v2(183.73,22.24) ; v2(53.21,58.11) v2(53.21,56.59) ; v2(133.56,70.99) 132.44,69.87 131.31,69.87 130.18,71.01 130.18,73.05 128.84,74.4 v2(128.84,74.92)
  BOTTOM w0.203: v2(116.85,75.25) 116.85,75.18 116.45,74.78 UC1.H30
  BOTTOM w0.508: v2(133.56,70.99) 132.89,70.32 132.89,60.18 134.79,58.28 v2(136.85,58.28) ; RC79.1 71.81,72.03 71.32,72.03 v2(71.04,71.75) RC166.1 ; RE59.1 327.54,34.82 327.75,35.03 330.5,35.03 333,32.53 333,25.51 332.24,24.75 332.24,22.09 332.18,22.03 332.18,17.3 332.82,16.66 334.62,16.66 336.19,15.09 336.19,10.52 334.17,8.49 326.02,8.49 324.33,10.18 323.71,10.18 322.75,11.14 321.16,11.14 v2(321.14,11.16) 318.74,8.76 v2(318.74,7.54)
  vias: v3(135.21,73.72)
+1.0V_VCCST_C: length 0.9
  TOP w0.102: 132.14,88.98 132.86,88.98 v1(132.97,89.08)
+1.0V_VCCSTG: length 302.3
  TOP w0.508: v2(70.38,72.06) 70.38,70.46 70.96,69.87 70.96,67.27 64.26,60.57 62.63,60.57 61.3,59.24 v2(54.75,59.24) 50.08,59.24 47.04,56.2 47.04,55.4 46.4,54.76 46.4,49.12 RC135.2 ; 129.63,72.47 129.93,72.16 130.78,72.16 RZ151.1 131.67,72.75 v2(132.38,72.03) ; v2(124.76,71.91) 125.64,71.91 126,71.55 127.22,71.55 127.22,71.55 ; RH312.2 208.72,48.53 208.29,48.96 208.29,51.93 207.44,52.78 v2(206.78,52.78)
  IN1 w0.508: v2(206.78,52.78) 206.75,52.78 206.29,52.32 204.52,52.32 v2(203.87,52.97)
  IN2 w0.508: v2(203.87,52.97) 203.87,52.94 202.66,51.74 194.06,51.74 192.89,52.91 180.02,52.91 176.95,55.99 176.95,75.79 177.4,76.25 v2(177.4,76.39)
  IN3 w0.508: v2(116.77,74.43) 116.59,74.43 116.2,74.04 116.15,73.99 116.15,73.25 116.68,72.72 123.95,72.72 v2(124.76,71.91)
  BOTTOM w0.254: UC1.H29 116.43,74.04 116.77,74.38 v2(116.77,74.43)
  BOTTOM w0.508: v2(142.64,78.51) 141.95,77.82 139.57,77.82 133.78,72.03 v2(132.38,72.03) 132.38,71.27 131.62,70.51 131.62,60.02 130.63,59.03 CC335.1 129.94,59.03 129.52,58.61 129.52,57.43 128.74,56.64 128.74,49.11 127.83,48.21 124.37,48.21 121.49,45.32 76.46,45.32 75.4,46.38 75.4,54.47 72.68,57.19 CC334.1 57.73,57.19 55.67,59.24 v2(54.75,59.24) ; v2(142.62,79.2) 140.1,79.2 137.93,81.37 137.93,86.87 139.97,88.91 144.5,88.91 145.18,88.24 153.46,88.24 162.4,79.3 174.49,79.3 v2(177.4,76.39) ; RH315.2 206.9,52.65 v2(206.78,52.78) ; RC83.1 71.41,73.09 v2(70.38,72.06) ; RH314.2 204.06,52.73 203.87,52.92 v2(203.87,52.97)
  vias: v3(144.18,80.07)
+1.0V_VCCSTG_C:
  vias: v3(142.92,75.95)
+1.0V_XTAL: length 7.1
  TOP w0.089: v2(198.17,44.93) 198.6,45.36 v3(198.6,45.73)
  TOP w0.508: RH238.2 197.36,44.1 196.88,44.58 CH45.1 v2(198.17,44.93)
  BOTTOM w0.152: UH1.P2 199.15,42.5 UH1.P3
  BOTTOM w0.254: v2(198.17,44.93) 198.24,44.93 198.5,44.68 198.5,44.06 199.41,43.15
+1.0VALWP: length 7.4
  BOTTOM w0.254: PR313.1 171.59,10.97 177.89,10.97 178.24,10.62
  vias: v2(178.37,9.83) v2(178.37,9.19) v2(178.37,8.56) v2(178.37,7.92) v2(178.37,7.29) v3(178.37,6.22)
+1.0VS_VCCIO: length 374.2
  TOP w0.457: RC1.2 121.28,83.16 120.89,82.77 120.89,82.27 121.32,81.84 122.93,81.84 123.4,81.37 v2(123.4,81.26)
  TOP w0.508: RC2.1 124.89,47.01 128.19,50.32 128.19,62.23 127.76,62.66 ; v2(323.71,7.1) 323.71,9.13 324.86,10.28 324.86,12.52 325.29,12.95 325.29,16.03 324.39,16.93 QE11.1 ; RC132.1 55.75,48.87 56.56,49.68 56.56,51.33 55.16,52.73 v2(55.16,56.39)
  IN1 w0.508: v2(75.18,61.26) 75.18,61.44 76.93,63.19 82.95,63.19 83.56,63.8 84.28,63.8 84.63,63.46 84.63,62.26 85.1,61.79 85.54,61.79 85.59,61.84 86.25,61.84 86.37,61.72 86.85,61.72 87.21,61.36 101.52,61.36 102.26,60.62 v2(102.32,60.62) 102.96,60.62 102.97,60.64 114.82,60.64 115.32,61.14 115.32,63.08 v2(115.22,63.18)
  IN2 w0.508: v2(144.34,68.43) 153.74,68.43 157.48,64.69 157.48,58.98 166.99,49.47 v2(166.99,46.19) ; v2(128.44,68.07) 128.44,68.2 129.84,69.6 129.84,75.46 128.29,77.02 125.92,77.02 123.24,79.7 123.24,80.34 123.42,80.52 123.42,81.24 v2(123.4,81.26) ; v2(323.71,7.1) 322.66,8.15 320.07,8.15 320.04,8.18 318.32,8.18 317.97,7.82 311.07,7.82 310.35,8.54 310.35,8.54 309.86,9.03 299.21,9.03 297.7,10.54 292.82,10.54 292.55,10.27 283.55,10.27 282.81,9.53 279.33,9.53 277.42,11.44 267.41,11.44 266.56,10.59 259.89,10.59 255.81,6.51 219.36,6.51 219.14,6.29 216.21,6.29 214.7,7.8 209.13,7.8 208.98,7.95 204.44,7.95 199.6,12.79 197.85,12.79 192.29,18.35 189.72,18.35 185.81,22.26 185.81,25.22 181.88,29.15 179.56,29.15 170.96,37.75 170.96,42.41 168.75,44.62 v2(168.75,46.25)
  IN3 w0.508: v2(55.16,56.39) 57.04,58.27 63.28,58.27 64.93,59.92 70,59.92 70.23,60.15 73.28,60.15 73.43,59.99 74.82,59.99 75.18,60.35 v2(75.18,61.26)
  BOTTOM w0.203: UC1.J26 115.28,72.12 ; 115.28,72.12 115.09,72.31 114.94,72.31 114.42,71.79 v2(114.42,71.57) 114.42,71 v2(114.47,70.95) ; 115.28,72.12 115.62,72.45 UC1.J27 ; 115.28,72.12 115.05,71.88 v2(115.05,71.65)
  BOTTOM w0.254: UC1.H19 116.41,66.16 v2(116.81,65.76) ; v2(117.38,62.64) 117.38,62.71 UC1.G15 ; v2(116.05,72.06) 116.38,72.39 UC1.H27 ; v2(116.05,72.06) 116.05,72 UC1.H26 116.38,71.66 v2(116.76,71.28) ; v2(116.05,72.06) 115.73,71.74 UC1.J26 115.73,71.59 v2(116.05,71.27) ; v2(116.05,72.06) 116.05,72.13 UC1.J27 ; UC1.J15 115.82,62.92 116.29,62.92 UC1.H15 116.06,63.33 116.06,63.33 ; UC1.J15 116.06,63.33 ; UC1.J15 115.55,63.18 v2(115.22,63.18) ; UC1.AG12 102.15,60.62 v2(102.32,60.62) ; 116.06,63.33 v2(116.06,63.4) ; v2(116.75,63.4) 116.75,63.43 UC1.H16 ; UC1.H20 116.4,66.94 v2(116.76,66.58) ; UC1.H17 116.38,64.52 v2(116.73,64.17) ; UC1.G19 117.42,65.81 v2(117.42,65.79) ; v2(117.41,67.35) 117.08,67.67 UC1.G21 ; UC1.J16 v2(115.21,63.79) ; UC1.J17 115.7,64.58 115.21,65.07 v2(115.21,65.35) ; UC1.H21 116.38,67.73 v2(116.79,67.32) ; UC1.G17 117.43,64.23 v2(117.43,64.17)
  BOTTOM w0.305: v2(115.22,66.94) UC1.J20 UC1.H20 ; v2(115.22,66.16) UC1.J19 UC1.H19 ; UC1.H21 UC1.J21 115.38,67.73 v2(115.22,67.57)
  BOTTOM w0.508: v2(75.18,61.26) 75.18,62.22 74.68,62.71 RC439.2 ; v2(168.75,46.25) 168.69,46.19 v2(166.99,46.19)
  vias: v2(140.84,68.39) v2(140.79,67.61) v2(141.41,68.4) v2(141.36,67.61) v2(142.02,68.39) v2(141.97,67.61) v2(142.54,67.61) v2(142.59,68.4) v2(143.11,67.61) v2(143.15,68.43) v2(143.71,68.44) v2(143.71,67.63) v2(144.29,67.64) v3(136.33,66.24)
+1.2V_DDR_B+:
  vias: v1(40.23,7.01) v2(40.54,6.61) v2(41.21,6.61)
+1.2V_DDRP: length 40.5
  IN2 w1.016: 50.34,11.35 50.82,10.87 56.94,10.87 58.58,9.23 63.74,9.23 64.28,8.69
  BOTTOM w0.254: 63.61,5.68 63.61,1.87 63.17,1.42 45.58,1.42 44.87,2.13 44.87,3.63 PC208.1 PR204.1
  vias: v2(48.51,9.32) v2(49.04,10.11) v2(59.61,7.26) v2(59.61,6.63) v2(60.24,7.26) v2(60.24,6.63) v2(61.13,7.26) v2(61.13,6.63) v2(61.9,7.26) v2(61.9,6.63) v2(62.91,7.26) v2(62.91,6.5) v2(63.67,7.26) v2(63.67,6.5) v2(64.69,7.26) v2(64.69,6.5) v3(59.88,7.91)
+1.2V_LDO: length 5.9
  BOTTOM w0.508: v2(19.96,63.83) 19.91,63.88 19.91,64.71 19,65.63 16.74,65.63 v2(15.72,64.61)
  vias: v1(18.73,64.69)
+1.2V_MEM: length 119.6
  TOP w0.457: v2(84.41,12.53) 84.99,13.11 CD4.1 ; v2(56.19,12.8) 55.91,13.08 CD14.1 ; v2(74.74,12.67) 74.45,12.96 CD15.1
  TOP w0.508: CD35.1 111.92,12.66 v2(111.76,12.5) ; RD11.1 52.27,13.65 51.99,13.37 51.99,12.61 v2(51.99,12.6) ; RZ119.1 70.14,60.8 69.39,61.54 69.39,61.57 v2(69.41,61.57)
  BOTTOM w0.203: UC1.AG5 102.07,55.78 v2(102.38,56.09) ; v2(102.38,56.09) 102.49,56.09 UC1.AF6 ; v2(102.38,56.09) 102.69,55.78 UC1.AF5 ; UC1.AJ12 99.87,60.34 v2(99.58,60.05) 99.21,59.69 UC1.AL11 ; UC1.K6 115.2,56.62 114.76,56.62 114.56,56.43 UC1.L6 ; UC1.AG9 101.92,58.39 v2(102.33,58.8)
  BOTTOM w0.254: v2(122.52,12.82) 122.47,12.87 JDIMM2.54 ; UC1.T6 110.25,56.43 v2(109.93,56.1) ; UC1.AA6 107.02,56.42 107.4,56.04 ; v2(103.21,59.98) 103.57,60.34 UC1.AE12 ; 107.4,56.04 107.4,56.04 107.78,56.43 UC1.W6 ; 107.4,56.04 v2(107.4,55.98) ; v2(111.76,12.5) 111.97,12.71 JDIMM2.12 ; UC1.AW6 92.46,56.12 v2(92.33,56.12) 92.24,56.12 UC1.AY6 ; 94.99,60.03 94.68,60.34 UC1.AT12 ; 94.99,60.03 v2(94.99,60.07) ; 94.99,60.03 95.02,60.03 95.33,60.34 UC1.AR12 ; UC1.Y12 107.52,60.34 v2(107.81,60.05) ; UC1.AR6 UC1.AP6 96.38,56.69 UC1.AP7 96.44,57.09 96.79,57.44 v2(96.79,57.5) ; UC1.L12 114.87,60.54 115.3,60.54 UC1.K12 115.53,60.31 v2(116.04,60.31) ; UC1.K6 UC1.J6 116.3,56.43 v2(116.64,56.09) 116.32,55.78 UC1.J5
  BOTTOM w0.305: JDIMM1.123 58.72,23.6 v2(58.15,24.16) ; JDIMM1.241 90.22,23.3 v2(89.93,23.59) ; v2(68.17,23.73) 68.22,23.68 JDIMM1.153 ; JDIMM1.75 46.72,23.35 46.23,23.84 v2(46.18,23.84) ; JDIMM2.135 142.72,23.25 142.39,23.58 v2(141.88,23.58) 141.52,23.58 141.22,23.28 JDIMM2.129 ; v2(74.74,12.67) 74.47,12.94 JDIMM1.178 ; v2(35.61,23.52) 35.94,23.52 36.22,23.24 JDIMM1.33 ; v2(147.72,23.57) 147.72,23.57 JDIMM2.147 ; v2(55.05,23.64) 55.38,23.64 55.72,23.29 JDIMM1.111 ; v2(57.73,23.65) 57.22,23.14 JDIMM1.117 ; v2(144.32,23.77) 144.22,23.67 JDIMM2.141 ; JDIMM1.129 60.22,23.29 60.58,23.65 v2(60.73,23.65) 61.49,23.65 61.72,23.43 JDIMM1.135 ; JDIMM1.142 63.47,13.1 v2(63.7,12.87) ; JDIMM2.124 139.97,12.99 v2(139.77,12.79) ; JDIMM2.153 149.22,23.37 v2(149.58,23.72) ; v2(145.7,12.71) 144.91,12.71 144.47,13.16 JDIMM2.142 ; UC1.T6 UC1.R6 ; v2(58.99,12.8) 58.97,12.82 JDIMM1.124 ; v2(139.42,24.2) 139.03,24.2 138.22,23.39 JDIMM2.117 ; v2(171.5,23.93) 171.5,23.83 171.22,23.56 JDIMM2.241 ; v2(60.37,12.75) 60.47,12.84 JDIMM1.130 ; JDIMM1.112 55.97,13.27 56.19,13.05 v2(56.19,12.8) ; v2(141.15,12.71) 141.47,13.03 JDIMM2.130 ; JDIMM2.136 142.97,13.21 143.25,12.92 v2(143.25,12.75) ; v2(30.78,12.72) 30.97,12.91 JDIMM1.12 ; JDIMM2.159 150.72,23.12 v2(151.39,23.79) 151.39,23.54 151.72,23.21 JDIMM2.163 ; v2(165.97,15.32) JDIMM2.220 ; v2(127.54,24.08) 127.54,23.76 127.72,23.58 JDIMM2.75 ; JDIMM2.111 136.72,23.21 v2(136.22,23.72) ; v2(66.67,23.6) 66.72,23.55 JDIMM1.147 ; v2(61.59,12.8) 61.97,13.18 JDIMM1.136 ; v2(78.72,23.89) 78.77,23.84 79.31,23.84 79.72,23.43 JDIMM1.199 ; JDIMM1.159 69.72,23.22 69.97,23.47 v2(69.97,23.49) 70.33,23.49 70.72,23.1 JDIMM1.163 ; JDIMM2.33 117.22,23.35 116.75,23.81 116.82,23.88 v2(116.82,24.05) ; v2(136.29,15.62) 136.97,14.94 JDIMM2.112 ; JDIMM1.118 v2(57.47,12.73) ; JDIMM2.148 147.97,13.14 v2(148.38,12.72) ; JDIMM1.148 66.97,13.11 66.65,12.79 v2(66.65,12.62) ; v2(139.02,12.84) 138.79,12.84 138.47,13.16 JDIMM2.118 ; v2(62.72,23.65) 63.22,23.15 JDIMM1.141 ; v2(155.52,15.4) 155.47,15.35 JDIMM2.178 ; v2(84.41,12.53) 84.97,13.09 JDIMM1.220 ; JDIMM2.123 139.72,23.46 v2(139.58,23.6) ; v2(150.75,12.49) 150.75,12.64 150.96,12.85 150.96,12.98 150.97,12.98 JDIMM2.160 ; JDIMM2.199 160.72,23.54 v2(160.8,23.62) ; JDIMM1.154 68.47,13.4 68.46,13.39 68.46,13.22 67.95,12.71 v2(67.42,12.71) ; JDIMM2.154 149.47,14.1 149.47,13.14 149.38,13.06 v2(149.38,12.74) ; JDIMM1.96 51.97,12.62 v2(51.99,12.6) ; v2(69.68,12.74) 69.68,12.97 69.97,13.26 JDIMM1.160 ; JDIMM2.96 132.97,12.97 v2(132.81,12.81) ; JDIMM1.54 41.47,13.24 40.97,12.74 40.45,12.74 v2(40.43,12.72)
  BOTTOM w0.381: UZ26.2 69.13,62.71 67.98,62.71 66.9,61.63 CD32.1 66.73,61.17 UD1.5
  vias: v2(58.97,10.21) v2(59.23,10.85) v2(59.61,10.21) v2(59.86,10.85) v2(60.24,10.21) v2(60.5,10.85) v2(60.88,10.21) v2(61.13,10.85) v2(61.51,10.21) v2(61.77,10.85) v2(62.15,10.21) v2(62.4,10.85) v2(62.78,10.21) v2(63.04,10.85) v2(63.42,10.21) v2(63.67,10.85) v2(63.88,50.27) v2(64.05,10.21) v2(64.23,49.78) v2(64.33,50.67) v2(64.31,10.85) v2(64.72,50.14) v2(64.84,51.1) v2(65.17,50.57) v2(72.77,58.93) v2(73.25,59.28) v2(136.95,52.48) v2(136.95,51.84) v2(137.08,53.24) v2(137.59,52.48) v2(137.59,51.84) v2(138.22,51.84) v3(145.49,28.89)
+1.2V_RUN: length 146.2
  IN1 w0.508: v2(117.78,122.96) 116.7,124.04 112.95,124.04 111.74,125.25 104.31,125.25 101.2,122.14 88.69,122.14 87.17,120.61 82.34,120.61 79.29,123.66 72.69,123.66 72.12,124.23 67.99,124.23 v2(66.59,122.83)
  IN2 w0.508: v2(117.78,122.96) 117.78,122.14 120.13,119.79 140.83,119.79 143.62,122.58 143.62,129.37 v2(144,129.76) ; v2(66.59,122.83) 64.69,120.93 64.69,119.4 64.05,118.77 60.56,118.77 58.15,116.36 55.1,116.36 50.53,111.78 40.24,111.78 39.4,112.62 34.55,112.62 30.39,116.78 30.39,117.32 29,118.71 21.26,118.71
  vias: v1(21.19,119.72) v2(20.05,118.74) v2(20.68,118.76) v2(144.01,130.38)
+1.2V_VDD_A1: length 1.3
  BOTTOM w0.203: UT9.13 25.52,113.35 v2(25.95,113.78)
  vias: v1(26.53,113.44)
+1.2V_VDD_A2: length 1
  BOTTOM w0.203: v2(19.29,112.23) 19.36,112.3 UT9.47
  vias: v1(19.86,112.1)
+1.2V_VDD_DM_D1: length 9.2
  TOP w0.508: v2(23.1,107.28) 23.22,107.4 CT614.1 ; v2(24.7,115.19) 24.61,115.28 CT628.1 24.11,115.21 24.06,115.16 CT616.1 ; CT617.1 19.88,109.46 v2(19.48,109.05)
  BOTTOM w0.102: v2(20.68,116.16) 20.68,116.17 v1(20.18,116.67)
  BOTTOM w0.203: UT9.16 25.64,112.3 25.7,112.36 v2(25.7,112.37) ; UT9.1 21,115.15 20.7,115.46 ; v2(23.1,107.28) UT9.30 ; v2(19.48,109.05) 19.57,109.15 UT9.38 ; v2(24.7,115.19) 24.29,115.19 24.15,115.05 UT9.10
  BOTTOM w0.254: 20.7,115.46 20.68,115.47 v2(20.68,116.16)
+1.2V_VDD_R1: length 1.4
  BOTTOM w0.203: UT9.6 22.75,115.81 22.53,116.04
  vias: v1(21.38,118.2)
+1.2V_VDD_R2: length 1.5
  BOTTOM w0.203: v2(23.41,116.1) 23.1,115.79 UT9.7
  vias: v1(22.53,116.86)
+1.2V_VIN:
  vias: v3(151.68,130.83)
+1.8V_3.3V_ALW_VTR3: length 31
  TOP w0.102: 313.47,14.06 313.47,14.91 v3(312.89,15.49)
  TOP w0.356: UE1.N5 316.92,30.06 316.91,30.04 316.91,29.87 316.4,29.36 CE21.1
  TOP w0.381: v2(315.68,28.09) 316.37,28.09 CE21.1
  TOP w0.508: RE549.1 307.04,30.03 v2(306.6,29.59)
  IN2 w0.508: v2(315.68,28.09) 314.47,28.09 312.74,29.83 306.83,29.83 v2(306.6,29.59)
  BOTTOM w0.508: v2(313.51,11.9) 316.15,14.54 316.15,22.96 314.74,24.37 314.74,25.18
+1.8V_ALW_PCHRES: length 9.7
  TOP w0.508: RH250.1 207.83,23.39 v2(208.3,23.86) ; RH294.1 207.97,28.64 v2(207.97,29.29) ; RH296.1 219.37,34.7 220.95,34.7 222.04,35.8 v2(222.04,36.03)
  IN3 w0.508: v2(221.94,40.02) 222.8,39.15 222.8,37.55 222.04,36.79 v2(222.04,36.03)
  vias: v3(221.89,40.7)
+1.8V_PHVLDO: length 1
  BOTTOM w0.254: UH1.AF19 204.85,34.81 v2(204.53,34.49) 204.85,34.16 UH1.AF20
  vias: v3(214.83,35.7)
+1.8V_PRIM: length 354.3
  TOP w0.508: RH607.2 214.07,45.86 214.54,45.39 v2(215.47,45.39) 215.52,45.44 215.52,46.2 RH613.1 216.53,46.52 RH605.2 217.03,47.02 217.03,49.03 RH614.1 216.52,49.29 215.61,50.2 RH604.2 215.5,53.65 207.85,61.3 193.54,61.3 190.56,64.28 186.78,64.28 181.21,69.85 v2(181.21,71.67)
  TOP w1.016: 308.96,13.36 308.96,20.13 307.86,21.23 306.69,21.23 305.48,22.44 305.48,26.09 304.76,26.81
  IN2 w0.508: v2(219.75,40.35) 219.75,40.72 218.74,41.73 218.74,42.2 217.67,43.28 217.35,43.28 216.7,43.93 216.7,44.82 216.12,45.39 v2(215.47,45.39) ; v2(331.26,49.55) 330.6,50.22 329.23,50.22 326.87,47.85 319.38,47.85 318.82,48.41 308.66,48.41 308.45,48.62 305.17,48.62 303.31,46.76
  IN2 w1.016: 228.56,41.43 230.26,39.73 236.51,39.73 238.39,37.85 239.75,37.85 ; 277.01,39.42 277.03,39.39 281.1,39.39 281.63,39.93 289.28,39.93 289.63,39.57 294.26,39.57 298.14,43.46 302.56,43.46 303.04,43.94 303.04,45.12 ; 247.77,36.68 247.79,36.66 249.04,36.66 249.89,35.81 267.97,35.81 268.4,36.25
  IN2 w1.524: 211.46,5.44 203.21,5.44 202.12,6.53 202.12,7.1 198.62,10.6 196.73,10.6 191.13,16.2 185.76,16.2 183.54,13.98 183.54,13.24 181.96,11.66 171.74,11.66 170.77,10.69 163.75,10.69 ; 147.01,8.43 145.6,7.03 129.44,7.03 129.42,7 128.95,7.47 ; 265.63,7.39 266.72,7.39 268.26,8.93 276.3,8.93 277.44,7.78 ; 262.17,7.31 260.38,7.31 256.17,3.1 216.4,3.1
  BOTTOM w0.381: UZ61.5 141.54,85.65 CZ544.1
  BOTTOM w0.508: CZ544.1 142.4,86.99 142.75,87.35 143.47,87.35 143.48,87.34 143.91,87.34 144.63,86.62 149.74,86.62 158.8,77.55 169.1,77.55 173.55,73.1 178.4,73.1 179.84,71.67 v2(181.21,71.67)
  vias: v2(127.05,8.66) v2(127.02,8.05) v2(127.62,8.32) v2(219.19,39.34) v2(303.02,46.06) v2(303.73,46.1) v2(304.7,28.07) v2(304.82,6.22) v2(305.16,6.9) v2(305.3,28.09) v2(305.56,6.3) v3(308.5,10.76)
+1.8V_PRIM_PCH: length 280.7
  TOP w0.508: v2(181.28,72.63) 182.37,71.54 182.37,69.6 187.04,64.92 190.82,64.92 193.81,61.93 208.12,61.93 217.3,52.75 217.3,50.79 218.39,49.7 224.15,49.7 226.84,47.01 226.84,39.15 227.89,38.1 228.38,38.1 228.78,37.7 v2(228.78,36.8) 227.45,36.8 226.93,37.31 223.24,37.31 223.08,37.16 221.02,37.16 221.01,37.17 220.65,37.17 220.2,37.62 218.33,37.62 218.33,37.62 218.06,37.62 217.93,37.74
  IN1 w0.508: v2(303.88,32.8) 303,33.68 302.05,33.68 300.97,34.76 294.85,34.76 293.94,35.67 v2(293.94,42.49)
  IN2 w0.508: v2(303.88,32.8) 303.88,32.16 299.81,28.09 294.91,28.09 293.89,27.08 285.73,27.08 284.69,26.03 284.69,23.91 281.03,20.26 263.3,20.26 260.63,22.93 237.09,22.93 235.83,21.67 235.79,21.67 235.67,21.55 232.82,21.55 232.49,21.88 225.55,21.88 v2(225.55,21.82)
  BOTTOM w0.254: UH1.AN15 v2(208.98,36.71) ; UH1.AG19 205.5,34.88 205.17,34.56 v2(205.17,34.5) 205.56,34.11 UH1.AG20 ; UH1.BB11 212.88,38.99 v2(212.7,39.16) ; UH1.AR15 v2(210.07,36.71)
  BOTTOM w0.508: RZ378.1 294.29,42.14 v2(293.94,42.49) 293.94,43.32 RZ376.1 ; v2(225.55,21.82) 226.14,22.41 228.84,22.41 230.67,24.24 230.67,27.84 235.85,33.02 236.89,33.02 238.24,34.37 238.24,35.17 236.18,37.23 229.21,37.23 v2(228.78,36.8) ; v2(181.28,72.63) 179.77,72.63 173.74,78.66 162.14,78.66 153.2,87.6 144.91,87.6 144.28,88.24 140.46,88.24 138.64,86.43 138.64,81.95 139.45,81.14 140.83,81.14 141.04,81.36 RZ543.2
  vias: v3(209.51,37.27)
+1.8V_RUN:
  vias: v3(335.73,46.35)
+1.8V_RUN_AUDIO: length 16.8
  TOP w0.203: UA1.36 339.12,41.1 339.04,41.18 v2(339.04,41.72) ; CA57.1 336.34,39.04 336.61,38.77 UA1.40
  TOP w0.381: CA57.1 336.28,39.88 335.85,40.31
  TOP w0.508: 335.85,40.31 335.85,43.1 CA58.1 v2(336.89,44.14) 337.12,43.92 v1(338.41,43.92) 338.62,44.12 CA69.1 337.85,45.33 RA3.1
  BOTTOM w0.508: v2(336.89,44.14) 337.6,43.43 337.6,42.85 338.21,42.24 338.78,42.24 339.04,41.98 v2(339.04,41.72)
+1.8V_RUN_CARD: length 27.8
  IN2 w1.016: 4.36,79.02 6.22,77.17 6.22,64.05 7.87,62.39 17.57,62.39
  vias: v2(3.48,80.54) v2(3.48,79.96) v2(5.94,81.05) v2(6.52,81.05) v2(18.14,63.66) v2(18.13,63.04) v3(5.84,79.69)
+1.8V_RUN_UZ8: length 0.9
  TOP w0.102: v1(332.81,48.26) 332.63,48.08 332.63,47.38
+1.8VALWP: length 3.2
  BOTTOM w0.203: 126.22,6.63 v1(126.96,6.63)
  BOTTOM w0.254: PC501.1 122.26,7.91 122.25,7.92 PC503.1 121.49,7.93 PR501.1
+1.24V_DPHY: length 5.9
  TOP w0.089: v1(210.42,31.1) 210.18,31.34 RH237.1
  TOP w0.254: v2(206.79,32.94) 206.83,32.9 206.83,32.16 207.64,31.34 RH237.1
  BOTTOM w0.254: UH1.AJ23 206.41,32.56 v2(206.79,32.94) 206.4,33.32 UH1.AJ22
+1.24V_DPHY_MAR: length 6.5
  BOTTOM w0.089: T75.1 219.01,44.14 CH30.1
  BOTTOM w0.203: 216.93,43.29 215.39,41.76 UH1.BG5
  BOTTOM w0.3: 216.93,43.29 216.93,44.5 217.23,44.8 217.87,44.8 218.13,44.54 CH30.1
+1.24V_LDOSRAM: length 1.1
  BOTTOM w0.254: UH1.AK22 207.55,32.97 v2(207.55,32.93) 207.54,32.93 UH1.AK23
+1VALWP_B+:
  vias: v1(167.1,4) v2(166.2,3.67) v2(166.2,3.05) v2(166.2,2.46)
+1VS_VCCIOP: length 26.6
  BOTTOM w0.254: PU401.1 149.67,59.03 149.46,58.83 149.46,58.19 v1(147.39,56.11) 146.72,55.45 143.68,55.45 140.97,58.16 140.97,59.79 139.62,61.13 139.62,63.5 140.1,63.98 142.13,63.98 ; 146.48,66.19 146.66,66.38 149.8,66.38 150.14,66.04 150.14,64.34 PR414.1
+2.5V_MEM: length 92.3
  TOP w1.016: 103.42,11.07 105.43,11.07 106.83,12.47 108.89,12.47 110.03,11.33 111.04,11.33 112.06,10.31 113.64,10.31 119.55,4.39 155.73,4.39 159.62,8.28 160.14,8.28 162.77,10.92 164.55,10.92 165.34,11.71 169.8,11.71 170.42,12.33 173.05,12.33 173.68,11.71 179.67,11.71 180.4,12.45
  BOTTOM w0.305: JDIMM2.259 175.72,21.79 176.46,21.05 v2(176.64,21.05) ; JDIMM2.257 175.22,21.34 175.54,21.02 v2(175.76,21.02) ; JDIMM1.259 94.72,21.53 95.07,21.18 v2(95.17,21.18) ; v2(95.75,20.65) 94.79,20.65 94.22,21.22 JDIMM1.257
  vias: v2(77.44,9.48) v2(77.44,8.85) v2(78.01,9.48) v2(78.01,8.85) v2(101.46,4.34) v2(102.03,4.34) v2(102.6,4.34) v2(103.17,4.34) v3(103.55,6.81)
+2.5V_VIN:
  vias: v1(70.01,8.11)
+2.8V_FHV0: length 0.5
  BOTTOM w0.203: UH1.AF31 204.85,28.76 v2(204.55,29.07)
  vias: v3(203.69,22.47)
+2.8V_FHV1: length 0.6
  BOTTOM w0.203: UH1.AG31 205.27,29.04 v2(205.16,29.04)
  vias: v3(204.68,27.06)
+3.3V_1.8V_AZIO:
  vias: v1(223.72,39.19)
+3.3V_1.8V_AZIO_R: length 3.6
  TOP w0.089: v1(212.71,37.47) 212.71,37.6 v2(212.98,37.87)
  TOP w0.381: 221.33,38.39 v2(222.15,38.39) ; 221.33,38.39 221.39,38.45 LC1.2 ; 221.33,38.39 CC310.1
  TOP w0.508: CC327.1 221.29,39.26 LC1.2
  BOTTOM w0.254: UH1.BB14 212.88,37.77 v2(212.98,37.87)
+3.3V_1.8V_GPPA: length 7.2
  IN2 w0.508: v2(216.23,25.86) 216.23,26.2 216.61,26.58 219.8,26.58 220.14,26.24 v2(220.72,26.24)
  BOTTOM w0.254: RH95.2 221.01,25.95 v2(220.72,26.24) 220.26,26.69 RH327.2 ; v2(208.47,27.98) UH1.AN32
  vias: v3(211.18,28.46)
+3.3V_1.8V_GPPD: length 11.3
  TOP w0.089: 217.99,33.78 218.23,33.54 v1(218.85,33.54)
  IN1 w0.508: v2(208.38,32.91) 208.38,33.05 208.92,33.59 216.49,33.59 217.26,34.36 v2(217.26,34.64)
  BOTTOM w0.254: UH1.AN24 v2(208.38,32.91)
+3.3V_1.8V_SPI: length 0.5
  BOTTOM w0.254: UH1.AN44 v2(208.85,22.49)
  vias: v3(208.54,18.45)
+3.3V_ALW: length 670.6
  TOP w0.254: RPE9.5 RPE9.6 RPE9.7 RPE9.8 321.85,23.2 v2(322.02,23.37) ; v2(325.78,11.9) 325.78,12.41 326.53,13.16 326.53,15.81 325.27,17.07 325.27,17.86 v2(325.29,17.88) 324,17.88 323.59,17.47 323.59,16.55 324.4,15.73 RE69.1
  TOP w0.305: JAPS1.3 173.82,44.76 174.11,45.05 v2(175.88,45.05) 175.82,44.99 JAPS1.7
  TOP w0.381: RE8.2 327.24,33.93 v2(327.26,33.94) ; v2(315.77,44.86) 315.72,44.81 315.72,43.58 RE303.2 ; v2(314.04,21.79) 314.04,21.03 313.84,20.84 313.84,20.63 UZ6.5 ; UE4.5 346.56,50.51 345.49,51.59 v2(345.49,52.04) ; v2(137.84,8.38) 137.53,8.7 CZ91.1
  TOP w0.508: RE38.2 330.42,34.25 v2(330.24,34.42) ; v2(240.88,32.58) 240.88,32.79 240.05,33.61 240.05,35.56 241.2,36.71 RZ369.1 ; RE68.2 303.92,49.14 v2(304.21,49.43) ; RE63.2 328.83,38.24 v2(328.79,38.19) ; v2(49.09,4.42) 48.97,4.54 PC206.1 48.15,4.54 47.97,4.36 PR205.2 47.55,5.1 v2(47.67,5.22) ; v2(339.57,51.59) 339.38,51.4 CE52.1 338.61,51.39 UE5.5 ; v2(251.08,7.54) 250.49,8.13 250.49,11.56 251.32,12.38 251.32,16.79 250.49,17.61 250.49,20.94 252.24,22.69 255.39,22.69 v2(258.22,25.53) ; RE79.1 RE83.2 329.19,35.97 329.92,35.97 v2(329.94,35.95) ; v2(71.27,128.19) 71.24,128.16 PR4.2 ; v2(308.2,48.01) 307.87,47.69 RE505.2 ; RZ518.1 281.77,2.11 281.26,2.62 v2(281.26,3.15) ; v2(306.75,42.82) RE362.2 RE11.2 ; v2(308.08,27.19) 309.61,27.19 RE43.2 ; PR405.1 152.73,55.55 153.72,54.57 153.72,52.86 ; CE61.1 308.56,49.94 309.06,49.43 v2(309.09,49.43) ; RE25.1 321.39,27.08 v2(321.77,27.46) ; RE35.2 324.15,27 v2(324.15,26.96) ; v2(118.21,7.8) 121,7.8 122.32,6.48 123.26,6.48 123.97,7.19 137.33,7.19 137.84,7.7 v2(137.84,8.38) ; v2(49.08,57.02) 51.13,57.02 53.13,55.02 53.13,52.48 53.01,52.35 53.01,51.54 RC241.1 ; RE561.2 312.99,26.48 312.75,26.72 v2(312.29,26.72) ; v2(120.72,135.31) 120.91,135.12 PR113.1 ; v2(64.02,103.9) 64.06,103.9 64.39,103.57 64.73,103.57 64.91,103.75 PR1225.2 ; 148.51,81.8 148.48,81.83 v2(144.06,81.83) ; v2(308.83,25.2) 308.81,25.17 CE59.1 ; UE3.5 342.92,51.02 342.92,51.65 CE53.1 v2(343.71,51.65) ; RE301.2 324,45.99 v2(324.49,45.5) ; RE302.2 v2(317.29,44.47) ; PR933.1 v2(5.38,40.16)
  TOP w1.016: 84.37,112.67 85.01,113.31 100.91,113.31 102.44,111.78 109.65,111.78 115.67,117.8 118.72,117.8 121.56,120.65
  IN1 w0.508: v2(287.65,4.65) 286.72,3.72 282.98,3.72 282.41,3.15 v2(281.26,3.15) ; v2(141.14,127.13) 151.98,127.13 153.78,128.93 v2(154.86,128.93) ; v2(304.21,49.43) 304.21,47.15 306.79,44.57 306.79,42.87 v2(306.75,42.82)
  IN2 w0.508: v2(71.27,128.19) 71.83,127.63 71.83,125.35 73.63,123.55 73.63,121.64 76.66,118.62 79.45,118.62 82.72,115.34 v2(82.72,114.45) ; v2(120.72,135.31) 120.72,135.48 122.14,136.91 135.12,136.91 141.14,130.89 v2(141.14,127.13) ; v2(34.24,52.09) 34.8,52.66 40.09,52.66 42.09,54.66 42.09,54.68 43.64,56.23 48.29,56.23 v2(49.08,57.02) ; v2(322.02,23.37) 321.94,23.44 321.94,24.21 324.15,26.42 v2(324.15,26.96) ; v2(33.37,52.09) 33.02,52.45 33.02,56.91 34.4,58.29 34.4,68.22 36.34,70.17 36.34,74.69 32.36,78.67 32.36,80.61 32.86,81.11 v2(33.02,81.11) ; v2(258.22,25.53) 258.01,25.53 254.11,29.43 253.49,29.43 v2(250.89,32.02) 250.47,32.45 243.7,32.45 243.43,32.18 241.28,32.18 v2(240.88,32.58) ; v2(64.02,103.9) 64.01,103.9 63.34,104.57 63.34,106.27 65.76,108.69 70.56,108.69 71.55,107.7 v2(71.55,107.09)
  IN2 w1.016: 121.77,124.55 122.68,125.45 125.01,125.45 129.46,121.01 137.66,121.01 141.65,124.99
  IN3 w0.508: v2(347.65,109.24) 348.15,108.74 348.15,53.62 346.39,51.86 345.67,51.86 v2(345.49,52.04) ; v2(5.38,40.16) 5.38,40.54 5.89,41.05 7.79,41.05 8.94,42.2 11.39,42.2 12.39,41.2 14.36,41.2 ; 77.77,2.72 77.87,2.82 77.87,7.54 79.9,9.58 83.56,9.58 84.6,8.53 v2(85.62,8.53)
  IN3 w1.016: 31.38,52.64 19.54,52.64 15.83,48.93 15.83,42.66 14.36,41.2 ; v2(47.67,5.22) 46.81,6.09 42.99,6.09 41.55,7.53 40.39,7.53 39.55,8.38 39.55,11.31 38.97,11.89 34.59,11.89 34.42,11.72 26.4,11.72 23.92,14.2 23.92,28.63 29.36,34.06 29.36,38.52 28.59,39.29 28.59,48.32 29.86,49.59 ; 48.79,3.23 57.53,3.23 59.69,5.38 67.26,5.38
  BOTTOM w0.254: v2(306.75,42.82) 304.74,42.82 304.25,43.32 301.29,43.32 299.03,45.58 295.51,45.58 RZ377.1 294.16,45.84 292.24,45.84 290.32,43.92 RZ381.1 ; v2(47.67,5.22) 47.67,5.21 47.41,5.46 PU200.13
  BOTTOM w0.305: JLED1.1 323.04,8.56 323.25,8.78 323.84,8.78 v2(324.66,7.96) ; JKBTP1.15 137.02,9.2 v2(137.84,8.38)
  BOTTOM w0.381: UZ10.5 348.04,110.88 348.31,110.61 348.31,110.04 348.15,109.88 CZ93.1 347.43,109.46 v2(347.65,109.24) ; QZ2.2 307.91,60.75 308.59,61.43 314.82,61.43 315.51,60.73 v2(315.51,60.6) ; RE300.1 326.76,34.06 327.2,34.06 327.29,33.97 v2(327.26,33.94) ; CZ104.1 153.72,52.98 153.34,53.36 152.9,53.36 152.68,53.14 UZ34.5 ; UZ35.5 144.98,82.74 v2(144.06,81.83)
  BOTTOM w0.508: v2(330.75,11.07) 331.47,11.79 RE74.1 331.71,12.71 RE72.1 RE71.1 ; v2(328.79,38.19) 328.02,38.96 327.91,38.96 RE10.2 ; v2(306.5,11.86) 306.5,13.08 306.97,13.55 RZ9.1 ; PR1235.2 82.72,110.26 80.9,112.09 PR1231.2 81.63,113.18 PR1233.2 81.89,114.37 v2(81.96,114.45) ; v2(153.88,92.39) 153.45,91.96 RV1656.1 ; v2(328.04,37.02) 328.04,36.85 327.68,36.49 326.75,36.49 RE84.2 ; RZ8.1 310.14,13.55 310.45,13.24 v2(310.45,11.88) ; v2(309.98,24.87) 311.77,23.08 311.77,21.55 312.72,20.6 312.74,20.6 312.77,20.57 313.09,20.57 CZ82.1 313.53,20.56 314.04,21.07 v2(314.04,21.79) ; v2(324.49,45.5) 323.8,44.81 323.8,44.09 RE12.2 324.13,43.76 RE21.2 ; v2(33.02,81.11) 32.94,81.19 RT68.2 ; v2(258.22,25.53) 259.4,24.35 UE6.5 ; PR607.1 164.08,10.18 v2(163.44,9.54) 162.73,10.25 162.29,10.25 161.91,9.87 PR2013.1 ; v2(71.55,107.09) 71.55,106.55 71.12,106.12 PR1230.2 ; RE73.1 RE75.1 326.17,11.9 v2(325.78,11.9) ; PR107.1 85.18,8.66 85.49,8.66 v2(85.62,8.53) ; PR1234.2 66.72,109.04 66.72,106.45 67.92,105.26 PR1232.2 66.7,105.05 66.57,105.18 PR1259.2 65.93,105.02 64.75,103.83 64.13,103.83 64.06,103.9 v2(64.02,103.9) ; v2(179.45,31.01) 179.45,39.15 175.59,43.01 175.59,44.76 v2(175.88,45.05) ; v2(317.29,44.47) 317.29,43.84 317.55,43.59 RE92.2 ; PR418.1 155.27,63.25 155.19,63.32 PR417.1 155.19,65.16 154.29,66.06 v2(153.84,66.06) ; RE532.1 320.27,24.42 321.32,23.37 v2(322.02,23.37) ; PR1.1 5.89,41.55 5.38,41.05 v2(5.38,40.16) ; CV17.1 UV24.5 ; v2(328.16,42.39) 327.55,42.39 RE526.1 325.88,40.45 323.78,38.35 RE91.2 ; CZ104.1 v2(154.86,52.98)
  vias: v2(66.53,9.11) v2(66.53,8.47) v2(67.17,9.11) v2(67.17,8.47) v2(107.54,9.4) v2(107.57,10.08) v2(107.59,8.69) v2(107.57,8) v2(108.06,7.58) v2(108.23,10.41) v2(108.25,9.7) v2(108.25,9.02) v2(108.36,8.33) v2(108.95,9.61) v2(108.95,8.92) v2(109.27,8.34) v2(109.6,9.58) v2(109.68,8.91) v2(110.31,9.45) v2(110.38,8.75) v2(117.6,8.27) v2(121.28,122.04) v2(121.88,122.07) v2(141.14,126.24) v2(141.65,125.73) v2(148.13,105.41) v2(148.59,104.85) v2(149.14,104.34) v2(149.65,103.83) v2(150.16,103.33) v2(152.32,66.83) v2(152.57,115.06) v2(152.83,66.32) v2(152.95,67.21) v2(153.21,114.55) v2(153.21,65.68) v2(153.46,66.7) v2(155.24,52.48) v2(155.37,51.84) v2(156,52.98) v2(156,52.35) v2(156,51.59) v2(170.3,8.44) v2(178.71,30.86) v2(179.19,30.38) v2(179.75,29.87) v2(179.96,30.5) v2(180.4,29.88) v2(192.58,3.71) v2(192.71,2.82) v2(193.09,3.33) v2(193.15,3.96) v2(193.4,2.76) v2(196.44,3.07) v2(196.77,3.64) v2(197.1,3.1) v2(197.47,3.64) v2(197.79,3.1) v2(198.1,3.64) v2(198.5,3.1) v2(198.87,3.64) v2(199.21,3.1) v2(199.56,3.64) v2(199.97,3.1) v2(200.26,3.64) v2(288.29,4.65) v2(288.49,5.28) v2(288.95,4.62) v2(289.1,5.26) v2(289.68,5.23) v2(305.71,11.88) v2(305.66,11.24) v2(305.69,10.63) v2(309.81,39.63) v2(309.8,39.07) v2(311.11,11.87) v2(315.13,59.97) v2(315.22,68.67) v2(315.65,59.57) v2(315.85,68.68) v2(315.96,69.38) v2(316.02,60.13) v2(316.33,59.59) v2(316.4,71.8) v2(316.46,60.74) v2(316.56,68.68) v2(316.68,69.33) v2(316.76,60.17) v2(316.88,72.13) v2(317.12,68.91) v2(317.09,60.74) v2(328.16,42.98) v3(81.71,112.55) v3(149.53,109.37) v3(165.37,35.12)
