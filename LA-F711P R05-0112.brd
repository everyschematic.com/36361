# Allegro board LA-F711P R05-0112.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GNDA: length 49.6
  TOP w0.102: v2(348.36,44.91) 348.36,44.96 v3(347.98,45.34) ; v3(365.7,37.89) RA36.1 ; v2(355.04,32.11) 355.16,32.11 v3(355.98,31.29)
  TOP w0.203: v2(337.24,39.75) 337.42,39.57 UA1.38
  TOP w0.381: CA57.2 335.67,39.07 v2(335.67,39.57)
  TOP w0.457: v2(347.41,38.58) 347.41,38.39 347.65,38.15 CA25.2
  TOP w0.508: CA58.2 335.61,44.27 v2(335.61,44.25) ; v2(355.04,32.11) CA2.2 ; v2(360.42,25.07) 360.22,24.87 RA37.1 ; CA52.2 336.72,42.29 336.57,42.44 v2(336.57,42.77) ; v2(367.4,37.16) 366.98,37.58 RA36.1 ; CA41.2 v2(348.1,33.84) ; v2(351.18,32.36) CA3.2 ; v2(343.69,45.52) 343.99,45.21 CA35.2 344.17,44.88 CA9.2 345.07,45.47 v2(345.15,45.56)
  GND1 w0.203: 359.13,25 JHP1.5 ; JHP1.5 360.21,25.67 ; JHP1.5 360.21,25 ; JHP1.5 358.05,25 ; JHP1.5 358.05,25.67 ; JHP1.7 363.23,35.89 ; JHP1.7 364.31,35.22 ; JHP1.7 362.15,35.22 ; JHP1.7 362.15,35.89 ; JHP1.7 364.31,35.89
  VCC w0.203: 362.15,35.89 JHP1.7 ; JHP1.7 364.31,35.89 ; JHP1.7 363.23,35.89 ; 359.13,25 JHP1.5 ; JHP1.5 358.05,25 ; JHP1.5 360.21,25
  GND2 w0.203: JHP1.5 360.21,25 ; JHP1.5 359.13,25 ; JHP1.5 358.05,25 ; JHP1.5 358.05,25.67 ; JHP1.5 360.21,25.67 ; JHP1.7 364.31,35.89 ; JHP1.7 364.31,35.22 ; JHP1.7 363.23,35.89 ; JHP1.7 362.15,35.89 ; JHP1.7 362.15,35.22
  BOTTOM w0.508: v2(343.69,45.52) 343.93,45.28 CA51.2 343.75,44.64 RA44.2 ; v2(337.24,39.75) 338,38.99 RA35.1 ; v2(346.4,31.31) 346.76,31.67 DA2.2 ; CA1.1 349.17,36.74 v2(349.06,36.63) 349.07,36.62 CA4.2
  vias: v2(345.08,42.02) v2(348.83,44.44)
VBAT1_ISL88738: length 5.9
  TOP w0.203: PU901.31 7.4,32.81 7.31,32.73 7.04,32.73 6.68,32.36 v2(6.48,32.36)
  BOTTOM w0.102: PR940.2 5.18,32.28 v1(5.18,30.94)
  BOTTOM w0.254: v2(6.48,32.36) 6.52,32.41 6.7,32.41 PC950.2 7.08,32.92 5.81,32.92 PR940.2
VBUS1_ECOK: length 371.8
  TOP w0.102: v2(315.31,25.73) 315.31,26.3 v1(315.49,26.48) 316.08,27.08 316.55,27.08 316.89,27.41 316.89,29.13 317.24,29.48
  TOP w0.104: UE1.M6 317.32,31.15 317.32,29.56 317.24,29.48
  TOP w0.254: PR1220.2 PR1222.1 58.44,108.68 v2(58.73,108.38)
  IN2 w0.254: v2(86.91,110.39) 86.91,110.62 86.66,110.87 85.58,110.87 84.12,109.41 74.41,109.41 73.82,108.82 71.71,108.82 71.33,109.19 67.73,109.19 67.29,109.63 60.52,109.63 59.24,108.34 58.77,108.34 v2(58.73,108.38)
  IN3 w0.102: v2(321.28,56.9) 321.46,56.73 321.46,56.46 322.8,55.12 322.8,53.09 322.33,52.61 321.37,52.61 318.7,49.95 318.7,48.93 316.66,46.89 316.66,43.92 312.42,39.68 312.42,31.29 314.77,28.94 314.77,26.99 315.31,26.45 v2(315.31,25.73)
  BOTTOM w0.102: v2(321.28,56.9) 321.09,57.1 311.81,57.1 311.17,56.45 305.43,56.45 303.43,54.44 298.16,54.44 296.93,53.21 290.08,53.21 283.2,46.33 283.2,40.53 280,37.33 272.43,37.33 272.39,37.29 269.74,37.29 269.11,36.66 250.64,36.66 248.77,38.53 244.23,38.53 241.85,40.91 240.67,40.91 238.3,43.28 236.27,43.28 221.87,57.68 216.9,57.68 211.66,62.93 211.66,75.48 196.43,90.7 176.71,90.7 155.98,111.43 155.08,111.43 145.52,120.99 126.96,120.99 124.49,118.53 102.17,118.53 98.95,115.31 92.98,115.31 88.06,110.39 v2(86.91,110.39)
  BOTTOM w0.254: v2(86.91,110.39) 86.91,110.26 86.53,109.88 85.98,109.88 PR1257.1
VBUS2_ECOK: length 365.6
  TOP w0.102: v2(313.64,28.1) 313.82,28.28 313.82,28.49 315.32,29.99 UE1.N3
  TOP w0.254: v2(87.8,114.68) 87.58,114.68 85.11,117.14 v1(84.22,117.14) v2(83.21,117.14) ; PR24.1 65.53,111.33 PR20.2 65.96,110.51 v2(66.14,110.69)
  IN3 w0.102: v2(313.64,28.1) 313.64,29.41 312.19,30.86 312.19,39.77 316.43,44.01 316.43,46.99 318.47,49.03 318.47,50.04 321.27,52.84 322.23,52.84 322.57,53.18 322.57,55.02 320.57,57.03 320.57,57.45 v2(321.28,58.16)
  BOTTOM w0.102: v2(321.28,58.16) 320.68,57.56 311.32,57.56 310.68,56.91 305.24,56.91 303.24,54.9 297.97,54.9 296.74,53.67 289.89,53.67 282.74,46.52 282.74,40.72 280.46,38.44 279.03,38.44 278.82,38.66 272.45,38.66 271.54,37.74 268.65,37.74 268.51,37.89 266.06,37.89 266.04,37.87 250.07,37.87 248.96,38.99 244.42,38.99 241.68,41.73 240.49,41.73 238.36,43.86 236.34,43.86 222.06,58.14 217.09,58.14 212.11,63.12 212.11,76.69 196.6,92.2 176.27,92.2 146.89,121.58 126.4,121.58 124.25,119.43 100.91,119.43 98.63,117.14 v2(83.21,117.14)
  BOTTOM w0.254: v2(66.14,110.69) 70.1,110.69 70.52,110.28 70.52,110.25 70.93,109.84 70.95,109.84 71.01,109.78 73.46,109.78 74.86,111.18 74.86,114.34 77.67,117.14 v2(83.21,117.14) ; v2(87.8,114.68) 87.88,114.6 PR1242.1
VCC_GT_B+:
  vias: v1(43.66,69.4) v2(42.76,59.24) v2(42.76,58.61) v2(42.76,57.97) v2(43.39,59.24) v2(43.39,58.61) v2(43.39,57.97) v2(43.86,71.42) v2(44.01,59.22) v2(44.01,58.58) v2(44.01,57.95) v2(44.41,67.02) v2(44.42,65.91) v2(44.5,71.42) v2(44.5,70.26) v2(44.5,69.49) v2(44.5,68.73) v2(44.5,67.97) v2(44.65,59.22) v2(44.65,58.58) v2(44.65,57.95) v2(45.13,71.42) v2(45.08,67.02) v2(45.08,65.91) v2(45.77,71.42)
VCC_GT_SENSE: length 48.5
  TOP w0.254: PR1728.2 62.28,76.5 63.5,75.29 v2(63.5,74.62)
  IN1 w0.254: v2(98.87,81.24) 98.76,81.35 96.18,81.35 95.48,80.64 82.95,80.64 82.87,80.57 80.43,80.57 79.91,81.09 77.41,81.09 75.57,79.25 75.57,78.35 73.18,75.96 63.38,75.96 62.9,75.48 62.9,74.88 63.15,74.62 v2(63.5,74.62)
  BOTTOM w0.254: PR1725.1 98.13,82.92 98.34,82.7 98.34,81.74 98.84,81.24 v2(98.87,81.24) 98.87,81.22 99.62,80.46 100.8,80.46 101.06,80.21 UC1.AH38
VCC_IO_SENSE: length 19.6
  TOP w0.254: PR415.1 134.39,60.73 133.96,61.16 v2(133.96,61.26)
  IN1 w0.254: v2(133.96,61.26) 133.96,61.32 133.58,61.69 121.11,61.69 120.71,62.1 117.13,62.1 116.8,62.43 v2(116.8,62.61)
  BOTTOM w0.254: UC1.H14 116.4,62.22 v2(116.8,62.61)
VCC_SA_B+:
  vias: v1(107.26,96.51) v2(106.44,96.82) v2(106.44,96.18) v2(106.44,95.55) v2(106.46,97.65) v2(106.5,93.79) v2(106.64,92.61) v2(107.3,93.78) v2(107.31,92.61)
VCC_SA_SENSE: length 55.9
  TOP w0.254: v2(66.32,86.69) 66.19,86.56 66.19,86.24 65.83,85.88 PR1710.1
  IN1 w0.254: v2(111.86,83.72) 111.65,83.51 111.65,83.19 111.1,82.64 105.96,82.64 104,84.6 73.53,84.6 72.77,85.36 69.92,85.36 69.47,84.91 66.68,84.91 66.13,85.47 66.13,86.46 66.32,86.65 v2(66.32,86.69)
  BOTTOM w0.254: PR1714.2 111.86,84.09 v2(111.86,83.72) 111.72,83.58 111.72,82.4 v1(112.16,81.97) 113.66,80.47 UC1.M38
VCC_SENSE: length 56.1
  IN1 w0.254: v2(62.75,89.58) 62.76,89.57 62.76,87.47 66.26,83.97 72.56,83.97 73.13,83.4 82.53,83.4 83.29,82.64 86.74,82.64 87.51,83.4 102.19,83.4 103.09,82.51 103.09,82.18 v2(103.16,82.1)
  BOTTOM w0.254: RC140.2 100.75,83.86 100.81,83.92 101.17,83.92 101.18,83.91 RC221.2 101.82,84.02 103.41,84.02 PR1721.2 103.77,84.06 104.08,83.76 104.08,82.55 103.63,82.1 v2(103.16,82.1) 103.16,81.69 102.26,80.79 102.26,79.42 102,79.15 UC1.AG37 ; PR1723.1 62.3,89.26 62.52,89.48 62.65,89.48 v2(62.75,89.58)
VCCDSW_EN: length 184.2
  TOP w0.102: v2(326.8,45.59) 327.36,45.59 327.41,45.64 328.31,45.64 328.68,46.02 CE66.1 ; v2(315.43,19.44) v1(315.43,16.78) 315.43,16.37 315.71,16.09 315.71,6.62 316.61,5.71 317.97,5.71 v2(318.36,6.11)
  TOP w0.107: v2(318.12,31.15) UE1.M7
  IN1 w0.099: v2(326.8,45.59) 326.52,45.32 326.52,44.25 324.61,42.34 323.41,42.34 322.21,41.14 322,41.14 321.76,40.9 321.76,40.65 320.91,39.8 319.84,39.8 319.31,39.28 319.31,38.78 319.01,38.48 319.01,35.78 318.54,35.31 318.54,34.86 319.07,34.33 319.07,31.89 318.33,31.15 v2(318.12,31.15) 318.08,31.15 317.27,30.35 317.27,24.69 316.1,23.52 316.1,20.12 v2(315.43,19.44)
  IN2 w0.102: v2(198.45,9.19) 198.45,9.04 201.11,6.37 201.11,4.5 202.45,3.16 204.1,3.16 204.44,2.82 204.44,2.29 205.24,1.49 259.24,1.49 260.3,2.55 260.3,4.98 261.09,5.77 266.63,5.77 268.85,7.99 275.46,7.99 276.85,6.59 283.31,6.59 283.99,7.28 287.14,7.28 287.64,6.78 294.35,6.78 295.24,5.89 297.72,5.89 298.56,5.05 302.54,5.05 302.99,5.51 317.76,5.51 v2(318.36,6.11)
  BOTTOM w0.102: RH445.1 198.93,8.29 198.45,8.78 v2(198.45,9.19)
VCCDSW_EN_GPIO: length 5.6
  BOTTOM w0.102: DH1.2 195.63,7.84 v1(196.99,7.84) RH445.2 198.01,7.17 198.42,6.77 QH6.2 199.11,6.77 199.87,7.53 RH431.1
VCCDSW_EN_Q: length 4.3
  BOTTOM w0.102: v1(195.58,4.67) DH1.1 195.55,6.06 RH442.1 194.37,7.02 194.43,7.09 DH2.2
VCCMPHY_SENSE: length 35.3
  TOP w0.152: v2(181.38,9.83) 181.53,9.98 182.1,9.98 182.44,10.32 189.2,10.32 192.78,13.91 196.77,13.91 197.6,14.74 197.6,16.6 v2(197.85,16.85) ; PR314.2 172.59,9.59 173.85,9.59 v2(173.88,9.55)
  IN1 w0.152: v2(181.38,9.83) 181.23,9.98 180.43,9.98 180.15,10.26 177.95,10.26 177.38,9.69 174.02,9.69 v2(173.88,9.55)
  BOTTOM w0.089: UH1.K47 197.32,21 197.38,20.93 197.38,19.14 198.42,18.1 T76.1 197.85,16.9 v2(197.85,16.85)
VCCST_PWRGD: length 308.1
  TOP w0.102: v2(144.7,53.75) 144.2,54.25 140.71,54.25 140.2,54.76 139.47,54.76 139.09,55.14 RC78.1 139.09,57.47 RC71.2 139.12,58.92 CC301.1 ; v2(337.05,52) 337.05,52.12 337.59,52.65 344.31,52.65 344.51,52.45 346.38,52.45 347.75,51.08 347.75,49.72 347.24,49.21 UE4.4 ; v2(185.06,17.22) 184.97,17.31 184.97,17.89 v1(184.49,18.37) 182.14,20.71 182.14,20.71 182,20.85 182,22.7 180.24,24.47 180.24,28.02 180.92,28.7 180.92,31.94 174.58,38.28 170.56,38.28 170.07,37.79 v2(168.94,37.79)
  IN2 w0.102: v2(334.12,9.56) 333.44,9.56 332.36,8.48 325.96,8.48 323.78,6.3 321.65,6.3 321.37,6.58 310.55,6.58 309.34,7.79 298.69,7.79 298.05,8.43 295.03,8.43 294.43,9.03 284.06,9.03 283.33,8.29 278.81,8.29 278.05,9.05 277.04,10.06 267.81,10.06 266.64,8.89 260.38,8.89 256.75,5.26 219.88,5.26 219.65,5.04 214.6,5.04 213.09,6.55 203.94,6.55 203.35,7.14 v2(203.33,7.14) ; v2(168.94,37.79) 168.94,41.11 161.95,48.1 155.78,48.1 150.97,52.91 145.55,52.91 v2(144.7,53.75)
  IN3 w0.102: v2(185.06,17.22) 185.06,16.89 185.33,16.62 189.85,16.62 195.04,11.43 195.64,11.43 198.4,8.66 201.81,8.66 v2(203.33,7.14) ; v2(329.43,34.41) 330.63,35.61 330.63,38.01 332.12,39.5 332.12,41.39 331.53,41.98 331.53,45.46 337.05,50.98 v2(337.05,52)
  BOTTOM w0.102: RE308.1 324.24,31.28 324.35,31.28 326.5,33.43 327.6,33.43 327.73,33.55 327.91,33.55 328.77,34.41 v2(329.43,34.41) 329.6,34.41 330.02,34 330.63,34 332.39,32.23 332.39,25.77 331.15,24.52 331.15,17.47 332.57,16.05 334.37,16.05 335.58,14.84 335.58,11.14 334.12,9.68 v2(334.12,9.56)
VCCST_PWRGD_CPU: length 24.6
  TOP w0.102: RC78.2 137.29,56.61 v1(136.36,57.54) 136.14,57.76 v2(136.14,59.05)
  IN1 w0.099: v2(136.14,59.05) 135.44,59.75 133.28,59.75 132.81,60.22 117.64,60.22 v2(116.82,61.04)
  BOTTOM w0.076: v2(116.82,61.04) 116.43,61.43 UC1.H13
VCCST_PWRGD_EC: length 4.5
  TOP w0.104: UE1.K10 v2(321.32,32.75)
  BOTTOM w0.102: v1(322.55,31.46) RE308.2 322.58,30.48 RE552.2
  BOTTOM w0.104: v1(322.55,31.46) 322.52,31.49 322.04,31.49 321.74,31.79 321.74,32.33 v2(321.32,32.75)
VCCSTG_EN: length 48.6
  TOP w0.254: UZ19.4 145.62,71.93 145.69,71.85 146.73,71.85 v1(146.87,72) 146.87,72.68 v2(146.82,72.73)
  IN3 w0.254: v2(141.6,72.73) v2(146.82,72.73)
  BOTTOM w0.254: v2(146.82,72.73) 146.82,81.1 RZ320.2 146.26,82.99 UZ35.4 ; RZ120.1 152.32,54.23 151.94,54.61 143.33,54.61 140.13,57.81 140.13,59.44 138.78,60.79 138.78,68.52 141.6,71.34 v2(141.6,72.73)
VDD_ISL88738: length 15.6
  TOP w0.381: PC933.1 11.38,37.76 10.43,37.76 9.95,38.24 PR918.2
  TOP w0.508: v2(10.65,38.51) 10.61,38.51 10.56,38.56 PR918.2
  IN2 w0.508: v2(14.02,31.24) 14.62,31.84 14.62,35.61 13.12,37.11 12.05,37.11 v2(10.65,38.51)
  BOTTOM w0.457: PR919.1 9.65,39.47 10.61,38.51 v2(10.65,38.51)
  BOTTOM w0.508: PR915.2 13.15,31.28 13.98,31.28 v2(14.02,31.24)
  vias: v1(11.22,36.98)
VDDP_ISL88738: length 3.5
  BOTTOM w0.102: PC932.2 10.36,30.26 v1(10.59,30.03)
  BOTTOM w0.508: v2(11.55,30.53) 11.69,30.67 PR915.1 11.63,31.28 11.06,31.28 11.02,31.24 PC932.2
VIN_1.8VALW: length 0.7
  BOTTOM w0.102: v1(115.72,5.38) 115.72,5.75 115.95,5.98
VIN_1VS_VCCIO:
  vias: v1(159.29,58.58)
VSS_A36: length 12.4
  TOP w0.102: v2(121.49,78.93) 123.57,78.93 125.7,76.8 131.03,76.8 v1(131.1,76.73) 132,76.73 RC178.1
  BOTTOM w0.254: v2(121.49,78.93) 121.01,78.45 UC1.A36
VSS_A37: length 7.9
  TOP w0.102: v2(121.59,79.55) 122.76,79.55 123.88,80.67 123.88,83 124.06,83.18 RC179.1 124.97,83.98 v1(125.08,84.09)
  BOTTOM w0.076: v2(121.59,79.55) 121.26,79.23 UC1.A37
VSS_GT_SENSE: length 50.2
  TOP w0.254: v2(63.5,73.87) 63.46,73.84 PR1735.2
  IN1 w0.254: v2(99.52,81.26) 99.37,81.41 99.37,81.49 99.26,81.6 99.22,81.6 98.97,81.85 95.97,81.85 95.27,81.15 82.74,81.15 82.66,81.08 80.64,81.08 80.12,81.6 77.2,81.6 75.07,79.46 75.07,78.56 72.97,76.47 63.17,76.47 62.39,75.69 62.39,74.67 62.94,74.12 63.25,74.12 v2(63.5,73.87)
  BOTTOM w0.254: UC1.AH37 101.11,79.15 101.46,79.5 101.46,80.51 101.16,80.8 99.77,80.8 99.52,81.06 v2(99.52,81.26) 99.08,81.7 99.02,81.7 v1(98.75,81.97) 98.75,82.64 PR1736.1
VSS_IO_SENSE: length 51
  IN1 w0.254: v2(137.08,62.32) 136.32,61.56 136.32,60.98 135.94,60.6 133.65,60.6 133.07,61.18 120.9,61.18 120.5,61.59 116.01,61.59 v2(115.91,61.69)
  IN3 w0.254: v2(150.67,62.46) 150.67,62.76 151.15,63.25 151.15,66.46 147.61,70 137.59,70 137.08,69.49 v2(137.08,62.32)
  BOTTOM w0.254: UC1.J14 115.73,61.87 v2(115.91,61.69) ; v2(150.67,62.46) PR416.1
VSS_SA_SENSE: length 54.5
  TOP w0.254: PR1708.1 66.63,85.96 v2(66.63,85.99)
  IN1 w0.254: v2(66.63,85.99) 66.63,85.99 66.63,85.68 66.89,85.42 69.26,85.42 69.71,85.86 72.98,85.86 73.74,85.1 104.21,85.1 106.17,83.15 110.89,83.15 111.14,83.4 111.14,83.68 v2(111.11,83.72)
  BOTTOM w0.254: PR1700.2 111.12,83.97 111.12,83.72 ; v2(111.11,83.72) 111.12,83.72 ; 111.12,83.72 v1(111.12,83.15) 111.12,82.24 113.26,80.11 113.26,79.55 UC1.M37
VSS_SENSE: length 52.8
  TOP w0.203: v2(62.22,89.86) 62.22,89.86 62.22,90.38 61.6,90.99 PR1726.1
  IN1 w0.254: v2(102.58,82.1) 102.58,82.3 101.98,82.89 87.72,82.89 86.95,82.13 83.08,82.13 82.32,82.89 72.92,82.89 72.35,83.46 66.05,83.46 62.24,87.27 62.24,89.83 62.22,89.85 v2(62.22,89.86)
  BOTTOM w0.254: UC1.AG38 101.92,79.88 101.92,81.17 102.58,81.83 v2(102.58,82.1) 102.61,82.13 PR1729.2 101.81,82.89 RC221.1 101.67,82.96 RC141.1
VSSMPHY_SENSE: length 35.1
  TOP w0.152: PR315.2 172.18,10.02 172.34,9.87 173.59,9.87 v2(173.89,10.17) ; v2(197.13,16.81) 197.32,16.62 197.32,14.85 196.65,14.19 192.66,14.19 189.08,10.6 182.27,10.6 181.94,10.27 181.53,10.27 v2(181.38,10.43)
  IN1 w0.152: v2(181.38,10.43) 181.21,10.26 180.54,10.26 180.26,10.54 177.83,10.54 177.26,9.97 174.1,9.97 v2(173.89,10.17)
  BOTTOM w0.089: UH1.K46 197.08,21.36 197.08,20.96 197.19,20.86 197.19,18.4 T77.1 197.38,17.07 v2(197.13,16.81)
32KHZ_OUT: length 2.8
  TOP w0.104: UE1.F3 v2(314.92,36.75)
  BOTTOM w0.102: v2(314.92,36.75) 314.43,36.75 CE54.1 v1(313.94,38.28)
81215_ALERT: length 2.9
  TOP w0.203: PR1717.2 62.33,78.81 v1(61.64,79.5) 61.38,79.77 61.38,79.86 60.84,80.39 PU1700.41
81215_SCLK: length 2.7
  TOP w0.203: PU1700.42 60.91,80.79 62,79.7 PR1715.1
81215_SDIO: length 3.2
  TOP w0.203: PR1719.1 60.96,79.62 60.96,79.78 60.75,79.99 PU1700.40
81215_VR_HOT: length 3.3
  TOP w0.203: PR1712.1 61.32,77.79 61.32,78.13 v1(61.13,78.32) 60.82,78.64 59.88,78.64 59.73,78.79 PU1700.39
+AC_IN: length 15.5
  TOP w0.508: 37.89,113.44 37.89,110.77 39.39,109.27 39.39,105.46 39.75,105.1 PR1251.1 41.09,105.1 43.2,107.21 43.89,107.21 44.43,107.75 PQ1215.3
  vias: v2(26.64,123.62) v2(27.3,123.57) v2(27.66,123.04) v2(27.99,123.72) v2(27.99,122.45) v2(28.34,123.06) v2(28.67,123.75) v2(28.72,122.45) v2(29.05,123.06) v2(29.36,123.75) v2(29.43,122.4) v2(29.74,123.09) v2(30.12,122.48) v2(30.76,122.5) v2(41.3,115.34) v2(41.3,114.68) v2(41.64,114.21) v2(41.98,115.42) v2(41.98,114.78) v2(42.31,114.31) v2(42.67,115.44) v2(42.69,114.78) v2(43.04,114.31) v2(43.35,115.44) v2(43.38,114.79) v2(43.99,115.44) v2(43.99,114.83) v2(44.75,115.39) v3(32.85,118.5)
+BL_PWR_SRC: length 30.9
  IN2 w0.508: v2(140.93,97.18) 140.93,97.14 140.3,96.51 138.97,96.51 132.29,103.19 119.5,103.19 118.37,102.06 v2(115.46,102.06)
  BOTTOM w0.508: CV634.1 141.76,96.18 DV11.2 v2(140.93,97.18)
  vias: v2(114.23,102.15) v2(114.84,102.15) v3(115.02,106.59) v3(115.14,103.4) v3(118.64,107.94)
+BL_PWR_SRC_P:
  vias: v3(121.15,113.66)
+CHARGER_SRC:
  vias: v2(17.65,39.43) v2(17.67,38.8) v2(17.69,38.05) v2(17.67,37.31) v2(18.31,36.35) v2(18.44,40.92) v2(18.7,40.31) v2(18.96,36.36) v2(19.15,40.92) v2(19.31,39.45) v2(19.3,38.82) v2(19.31,38.07) v2(19.33,37.38) v2(19.41,40.28) v2(19.62,36.35) v2(19.81,40.92) v2(20.14,40.31) v2(20.27,36.35) v2(20.54,40.89) v3(17.84,40.98)
+COINCELL: length 5.5
  TOP w0.102: v2(295.58,5.49) v1(294.93,5.49)
  TOP w0.508: v2(295.58,5.49) 295.92,5.15 PC2.2 296.35,5.17 PR2.1
  BOTTOM w0.508: JRTC1.1 295.04,4.95 v2(295.58,5.49)
+CRT_VCC: length 42.7
  TOP w0.203: UV6.17 329.93,69.43 330.25,69.11 CV101.1
  TOP w0.508: CV101.1 330.99,69.05 330.99,68.16 CV102.1 330.81,67.97 v2(330.25,67.97)
  IN2 w0.508: v2(330.25,67.97) 330.88,67.97 331.77,68.86 331.77,70.76 333.42,72.41 335.96,72.41 336.98,73.43 345.87,73.43 351.94,79.5 351.94,84.32
  BOTTOM w0.102: v1(359.33,103.86) v2(359.33,103.28)
  BOTTOM w0.508: RV122.2 RV119.2 358.75,102.69 v2(359.33,103.28) ; RV121.2 358.57,87.15 358,86.58 357.55,86.58 355.96,84.98 UV4.3
  vias: v2(351.77,84.89) v2(352.34,84.86) v2(359.79,96.8) v2(359.79,95.27)
+DC_IN: length 30.8
  IN2 w0.508: v2(68.67,117.3) 68.56,117.2 66.19,117.2 64.41,115.42 55.4,115.42 51.65,111.67 51.65,108.83 49.83,107.01 v2(49.83,101.62)
  BOTTOM w0.508: PR1201.1 v2(49.83,101.62)
  vias: v2(68.1,120.62) v2(68.44,120.08) v2(68.71,120.62) v2(69.29,120.61) v2(69.29,118.25) v2(69.26,117.61) v2(69.88,120.61) v2(70.75,118.97) v2(70.79,119.63) v2(70.79,118.33) v2(70.8,117.69) v2(70.79,117.07) v2(70.82,116.48) v3(68.09,121.51) v3(68.69,118.76) v3(70.3,117.97)
+DC_IN_SS: length 156.2
  TOP w0.102: v3(13.62,42.29) 13.28,42.63 v2(12.94,42.63)
  IN1 w0.508: v2(27.86,125.7) 26.51,125.7 25.47,124.67 19.84,124.67 18.25,123.07 18.25,122.11 14.52,118.39 13.8,118.39 13.19,117.78 13.19,116.53 13.56,116.17 13.56,115.57 14.33,114.8 15.25,114.8 16.24,113.82 16.24,113.18 17,112.42 17,110.17 16.32,109.48 15.72,109.48 13.14,106.91 v2(13.14,102.84) ; v2(13.66,80.85) 13.66,81.24 14.99,82.57 14.99,83.74 17.19,85.94 17.19,87.3 18.03,88.14 18.03,94.48 15.74,96.77 15.74,98.39 13.95,100.19 12.46,100.19 v2(11.66,100.99)
  IN2 w0.508: v2(27.86,125.7) 28.98,125.7 32.51,122.17 32.51,119.1 36.5,115.11 38.6,115.11 40.67,113.04 47.25,113.04 51.76,117.55 57.55,117.55 60.12,120.12 v2(63.15,120.12)
  IN3 w0.508: v2(13.66,80.85) 13.66,80.07 7.53,73.94 7.53,64.17 9.7,62.01 9.7,45.36 12.43,42.63 v2(12.94,42.63) ; v2(13.14,102.84) 12.43,102.84 11.71,102.12 11.71,101.05 v2(11.66,100.99)
  BOTTOM w0.508: v2(12.94,42.63) 13.55,42.02 PD904.2
+DCIN_JACK: length 3.4
  BOTTOM w0.102: v3(64.69,119.02) v3(64.69,120.93) ; v3(66.59,115.4) 66.47,115.53 PC5.1
+DDR_VREF_A_CA: length 7.9
  TOP w0.102: RD16.1 69.77,11.24 v1(70.28,10.73)
  TOP w0.508: v2(70.97,12.86) 71.02,12.91 CD25.1 CD26.1 RD17.1 69.04,13.58 RD15.2 RD16.1
  BOTTOM w0.305: JDIMM1.164 v2(70.97,12.86)
+DDR_VREF_B_CA: length 7.2
  TOP w0.508: v2(151.79,15.72) 152.18,15.72 v1(152.38,15.52) 152.38,15.14 152.05,14.8 CD57.1 CD58.1 RD29.1 149.41,14.57 RD28.2 148.53,14.59 RD30.1
  BOTTOM w0.254: JDIMM2.164 151.97,15.54 v2(151.79,15.72)
+DDR_VREF_B_DQ: length 170.3
  TOP w0.508: RD30.2 CD62.1 147.14,13.54 146.53,14.15 v2(146.53,15.01) ; v2(63.72,51.38) 63.72,54.74 v3(65.93,56.94) 68.77,59.78 71.32,59.78 71.66,60.12 73.3,60.12 76.13,57.29 76.13,56.58 76.93,55.78 77.93,55.78 78.01,55.86 78.06,55.86 79.74,57.55 79.77,57.55 80.67,58.44 80.67,60.16 v2(81.32,60.81)
  IN1 w0.508: v2(63.72,51.38) 62.85,50.51 62.85,47.36 54.35,38.86 54.35,29.16 51.1,25.91 51.1,23.6 51.03,23.54 51.03,17.74 v2(50.34,17.04)
  IN2 w0.508: v2(50.34,17.04) 51.48,15.9 51.48,15.47 52.55,14.4 73.28,14.4 73.58,14.71 96.9,14.71 97.13,14.48 139.43,14.48 139.44,14.49 139.44,14.58 144.47,14.58 145.39,15.49 146.05,15.49 v2(146.53,15.01)
  BOTTOM w0.254: UC1.BR13 81.01,61.16 81.32,60.85 v2(81.32,60.81)
+DDR_VREF_CA: length 84.5
  TOP w0.508: v2(69.03,15.54) 69.12,15.46 RD17.2 CD31.1
  IN1 w0.508: v2(81.96,61.63) 81.95,61.63 81.77,61.81 80.86,61.81 80.49,62.18 77.69,62.18 75.76,60.25 75.17,60.25 71.69,56.77 68.42,56.77 65.81,54.16 65.81,48.46 55.42,38.07 55.42,28.52 52.14,25.25 52.14,21.89 52.05,21.8 52.05,15.05 52.35,14.75 68.29,14.75 68.98,15.44 68.98,15.49 v2(69.03,15.54)
  BOTTOM w0.254: UC1.BN13 82.31,61.25 81.96,61.6 v2(81.96,61.63)
+EC_DEBUG_VCC: length 2.8
  BOTTOM w0.102: v1(329.92,11.72) RE71.2 329.9,12.74 JDEG1.1
+EDP_VDD:
  vias: v1(140.38,105.51)
+LCDVDD: length 35.9
  TOP w0.508: 136.76,104.88 142.11,104.88 143.36,103.63 143.36,99.96 144.42,98.9 144.42,97.15 v2(146,95.58)
  TOP w1.524: 129.16,103.4 129.1,103.4 125.9,106.6
  IN2 w0.508: v2(154.87,98) 152.45,95.58 v2(146,95.58)
  BOTTOM w0.508: RV623.1 154.33,98.54 v2(154.87,98) ; DV12.2 144.99,93.2 CV636.1 144.99,94.58 v2(146,95.58) ; RV7.2 v2(111.66,102.2)
  vias: v2(108.76,104.95) v2(109.25,101.56) v2(109.27,104.47) v2(135.07,106.15) v2(135.35,105.49) v2(135.71,106.17) v3(117.82,105) v3(118.44,101.43) v3(121.7,106.19)
+LINE1-VREFO-L: length 3.2
  TOP w0.203: RA57.1 341.12,43.46 341.12,43 341.19,42.93 v1(341.19,42.85) 341.19,41.29 341.12,41.22 UA1.31
+LINE1-VREFO-R: length 5.5
  TOP w0.102: RA58.1 343.11,44.44 v1(343.11,45.68)
  TOP w0.203: UA1.30 341.52,42.59 342.01,43.08
  TOP w0.381: 342.01,43.08 342.47,43.54 RA58.1
+MIC2-VREFO: length 9.7
  TOP w0.203: UA1.29 341.92,42.25 v2(342.09,42.41)
  BOTTOM w0.508: v2(342.09,42.41) v3(345.12,39.37) 345.95,38.55 RA6.1 RA5.1
+PBATT: length 35.3
  IN2 w0.508: v2(3.4,27) 3.4,25.49 1.44,23.54 1.44,16.44 6.86,11.02 6.86,9.34 10.99,5.21 v2(13.84,5.21)
  BOTTOM w0.508: v2(3.4,27) 5.76,29.36 PR940.1
  vias: v1(13.89,1.42)
+PECI_VREF: length 4.9
  TOP w0.356: UE1.J11 v2(322.12,33.55)
  BOTTOM w0.508: RE59.2 325.34,34.57 v1(324.43,34.57) 323.13,34.57 322.88,34.31 322.88,34.16 322.88,33.97 CE25.1 322.46,33.55 v2(322.12,33.55)
+PWR_SRC: length 434.1
  TOP w0.381: PR929.2 8.28,26.25 7.21,25.18 7.14,25.18 7.14,25.16 v2(7.16,25.16)
  TOP w0.508: 136.09,113.42 141.74,113.42 145.06,110.11 145.06,99.94 v2(146.12,98.87)
  TOP w7.62: 161.18,62.32 161.18,67.5 160.14,68.54 160.14,96.39 161.2,97.45 161.2,113.77 154.7,120.27 146.98,120.27 146.98,120.27 131.76,120.27 131.73,120.23 131.73,120.41 ; 161.18,61.23 161.18,53.88
  IN1 w0.254: v2(86.23,8.97) 86.15,8.89 86.15,8.35 83.66,5.86 80.76,5.86 80.75,5.84
  IN1 w0.508: v2(16.62,41.93) 16.67,41.97 16.67,48.29 19.49,51.11 23.78,51.11
  IN1 w1.016: 85,1.84 85.06,1.77
  IN1 w2.032: 157.05,4.22 119.62,4.22 116.94,6.91 110.05,6.91 107.19,4.05 105.82,4.05 104.01,2.23 81.14,2.23
  IN3 w0.381: v2(28.09,5.78) 28.09,6.46 23.9,10.64 21.43,10.64 20.45,11.62 7.53,11.62 2.35,16.8 2.35,20.37 7.14,25.16 v2(7.16,25.16) ; v2(162.76,5.26) 162.76,4.1 165.34,1.52 178.36,1.52 184.54,7.71 187.66,7.71 190.38,4.98 190.38,3.16 192.08,1.46 272.82,1.46 277.95,6.59 282.32,6.59 283.13,5.78 285.18,5.78 287.55,8.15 297.13,8.15 298.09,7.19 298.09,5.93 298.84,5.18 302,5.18 302.66,5.84 302.66,7.4 303.27,8.01 312.59,8.01 v2(313.37,8.79)
  BOTTOM w0.254: v2(86.23,8.97) 86.23,8.99 85.9,9.32 85.62,9.32 85.15,9.79 PR102.2
  BOTTOM w0.508: v2(16.62,41.93) PD901.2 ; v2(313.37,8.79) 313.59,9.01 LZ2.1 ; QV18.3 148.32,98.43 147.89,98.87 v2(146.12,98.87)
  vias: v2(21,15.85) v2(21,15.19) v2(21,14.53) v2(20.98,13.89) v2(20.98,13.23) v2(21.74,14.27) v2(21.74,13.64) v2(21.76,16.23) v2(21.76,15.57) v2(21.76,14.91) v2(25.37,36.75) v2(25.37,36.16) v2(25.37,35.57) v2(26.13,36.75) v2(26.13,36.16) v2(26.13,35.57) v2(26.89,36.75) v2(26.89,36.16) v2(26.89,35.57) v2(27.66,36.75) v2(27.66,36.16) v2(27.66,35.57) v2(27.96,8.83) v2(28,8.15) v2(28.42,36.75) v2(28.42,36.16) v2(28.42,35.57) v2(28.65,8.83) v2(28.69,8.15) v2(29.27,8.85) v2(29.31,8.18) v2(29.94,8.85) v2(29.98,8.18) v2(30.59,8.83) v2(30.63,8.15) v2(31.23,8.84) v2(31.26,8.17) v2(31.85,8.81) v2(31.89,8.14) v2(32.46,8.79) v2(32.5,8.11) v2(33.09,9.36) v2(33.09,8.74) v2(33.13,8.06) v2(33.71,9.37) v2(33.75,8.71) v2(33.77,8.05) v2(35.51,9.84) v2(35.51,9.28) v2(35.52,8.65) v2(35.51,7.99) v2(35.51,7.29) v2(35.85,54.93) v2(35.85,54.16) v2(36.45,54.93) v2(36.45,54.16) v2(37.09,54.94) v2(37.09,54.18) v2(37.79,57.57) v2(37.79,56.93) v2(37.79,56.17) v2(37.79,55.54) v2(37.78,54.94) v2(37.78,54.18) v2(38.52,54.91) v2(38.52,54.15) v2(38.55,57.57) v2(38.55,56.93) v2(38.55,56.17) v2(38.55,55.54) v2(39.15,57.56) v2(39.15,56.92) v2(39.15,56.16) v2(39.15,55.52) v2(39.15,54.93) v2(39.15,54.16) v2(39.72,57.56) v2(39.72,56.92) v2(39.72,56.16) v2(39.72,55.52) v2(39.75,54.94) v2(39.75,54.18) v2(40.12,4.06) v2(40.14,3.38) v2(40.78,4.06) v2(40.78,3.34) v2(41.47,4.1) v2(41.47,3.34) v2(42.12,4.08) v2(42.12,3.31) v2(79.38,5.83) v2(79.42,5.1) v2(79.42,4.47) v2(79.42,3.83) v2(80.09,5.85) v2(80.18,5.1) v2(80.18,4.47) v2(80.18,3.83) v2(135.17,112.55) v2(135.3,113.18) v2(161.27,6.26) v2(161.97,6.2) v2(162.47,5.83) v2(164.61,38.63) v2(164.68,40.42) v2(164.65,39.84) v2(164.65,39.24) v2(165.24,38.66) v2(165.3,40.42) v2(165.31,39.85) v2(165.27,39.26) v2(165.91,40.42) v2(165.92,39.83) v2(165.9,39.23) v2(165.87,38.62) v3(161.13,44.93)
+PWR_SRC_AC:
  vias: v2(17.7,47.14) v2(17.7,46.38) v2(17.68,45.62) v2(18.44,48.2) v2(19.2,48.2) v2(19.96,48.2) v2(20.68,48.21) v2(21.41,48.22) v2(21.51,47.27) v2(21.51,46.51) v2(21.51,45.74) v2(22.14,47.01) v2(22.14,46.13) v2(22.18,45.43) v3(18.87,51.27)
+PWR_SRC_R: length 3.1
  BOTTOM w0.102: v1(312.86,11.1) 312.71,10.95 312.71,10.09 LZ2.2
  BOTTOM w0.305: JUSH1.1 312.33,9.65 LZ2.2
+REGCTL_PNP10:
  vias: v1(325.81,86.19)
+RREF:
  vias: v1(14.7,65.32)
+RSVD_VCC3P3_1: length 3
  TOP w0.508: 324.84,83.34 324.84,83.26 v1(325.53,82.57) 326.04,82.06 RL6.1
+RTC_CELL: length 160.9
  TOP w0.508: RE551.2 309.57,57.26 309.88,56.96 309.88,56.05 QE15.3 310.78,55.14 v2(310.96,55.14) ; v2(281.09,11.06) 281.1,11.07 281.1,14.05 288.66,21.61 288.66,22.12 291.91,25.38 291.91,26.53 292.33,26.94 v3(292.33,30.96) 292.33,33.39 293.73,34.79 293.73,35.69 297.4,39.37 297.4,45.26 297.67,45.52 297.67,51.89 298.75,52.97 301.33,52.97 301.9,53.54 304.29,53.54 304.39,53.44 306.12,53.44 310.7,48.86 310.7,47.72 311.25,47.17 312.24,47.17 v2(312.85,47.78) 313.04,47.97 RE31.1 ; v2(295.96,9.93) 295.96,9.93 295.96,9.93 296.07,9.82 PC3.1 PD3.1 ; v2(352.58,41.86) 351.76,41.86 351.07,41.17 351.07,40.92 RA54.2
  IN1 w0.508: v2(310.96,55.14) 310.96,54.98 312.05,53.89 312.05,48.58 v2(312.85,47.78)
  IN2 w0.508: v2(312.85,47.78) 316.38,47.78 317.22,46.94 326.75,46.94 327.62,46.08 328.78,46.08 329.6,46.9 332.7,46.9 333.36,47.56 341.96,47.56 343.71,49.31 346.97,49.31 351.71,44.58 351.71,42.73 v2(352.58,41.86)
  BOTTOM w0.508: v2(295.96,9.93) 295.96,9.59 294.97,8.6 293.62,8.6 290.95,5.93 284.17,5.93 283.16,6.93 283.16,8.66 281.09,10.74 v2(281.09,11.06) ; v2(312.85,47.78) 313.97,47.78 316.38,45.37 316.38,44.25 316.66,43.97 RE507.2 RE324.2 RE508.2 RE32.2
+RTC_CELL_PCH: length 142.6
  TOP w0.508: RE546.1 312,53.87 QE15.1 310.32,53.87 308.71,55.48 CE63.1 308.48,55.52 RE551.1 306.98,56.35 305.94,57.39 302.79,57.39 301.91,56.51 301.91,54.66 300.97,53.72 298.26,53.72 297.03,52.49 297.03,45.78 296.77,45.52 296.77,39.63 293.09,35.95 293.09,35.05 291.17,33.14 291.17,29.38 288.82,27.03 286.47,27.03 285.23,25.78 285.23,19.08 280.46,14.31 280.46,11.14 v2(280.41,11.09)
  IN2 w0.508: v2(280.41,11.09) 280.01,11.09 278.1,12.99 259.52,12.99 256.48,9.95 243.57,9.95 243.14,10.39 238.62,10.39 238.41,10.18 223.29,10.18 221.51,11.96 214.99,11.96 214.19,12.76 v2(214.19,13.06)
  BOTTOM w0.508: RH200.1 213.83,11.59 214.36,12.12 214.36,12.89 214.2,13.06 v2(214.19,13.06)
  vias: v3(214.32,12.33)
+RTC_CELL_VBAT: length 3.1
  TOP w0.33: v2(314.52,40.92) UE1.A2
  BOTTOM w0.102: v1(314.69,40.28) 314.52,40.45 v2(314.52,40.92)
  BOTTOM w0.508: v2(314.52,40.92) 314.28,41.16 CE11.1 314.28,41.9 313.99,42.19 RE32.1
+SDC_IN: length 161.3
  TOP w0.508: 55.39,118.95 55.39,119.1 54.25,120.24 PQ1203.3 53.08,120.22 52.37,120.22 51.99,120.6 PR1202.1 PC1203.1 PR1207.1 ; PR944.1 15.37,37.2 v2(15.13,37.44) 14.89,37.68 14.89,40.31 14.39,40.82 v2(10.97,40.82)
  TOP w3.302: 41.27,88.79 39.37,86.88 39.37,81.43 35.61,77.67 9.62,77.67 5.25,73.3 5.25,63.07
  IN1 w3.302: 6.92,66.06 6.93,66.08 6.93,74.32 8.68,76.07 28.85,76.07 31.16,78.38 35.1,78.38 38.29,81.57 38.29,88.19 41.32,91.22
  IN2 w0.508: v2(5.34,58.8) 5.34,55.9 10.97,50.28 v2(10.97,40.82)
  BOTTOM w0.508: PQ5.3 57.69,109.21 PR10.1 55.28,109.21 54.84,108.76 49.9,108.76 49.48,109.19 49.48,112.93 v2(51.86,115.32) ; PR943.2 15.27,37.3 v2(15.13,37.44)
  vias: v2(3.78,61.12) v2(3.78,60.36) v2(3.78,59.6) v2(3.82,58.92) v2(4.42,60.74) v2(4.42,59.98) v2(4.45,59.24) v2(42.21,96.67) v2(42.21,95.91) v2(42.24,95.17) v2(42.64,94.55) v2(42.97,96.67) v2(42.97,95.91) v2(43.01,95.22) v2(43.73,90.96) v2(43.73,90.07) v2(43.73,89.05) v3(42.6,92.07)
+SDREG2: length 3.8
  TOP w0.102: CR15.1 v1(21.79,72.29)
  TOP w0.508: CR15.1 20.75,70.85 20.14,70.24 20.14,69.8
+SIM_PWR: length 44.9
  IN1 w0.508: v2(333.52,59.44) 333.92,59.44 335.18,60.7 341.37,60.7 342,60.07 344.18,60.07 347.15,57.09 349.34,57.09 v2(349.9,56.53)
  IN3 w0.508: v2(349.9,56.53) 350.03,56.4 350.03,52.09 348.67,50.74 348.67,48.84 347.72,47.89 v2(347.72,46.24)
  BOTTOM w0.305: v2(333.52,59.44) 333.4,59.56 JNGFF2.36
  BOTTOM w0.508: v2(349.9,56.53) 350.42,56.01 v1(350.42,54.51) CZ41.1 CZ37.1 351.11,52.03 352.09,51.05 353.75,51.05 355.47,52.76 JSIM1.1 ; v2(347.72,46.24) 348.69,47.21 RZ335.1
+TBTA_LDO_BMC: length 2.5
  BOTTOM w0.076: UT5.E1 29.37,87.69
  BOTTOM w0.104: 29.37,87.69 28.64,86.96 CT71.1
+TBTA_VBUS:
  vias: v2(6.9,115.11) v2(6.88,112.22) v2(9.13,115.44) v2(9.15,114.83) v2(9.44,112.23) v2(9.79,115.44) v2(9.76,114.86) v2(9.83,111.78) v2(10.21,112.23) v2(10.4,115.44) v2(10.37,114.86) v2(10.46,111.66) v2(10.84,123.21) v2(10.84,122.45) v2(10.84,121.82) v2(10.77,121.06) v2(10.97,111.91) v2(11.22,123.85) v2(11.6,123.21) v2(11.6,122.45) v2(11.6,121.82) v2(11.55,121.08) v2(11.98,123.85) v2(12.24,121.31) v2(12.26,120.57) v2(12.75,123.85) v2(13.05,121.18) v3(12.8,122.62)
+TBTA_VBUS_1: length 4.1
  BOTTOM w0.508: PR1239.1 41.28,98.34 39.46,98.34 39.16,98.63 38.12,98.63 v2(37.87,98.37)
  vias: v2(20.24,122.83) v2(20.24,122.05) v2(20.21,121.28) v2(20.65,120.73) v2(20.85,122.81) v2(20.9,122.05) v2(20.98,121.28) v2(21.43,120.7) v2(21.56,122.81) v2(21.61,122.02) v2(21.69,121.26) v2(22.09,123.65) v2(22.81,123.65) v2(23.47,123.62) v2(32.25,113.42) v2(32.66,112.76) v2(32.84,113.33) v2(33.19,112.28) v2(33.35,112.88) v2(33.82,112.23) v2(35.19,85.21) v2(35.86,90.45) v2(35.86,89.86) v2(36.5,90.45) v2(36.5,89.81) v2(38.38,92.1) v2(38.4,91.46) v3(35.9,93.92)
+USB_EX2_PWR: length 2
  TOP w0.102: v3(16.94,94.35) 16.58,94.71 JUSB2.1
+USB_EX3_PWR:
  vias: v2(91.16,123.53) v2(91.87,123.53) v2(92.5,123.53) v2(93.16,123.55) v3(90.37,124.27)
+UZ12_TPM: length 4.7
  TOP w0.254: UZ12.8 245.44,33.67 v1(245.64,33.87) 245.79,34.02 CZ50.1
  TOP w0.381: CZ75.1 245.07,34.78 CZ50.1
  TOP w0.508: RZ367.2 244.13,34.74 RZ89.2 CZ75.1
+UZ12_VHIO: length 16.6
  TOP w0.254: UZ12.22 247.94,27.14 247.95,27.14 247.95,26.6 248.35,26.2 v3(249.64,26.2) 250.28,26.2 250.53,26.45 250.53,27.22 v2(250.58,27.27)
  IN2 w0.508: v2(250.58,27.27) 250.58,26.89 249.5,25.81 244.01,25.81 243.32,26.5 v2(243.32,29.92)
+VCHGR: length 1.1
  TOP w0.102: 24.58,5.61 24.58,5.7 v3(25.32,6.44)
+VHDMI_VCC: length 1.9
  TOP w0.508: RV22.2 117.6,126.14 v2(118.23,125.5) ; RV23.2 114.25,125.73 v2(114.25,125.48)
  vias: v3(116.49,122.97)
+VR_CAP: length 23.5
  TOP w0.356: UE1.C10 v2(321.32,39.15)
  IN2 w0.508: v2(309.7,42.3) 310.36,41.64 312.2,41.64 313.94,39.9 320.59,39.9 321.32,39.18 v2(321.32,39.15)
  IN3 w0.508: v2(309.7,42.3) 309.8,42.2 309.8,41.66 308.99,40.85 308.99,38.73 310.51,37.21 310.51,35.89 309.98,35.36 309.98,34.3 v2(310.52,33.76)
  vias: v1(311.58,33.36)
+Z4012: length 2.7
  TOP w0.102: PR2.2 297.92,6.09 v3(298.6,5.41)
  TOP w0.508: PR2.2 297.32,6.1 PD3.2
AC1_DISC#: length 137.4
  TOP w0.254: v2(6.02,48.92) 5.51,48.41 PR939.1
  IN1 w0.254: v2(64.28,104.5) 63.42,104.5 61.87,102.95 52.8,102.95 51.99,102.13 51.99,100.97 51.71,100.69 35.33,100.69 34.81,100.16 32.43,100.16 v2(32.3,100.29) 32.3,100.61 31.86,101.05 28.11,101.05 27.67,101.5 26.65,101.5 25.71,100.56 21.78,100.56 18.73,103.61 17.89,103.61 16.31,102.03 14.93,102.03 v2(14.77,101.88)
  IN3 w0.254: v2(6.02,48.92) 6.47,49.38 6.47,61.37 4.81,63.03 4.81,77.35 9.74,82.28 14.3,82.28 14.91,82.89 14.91,84.48 16.4,85.98 16.4,95.41 15.27,96.54 15.27,101.38 v2(14.77,101.88)
  BOTTOM w0.254: v2(32.3,100.29) 32.34,100.29 33.42,99.22 36.31,99.22 38.06,97.46 38.25,97.46 39.01,96.7 39.01,94.06 39.42,93.65 39.66,93.65 39.99,93.32 39.99,92.99 39.72,92.72 39.72,91.36 39.17,90.82 39.17,90.38 38.66,89.88 RT72.2 ; v2(64.28,104.5) 63.77,104.5 63.29,104.98 v1(63.29,106.02) PR1244.1
AC1_DISC#_R: length 3
  BOTTOM w0.076: UT5.G11 36.68,88.69
  BOTTOM w0.104: 36.68,88.69 36.77,88.69 37.75,89.67 RT72.1
AC_DIS: length 377.1
  TOP w0.102: RE83.1 328,36.24 327.22,36.24 327.06,36.4 325.21,36.4
  TOP w0.104: UE1.H12 322.85,34.42 323.52,34.42 324.46,35.36 v2(324.93,35.36) 324.99,35.43 324.99,36.18 325.21,36.4
  IN2 w0.102: v2(322.98,49.55) 322.64,49.55 322.29,49.2 321.46,49.2 320.62,50.04 317.85,50.04 316.65,51.23 308.58,51.23 308.02,50.67 304.52,50.67 300.09,46.24 292.91,46.24 289.81,43.13 283.34,43.13 281.64,41.43 280.09,41.43 279.15,40.49 275.08,40.49 273.78,39.19 272.31,39.19 271.77,38.65 269.22,38.65 268.39,37.81 267.2,37.81 266.2,36.82 250.43,36.82 248.97,38.28 244.66,38.28 244.2,38.73 240.58,38.73 236.12,43.19 234.97,43.19 222.77,55.39 218.14,55.39 213.43,60.1 188.81,60.1 184.77,56.06 181.94,56.06 180.88,57.11 v2(180.63,57.11)
  BOTTOM w0.102: v2(324.93,35.36) 324.78,35.36 324.77,35.37 322.11,35.37 321.7,35.77 321.7,36.11 321.44,36.37 321.16,36.37 320.94,36.59 320.94,38.51 321.19,38.76 321.47,38.76 322.05,39.34 322.05,39.47 322.26,39.68 322.26,40 322.75,40.49 322.75,40.98 322.7,41.03 322.7,42.59 321.78,43.52 321.78,44.06 321.23,44.6 321.23,46.58 322.86,48.21 322.86,49.39 322.98,49.51 v2(322.98,49.55) ; v2(180.63,57.11) 180.56,57.17 177.81,57.17 v1(175.75,55.12) 168.68,48.04 165.12,48.04 156.27,39.19 39.57,39.19 35.12,43.64 32.79,43.64 28.6,47.83 25.47,47.83 23,50.3 16.23,50.3 14.53,48.6 14.33,48.6 14.09,48.36 14.09,47.45 13.04,46.41 9.34,46.41 PR927.1 7.61,44.66 PQ909.2
AC_DISC#: length 360.7
  TOP w0.254: UE1.E13 323.32,37.24 v2(323.01,37.55) ; PR1223.1 70.06,104.62 70.05,104.63 v1(70.05,105.36) 68.75,106.65 68.75,107.16 v2(68.58,107.34) 68.03,106.79 67.22,106.79 67.04,106.97 65.67,106.97 64.61,108.03 PR25.1
  IN2 w0.254: v2(72.18,107.21) 72.18,106.84 71.38,106.04 69.62,106.04 68.58,107.09 v2(68.58,107.34) ; v2(322.99,50.52) 321.53,50.52 317.81,54.24 315,54.24 313.12,56.12 305.46,56.12 299.06,49.73 287.24,49.73 281.09,43.57 275.45,43.57 274.1,42.23 263.05,38.91 262.16,38.91 261.91,38.91 261.8,38.81 253.88,38.81 253.63,39.06 251.16,39.06 250.05,40.18 246.92,40.18 245.4,41.7 240.46,41.7 235.6,46.56 234.94,46.56 222.49,59.02 217.31,59.02 212.26,64.06 212.26,87.02 180.21,119.07 124.81,119.07 119.8,114.06 102,114.06 101.37,114.69 89.82,114.69 v2(89.45,114.32)
  BOTTOM w0.254: v2(322.99,50.52) 323.47,50.04 323.47,48.39 321.53,46.46 321.53,44.73 322.08,44.18 322.08,43.64 323.01,42.72 323.01,41.12 323.03,41.09 323.03,40.05 322.33,39.35 322.33,38.09 322.87,37.55 v2(323.01,37.55) ; v2(72.18,107.21) 72.18,107.43 76.5,111.74 PR1245.1 75.94,112.22 75.74,112.42 75.74,113.64 77.13,115.04 79.14,115.04 79.55,114.63 79.55,114.17 78.93,113.55 PQ1210.6 78.99,113.18 PR1231.1 79.98,115.52 80.31,115.85 87.93,115.85 v2(89.45,114.32) 89.45,112.29 88.95,111.78 87.6,111.78 PC1217.1 86.41,112.42 86.03,112.8 86.03,113.31 85.77,113.56 85.39,113.56 85.28,113.45 PQ1211.6 85.28,112.64 84.93,112.29 84.12,112.29 83.98,112.15 PQ1211.3
AC_PRESENT: length 121.9
  TOP w0.089: v2(318.16,29.12) 318.28,29.25 318.28,30.08 318.84,30.63 318.84,32.72 319.26,33.15 UE1.K8
  IN2 w0.102: v2(221,22.24) 221.18,22.06 222.55,22.06 222.93,22.44 225.71,22.44 226.22,22.96 229.09,22.96 229.86,23.72 232.41,23.72 233.6,22.53 233.6,22.34 233.84,22.1 235.65,22.1 237.8,24.26 256.33,24.26 256.66,23.93 261.63,23.93 264.54,21.02 280.31,21.02 283.87,24.58 283.87,26.94 284.56,27.63 289.97,27.63 292.05,29.72 297.22,29.72 301.17,33.67 305.11,33.67 306.32,32.46 309.38,32.46 311.61,30.23 312.91,30.23 314.26,28.88 317.92,28.88 v2(318.16,29.12)
  BOTTOM w0.089: UH1.BG42 215.5,23.38 217.78,23.38 218.66,22.5 218.74,22.5 218.9,22.35 218.94,22.35
  BOTTOM w0.102: RH243.1 221.5,21.78 221.04,22.24 v2(221,22.24) 220.82,22.06 219.23,22.06 218.94,22.35 218.94,22.35 ; v2(318.16,29.12) v1(318.8,29.12)
ACAV_IN: length 354
  TOP w0.089: v2(319.53,40.8) 319.62,40.7 319.62,40.13 319.54,40.05 319.09,40.05 318.82,39.78 318.82,39.4 318.52,39.09 UE1.C7
  TOP w0.102: v1(16.53,45.93) PR946.2 15.63,45.83 PR953.1 15.08,44.51 v2(13.77,44.51)
  IN2 w0.102: v2(181.7,55.73) 181.87,55.55 184.59,55.55 188.9,59.87 213.34,59.87 218.05,55.16 222.35,55.16 234.55,42.96 236.03,42.96 240.48,38.51 243.93,38.51 244.38,38.05 248.87,38.05 250.33,36.59 266.3,36.59 267.29,37.59 268.48,37.59 268.73,37.83 271.28,37.83 272.41,38.96 273.88,38.96 275.18,40.27 279.25,40.27 280.09,41.11 281.63,41.11 283.07,42.54 289.54,42.54 293.01,46.01 300.18,46.01 304.03,49.86 315.4,49.86 315.5,49.76 319.58,49.76 v2(319.71,49.63)
  BOTTOM w0.102: v2(181.7,55.73) 181.64,55.79 178.13,55.79 169.18,46.84 165.62,46.84 156.77,37.99 35.21,37.99 32.45,40.74 30.37,40.74 22.01,49.1 18.02,49.1 15.83,46.91 15.83,46.19 14.81,45.17 14.43,45.17 v2(13.77,44.51) ; v2(319.53,40.8) 319.22,41.11 319.22,41.42 319.49,41.7 319.49,43.98 319.5,43.98 319.5,44.73 320.24,45.48 320.24,47.41 320.47,47.64 320.47,48.87 v2(319.71,49.63)
ACAV_IN1: length 11.7
  TOP w0.102: PR942.1 v1(8.1,44.28) 8.1,43.92 8.99,43.03 v2(8.99,41.15) 9.34,41.15 9.95,40.53 PR918.1 ; v2(7.79,40.16) 7.29,39.65 PR928.1
  IN1 w0.099: v2(7.79,40.16) 8.28,40.64 8.48,40.64 v2(8.99,41.15)
  BOTTOM w0.102: v2(7.79,40.16) PR925.1 7.99,41.62 PQ909.1
ACIN_ISL88738: length 8.5
  TOP w0.203: PU901.19 10.41,36.94 v2(10.54,37.07)
  TOP w0.254: PC955.1 14,37.55 v2(14.14,37.41) 14.46,37.1 PR944.2
  IN3 w0.254: v2(10.54,37.07) 10.88,37.41 v2(14.14,37.41)
  BOTTOM w0.102: PR945.1 11.5,36.41 v1(11.54,36.45)
  BOTTOM w0.254: PR945.1 10.44,36.97 v2(10.54,37.07)
ACOK_ISL88738: length 3.4
  TOP w0.203: PU901.24 8.41,36.11
  TOP w0.254: 8.41,36.11 8.24,36.28 7.81,36.28 7.29,36.81 v1(7.29,37.6) PR928.2
ADJ_1.2V: length 4.5
  TOP w0.102: PR512.2 v1(143.99,127.08)
  TOP w0.254: PC509.2 146.43,127.08 146.87,126.64 PU502.3 ; PC509.2 PR510.1 ; PC509.2 PR512.2
ADP_ISL88738: length 2.9
  BOTTOM w0.102: v1(15.33,35.24) 15.17,35.24 PR943.1
  BOTTOM w0.508: v2(13.13,36.22) 13.45,36.54 PR943.1
ALW_PWRGD_3V_5V: length 278
  TOP w0.102: v2(82.23,8.96) v1(81.6,8.96) ; UZ6.2 313.15,22.17 313.31,22.02 313.31,21.09 313.15,20.94 313.15,16.92 315.45,14.62 315.45,6.2 316.29,5.36 317.09,5.36 v2(317.42,5.03)
  IN1 w0.099: v2(317.42,5.03) 317.56,4.89 317.56,3.67 315.48,1.6 296.24,1.6 295.68,2.16 291.89,2.16 291.18,1.45 286.65,1.45 278.41,1.45 278.05,1.81 277.29,2.58 277.29,3.98 275.68,5.58 269.91,5.58 265.87,1.55 216.74,1.55 215.26,3.02 213,3.02 212.43,2.45 211.4,2.45 208.18,5.66 198.99,5.66 198.67,5.35 196.11,5.35 195.8,5.66 193.99,5.66 193.43,6.22 v2(193.43,6.92) 191.63,6.92 188.69,9.85 186.11,9.85 184.15,11.82 184.15,14.02 183.57,14.59 181.9,14.59 180.49,13.18 177.75,13.18 176.58,12.01 171.4,12.01 170.76,11.38 157.9,11.38 157.28,10.76 148.03,10.76 147.01,9.74 142.34,9.74 142.07,9.47 131.49,9.47 130.43,10.54 110.16,10.54 109.29,11.41 99.49,11.41 98.68,12.22 92.1,12.22 91.47,11.58 89.28,11.58 88.64,10.95 85.9,10.95 83.91,8.96 v2(82.23,8.96)
  BOTTOM w0.102: v2(193.43,6.92) 192.73,7.62 DH2.1
  BOTTOM w0.254: v2(82.23,8.96) PR120.2 PR119.2
ALWON: length 284
  TOP w0.104: UE1.A5 v2(316.92,41.43)
  IN3 w0.102: v2(320.58,61.73) 322.12,60.19 322.12,56.45 323.32,55.25 323.32,52.58 318.85,48.11 318.85,43.35 316.93,41.43 v2(316.92,41.43)
  BOTTOM w0.102: PR114.1 119.66,126.75 120.74,126.75 121.25,127.26 ; PD100.2 121.14,128.37 121.25,128.26 121.25,127.26 ; v2(320.58,61.73) 320.47,61.84 319.74,61.84 318.79,62.79 301.43,62.79 293.23,54.58 289.28,54.58 279.32,44.63 278.62,44.63 270.66,41.27 269.64,41.01 264.36,38.79 250.45,38.79 249.33,39.91 244.8,39.91 241.62,43.09 240.43,43.09 238.52,45 236.58,45 222.42,59.16 217.36,59.16 213.03,63.5 213.03,77.76 167.06,123.72 v1(151.34,123.72) 132.38,123.72 130.73,125.37 122.05,125.37 121.25,126.18 121.25,127.26
AR_DET#: length 13.9
  TOP w0.102: v2(220.77,36.59) v1(221.24,36.59) 221.38,36.73 223.27,36.73 223.4,36.85 224.2,36.85 224.53,36.52 RH400.1
  IN1 w0.122: v2(220.77,36.59) 220.77,36.56 220.39,36.56 220.12,36.29 213.14,36.29 v2(212.88,36.56)
  BOTTOM w0.089: v2(212.88,36.56) UH1.BB16
  BOTTOM w0.102: RH401.1 221,37.53 221,36.82 v2(220.77,36.59)
AUD_AZACPU_SCLK: length 107.1
  IN1 w0.099: v2(172.88,67.02) 163.15,67.02 159.47,70.7 150.68,70.7 149.09,69.11 140.64,69.11 138.91,67.39 120.96,67.39 119.6,68.74 119.6,69.06 119,69.67 119,69.77 v2(116.76,72.01)
  BOTTOM w0.076: UC1.G27 116.76,72.13 v2(116.76,72.01)
  BOTTOM w0.107: v2(172.88,67.02) 173.06,67.2 190.64,67.2 197.24,60.59 204.12,60.59 207.16,57.55 207.61,57.1 207.61,56.55 210.57,53.58 210.57,52.03 RH38.1
AUD_AZACPU_SCLK_R: length 10.5
  BOTTOM w0.089: UH1.AM3 208.52,42.94 208.52,45.22 209.86,46.56 209.86,47.05 v1(210.79,47.98) 211.62,48.81 211.62,50.17
  BOTTOM w0.107: 211.62,50.17 211.62,50.42 211,51.04 RH38.2
AUD_AZACPU_SDI: length 19.4
  IN3 w0.102: v2(123.92,79.88) 123.92,79.12 120.7,75.9 120.7,75.13 119.87,74.3 118.67,74.3 118.11,73.74 117.49,73.74 v2(117.37,73.62)
  BOTTOM w0.076: UC1.G29 117.08,73.91 v2(117.37,73.62)
  BOTTOM w0.102: v2(123.92,79.88) 123.95,79.91 123.97,79.91 125.4,81.33 125.4,83.16 125.68,83.44 125.68,85.47 125,86.15 RC66.1
AUD_AZACPU_SDI_R: length 131.8
  TOP w0.102: v2(184.32,74.42) 184.73,74.42 v1(188.74,70.4) 193.09,66.05 v2(193.09,65.62)
  BOTTOM w0.089: 212.23,50.17 212.23,49.95 212.23,48.93 210.05,46.74 210.05,46.44 208.69,45.08 208.69,42.69 208.64,42.64 UH1.AN3
  BOTTOM w0.102: v2(184.32,74.42) 180.65,74.42 175.08,79.98 162.68,79.98 153.74,88.92 145.46,88.92 144.79,89.6 136.61,89.6 135.12,91.08 132.09,91.08 126.75,96.43 123.29,96.43 122.05,95.19 122.05,89.5 122.78,88.78 125.42,88.78 125.91,88.28 RC66.2 ; 212.23,50.17 212.23,52.79 208.22,56.8 208.22,57.36 204.38,61.2 197.5,61.2 193.09,65.6 v2(193.09,65.62)
AUD_AZACPU_SDO: length 107.2
  IN1 w0.099: v2(173.29,66.4) 172.89,66 163.31,66 159.24,70.08 151.27,70.08 147.71,66.52 121.08,66.52 120.84,66.76 119.92,66.76 119.45,67.23 119.45,68.04 119,68.49 119,68.81 118.26,69.54 118.26,69.6 117.79,70.07 117.13,70.07 v2(116.71,70.49)
  BOTTOM w0.102: UC1.G25 117.08,70.86 v2(116.71,70.49) ; v2(173.29,66.4) 173.47,66.58 190.21,66.58 196.86,59.93 203.91,59.93 207,56.85 207,56.29 209.69,53.6 RH39.1
AUD_AZACPU_SDO_R: length 9.8
  BOTTOM w0.089: UH1.AM2 208.15,43.43 208.34,43.62 208.34,45.31 209.67,46.64 209.67,47.34 211.21,48.88 v1(211.21,49.33) 211.21,49.97 211.01,50.17
  BOTTOM w0.102: 211.01,50.17 210.81,50.37 209.75,50.37 RH39.2
AUD_HP_NB_SENSE: length 21.1
  TOP w0.102: v2(348.35,31.44) 348.1,31.19 v1(347.65,31.19)
  TOP w0.254: v2(348.35,31.44) 348.1,31.68 RA60.2
  IN2 w0.254: v2(349.8,30.76) 354.76,30.76 355.77,29.74 355.77,26.06 357.37,24.46 360.67,24.46 JHP1.6
  BOTTOM w0.254: v2(348.35,31.44) 348.58,31.67 DA2.3 349.8,31.12 v2(349.8,30.76)
AUD_HP_OUT_L: length 23.3
  TOP w0.381: v2(348.01,43.55) v1(349.59,43.55) 350.18,42.96 RA7.2 ; LA15.1 349.04,32.42 349.04,33.67 v2(349.01,33.7) ; RA57.2 v2(341.45,45.32)
  IN1 w0.381: v2(341.45,45.32) 341.45,44.98 342.09,44.34 347.22,44.34 v2(348.01,43.55) 348.38,43.18 348.38,38.12 349.65,36.84 349.65,34.24 349.12,33.7 v2(349.01,33.7)
AUD_HP_OUT_L1: length 12.2
  TOP w0.381: LA15.2 349.19,31.44 CA3.1 351.1,31.44 v2(351.2,31.55)
  BOTTOM w0.381: v2(351.2,31.55) DA1.2 353.25,32.66 355.85,32.66 356.25,33.06 356.25,34.22 357.24,35.22 JHP1.1
AUD_HP_OUT_R: length 23.3
  TOP w0.381: v2(349.3,40.79) 349.4,40.79 349.57,40.96 349.61,40.96 349.79,41.14 349.79,41.18 350.14,41.53 RA8.2 ; LA16.1 352.54,32.05 v1(351.47,33.12) 350.82,33.77 v2(350.49,33.77) ; v2(342.29,45.32) 342.29,44.88 RA58.2
  IN1 w0.381: v2(350.49,33.77) 350.49,34.2 350.29,34.4 350.29,37.26 349.3,38.25 v2(349.3,40.79) 349.3,43.17 347.5,44.97 342.77,44.97 342.43,45.32 v2(342.29,45.32)
AUD_HP_OUT_R1: length 20.6
  TOP w0.381: LA16.2 354.37,31.2 CA2.1 354.38,30.48 v2(354.07,30.17)
  BOTTOM w0.381: v2(354.07,30.17) DA1.3 354.81,31.55 355.27,31.09 355.27,25.93 356.84,24.36 363.32,24.36 JHP1.2
AUD_PC_BEEP: length 6.4
  TOP w0.203: CA28.2 346.59,35.49 345.31,36.77 UA1.16
  TOP w0.254: CA28.2 347.03,35.08 347.56,34.54 v1(348.47,34.54) 349.62,34.54 CA27.2
AUD_PWR_EN: length 183
  TOP w0.102: UZ5.3 332.81,17.25 333.14,16.92 333.29,16.92 ; v2(232.55,7.82) 232.55,8.32 231.64,9.23 231.64,12.32 233.73,14.4 233.73,15.15 234.69,16.12 234.69,17.03 234.9,17.24 234.9,20.28 236.31,21.69 236.31,24.9 236.21,25 236.21,30.55 235.88,30.89 235.88,33.51 237.02,34.65 237.02,39.17 v1(235.85,40.33) v2(234.93,41.25) ; 333.29,16.92 333.29,15.25 332.05,14.01 332.05,9.78 v2(331.63,9.36) ; 333.29,16.92 333.41,16.92 333.62,17.13 333.62,17.81 333.61,17.83 UZ5.5
  IN2 w0.102: v2(331.63,9.36) 331.43,9.16 320.53,9.16 319.33,10.35 306.76,10.35 306.4,10 304.99,10 304.62,10.37 301.93,10.37 301.14,11.16 297.99,11.16 296.88,12.27 284.53,12.27 282.46,10.2 279.6,10.2 277.69,12.1 267.14,12.1 266.29,11.25 259.55,11.25 256.49,8.19 251.1,8.19 250.68,8.61 239.85,8.61 239.27,8.03 235.19,8.03 234.99,7.82 v2(232.55,7.82) ; v2(219.44,42.56) 233.62,42.56 v2(234.93,41.25)
  BOTTOM w0.089: UH1.BD8 214.06,40.03 214.44,40.03 214.66,39.82 214.97,39.82 215.15,39.64 215.61,39.64 215.81,39.84 216.3,39.84 216.72,40.26 216.98,40.26 217.21,40.49 219.28,42.56 v2(219.44,42.56) 219.44,42.92 221.31,44.79 221.31,44.79 221.36,44.84 221.72,44.84
  BOTTOM w0.102: RH345.2 221.72,44.84
AUD_SENSE_A: length 6.5
  TOP w0.203: 345.08,34.98 344.99,35.06 344.99,35.36 344.78,35.57 UA1.13
  TOP w0.254: 345.08,34.98 345.23,34.82 346.34,34.82 v1(346.98,34.18) 347.19,33.98 CA41.1 RA60.1 RA59.2
AUD_SENSE_B: length 4
  TOP w0.203: UA1.14 345.1,35.97 345.49,35.58 v2(345.49,35.33)
  TOP w0.254: RA61.2 346.2,33.98 v2(345.99,34.19)
  IN1 w0.254: v2(345.49,35.33) 345.49,35.08 345.99,34.57 v2(345.99,34.19)
AUX_EN_WOWL: length 66.9
  TOP w0.102: RZ70.1 287.19,2.44 287.45,2.18 288.89,2.18 DZ9.2 289.42,2.44 290.05,3.07 290.75,3.07 291.07,3.39 291.07,4.09 291.37,4.39 292.63,4.39 293.12,4.89 RZ379.2 293.25,4.86 293.72,4.39 298.35,4.39 299.41,5.45 299.41,8.76 297.47,10.7 v1(297.47,10.97) 297.47,12.11 298.59,13.22 298.59,21.58 297.13,23.05 297.13,26.92 298.37,28.16 298.37,30.71 297.75,31.33 297.75,33.26 300.34,35.85 v2(300.34,36.03)
  TOP w0.104: UE1.D3 v2(314.92,38.35)
  IN2 w0.102: v2(300.34,36.03) 303.43,39.12 306.29,39.12 307.39,40.21 312.1,40.21 313.96,38.35 v2(314.92,38.35)
BAT1_LED#: length 63.3
  TOP w0.254: UE1.D10 v2(321.32,38.35)
  IN2 w0.254: v2(330.17,36.52) 330.42,36.27 330.42,35.51 330.36,35.45 329.28,35.45 328.99,35.74 328.99,37.69 329.43,38.14 329.43,38.51 329.18,38.76 324.44,38.76 324.03,38.35 v2(321.32,38.35)
  BOTTOM w0.254: RZ28.1 323.16,9.6 324.1,9.6 325.83,7.87 v1(328.21,7.87) 334.26,7.87 337.08,10.69 337.08,16.6 335.64,18.04 334.26,18.04 333.42,17.2 333,17.2 332.69,17.52 332.69,21.83 332.75,21.89 332.75,23.64 332.76,23.65 332.76,24.55 333.51,25.3 333.51,32.82 331.11,35.22 331.11,35.76 330.34,36.52 v2(330.17,36.52)
BAT2_LED#: length 47.7
  TOP w0.254: UE1.D11 v2(322.12,37.55)
  IN3 w0.254: v2(323.66,60.55) 324.63,60.55 325.55,59.64 325.55,57.35 328.11,54.78 328.11,48.86 327.02,47.76 327.02,46.19 327.42,45.79 327.42,43.9 326.13,42.61 326.13,41.61 324.68,40.16 323.28,40.16 322.12,39 v2(322.12,37.55)
  BOTTOM w0.254: QZ2.1 307.26,60.98 307.64,61.37 307.64,61.49 RZ361.1 308.02,61.87 317.29,61.87 318.79,60.38 v1(320.49,60.38) 323.48,60.38 v2(323.66,60.55)
BAT2_LED#_R: length 9
  BOTTOM w0.102: v1(301.77,61.1) 302.22,60.65 QZ3.2 304.31,59.71 304.72,59.71 305.86,58.58 QZ2.6 307.26,59.18 QZ2.3
BATT_WHITE#: length 103.3
  IN3 w0.254: v2(330.32,56.58) 330.32,57.38 328.27,59.44 v2(327.55,59.44)
  BOTTOM w0.254: JLED1.4 321.54,6.63 321.79,6.37 323.83,6.37 324.02,6.57 326.88,6.57 327.22,6.22 332.48,6.22 333.22,5.49 335.99,5.49 338.91,8.4 338.91,18.02 337.87,19.06 337.87,20.01 334.35,23.53 334.35,33.16 332.71,34.81 332.71,36.92 329.13,40.5 329.13,49.05 330.03,49.95 330.03,50.66 329.13,51.56 329.13,56.11 329.67,56.65 330.24,56.65 v2(330.32,56.58) ; QZ3.3 306.27,61.62 RZ361.2 307.49,62.25 317.6,62.25 318.87,60.98 321.99,60.98 322.04,61.04 323.86,61.04 324.14,60.75 324.14,60.16 324.71,59.59 327.4,59.59 v2(327.55,59.44)
BATT_YELLOW#: length 2.5
  BOTTOM w0.254: JLED1.5 v1(321.04,9.11) 321.04,9.31 RZ28.2
BBS_BIT6: length 5.6
  TOP w0.102: RH311.2 216.37,29.5 v1(215.82,30.05) 215.61,30.26 212.43,30.26 212.19,30.5 v2(212.19,30.66)
  BOTTOM w0.089: UH1.BA26 v2(212.19,30.66)
BC_CLK_ECE1117: length 239.3
  TOP w0.107: v2(325.27,41.45) 325.27,41.43 325.05,41.21 325.05,40.28 324.79,40.02 324.79,39 323.75,37.95 UE1.D13
  IN1 w0.099: v2(320.95,19.23) 321.17,19.23 321.61,19.67 321.61,20.01 321.61,20.05 322.41,20.85 322.99,20.85 325.85,23.71 325.85,26.18 324.93,27.09 324.93,31.33 325.71,32.11 325.71,40.73 325.27,41.17 v2(325.27,41.45) ; v2(138.02,11.99) 137.97,12.04 137.97,12.24 138.07,12.34 138.26,12.34 138.86,11.75 146.63,11.75 148.4,13.51 175.93,13.51 178.19,15.78 179.87,15.78 181.72,17.63 185.77,17.63 195.48,7.92 203.61,7.92 204.13,7.4 209.69,7.4 210.63,6.46 211.69,6.46 213.62,4.52 215.88,4.52 217.36,3.04 254.98,3.04 255.62,3.68 259.55,3.68 260.17,3.06 264.51,3.06 269.21,7.76 276.38,7.76 277.64,6.49 283.08,6.49 283.88,5.69 291.76,5.69 293.26,4.19 297.28,4.19 297.66,3.81 310.41,3.81 312.83,6.23 314.23,6.23 314.41,6.06 v2(314.41,6.02)
  BOTTOM w0.107: JKBTP1.11 139.02,10.58 CZ87.1 138.27,11.73 v2(138.02,11.99) ; v2(314.41,6.02) 314.78,6.39 314.91,6.39 315.22,6.71 315.24,6.71 316.62,8.09 316.62,10.42 321.05,14.85 321.05,19.13 v2(320.95,19.23)
BC_DAT_ECE1117: length 242.2
  TOP w0.107: UE1.D12 322.93,38.36 323.57,38.36 324.38,39.17 324.38,40.19 324.64,40.45 324.64,41.4 v2(324.66,41.43) 324.66,41.4 324.86,41.6 324.86,41.62 325.1,41.86 325.12,41.86 325.19,41.93 325.6,41.93 RE365.1
  IN1 w0.099: v2(315.05,5.98) 314.4,6.63 312.66,6.63 310.24,4.21 297.82,4.21 297.45,4.59 293.43,4.59 291.93,6.09 284.05,6.09 283.25,6.89 277.81,6.89 276.54,8.16 269.04,8.16 264.35,3.46 260.34,3.46 259.72,4.08 255.45,4.08 254.81,3.45 217.52,3.45 216.04,4.92 213.79,4.92 211.85,6.86 210.8,6.86 209.86,7.8 204.3,7.8 203.77,8.33 195.64,8.33 185.94,18.03 181.56,18.03 179.7,16.18 178.03,16.18 175.76,13.92 148.23,13.92 146.46,12.15 139.03,12.15 138.43,12.75 137.9,12.75 137.57,12.41 137.57,12.12 v2(137.41,11.96) ; v2(324.66,41.43) 324.66,41.21 325.31,40.57 325.31,32.27 324.53,31.5 324.53,26.92 325.45,26.01 325.45,23.88 322.82,21.26 322.24,21.26 321.21,20.22 v2(321.21,19.84)
  BOTTOM w0.107: v2(137.41,11.96) CZ86.1 138.02,10.72 JKBTP1.13 ; v2(321.21,19.84) 321.39,19.66 321.39,19.37 321.46,19.3 321.46,14.68 317.04,10.25 317.04,7.92 315.41,6.29 315.39,6.29 315.08,5.98 v2(315.05,5.98)
