# Allegro board LA-F711P R05-0112.brd (continued)
## Nets (continued)
CORE_SW4: PC1919.1 PL1901.1 PU1901.11 PU1901.12
CPU_2_PCH_TRIGGER: RC177.1 UH1.AK2
CPU_2_PCH_TRIGGER_R: RC177.2 UC1.J23
CPU_24MHZ_R_D: RH169.1 UC1.E31
CPU_24MHZ_R_D#: RH170.1 UC1.D31
CPU_B+: PC1804.1 PC1806.1 PC1807.1 PC1808.1 PC1809.1 PC1810.1 PC1811.1 PC1816.1 PC1817.1 PC1818.1 PC1819.1 PC1820.1 PC1821.1 PC1826.1 PC1828.1 PC1901.1 PC1902.1 PC1903.1 PC1904.1 PC1905.1 PC1906.1 PC1910.1 PC1911.1 PC1912.1 PC1913.1 PC1914.1 PC1915.1 PC1920.1 PC1922.1 PC2032.2 PC2033.2 PC2034.2 PC2035.2 PC2053.1 PC2054.1 PJP2001.2 PL1800.2 PL1801.2 PR1753.1 PU1800.8 PU1800.9 PU1801.8 PU1801.9 PU1900.8 PU1900.9 PU1901.8 PU1901.9
CPU_C10_GATE#: PR2009.1 RH616.1 RZ543.1 UZ61.2
CPU_DP1_N0: CV32.1 UC1.K37
CPU_DP1_N1: CV34.1 UC1.J34
CPU_DP1_N2: CV36.1 UC1.H36
CPU_DP1_N3: CV38.2 UC1.J38
CPU_DP1_P0: CV31.1 UC1.K36
CPU_DP1_P1: CV33.1 UC1.J35
CPU_DP1_P2: CV35.1 UC1.H37
CPU_DP1_P3: CV37.2 UC1.J37
CPU_DP2_AUXN: CT81.1 CT116.1 UC1.E26
CPU_DP2_AUXN_C: CT81.2 RT95.1 UT5.J2
CPU_DP2_AUXN_C_MUX: CT116.2 RT131.1 UT9.32
CPU_DP2_AUXP: CT80.1 CT115.1 UC1.F26
CPU_DP2_AUXP_C: CT80.2 RT96.1 UT5.J1
CPU_DP2_AUXP_C_MUX: CT115.2 RT130.1 UT9.31
CPU_DP2_N0: CT104.1 UC1.H33
CPU_DP2_N0_C: CT104.2 UT9.18
CPU_DP2_N1: CT106.1 UC1.G38
CPU_DP2_N1_C: CT106.2 UT9.21
CPU_DP2_N2: CT108.1 UC1.F35
CPU_DP2_N2_C: CT108.2 UT9.24
CPU_DP2_N3: CT110.1 UC1.E36
CPU_DP2_N3_C: CT110.2 UT9.26
CPU_DP2_P0: CT103.1 UC1.H34
CPU_DP2_P0_C: CT103.2 UT9.17
CPU_DP2_P1: CT105.1 UC1.F37
CPU_DP2_P1_C: CT105.2 UT9.20
CPU_DP2_P2: CT107.1 UC1.F34
CPU_DP2_P2_C: CT107.2 UT9.23
CPU_DP2_P3: CT109.1 UC1.E37
CPU_DP2_P3_C: CT109.2 UT9.25
CPU_DP3_AUXN: CV74.1 UC1.B27
CPU_DP3_AUXN_C: CV112.2 UV6.3
CPU_DP3_AUXN_C_RD: CV74.2 UV9.29
CPU_DP3_AUXN_RD: CV112.1 RV71.1 UV9.27
CPU_DP3_AUXP: CV73.1 UC1.A27
CPU_DP3_AUXP_C: CV111.2 UV6.2
CPU_DP3_AUXP_C_RD: CV73.2 UV9.30
CPU_DP3_AUXP_RD: CV111.1 RV77.1 UV9.28
CPU_DP3_N0: CV66.1 UC1.D34
CPU_DP3_N0_C: CV108.2 UV6.6
CPU_DP3_N0_C_RD: CV66.2 UV9.39
CPU_DP3_N0_RD: CV108.1 UV9.22
CPU_DP3_N1: CV68.1 UC1.B34
CPU_DP3_N1_C: CV110.2 UV6.8
CPU_DP3_N1_C_RD: CV68.2 UV9.42
CPU_DP3_N1_RD: CV110.1 UV9.19
CPU_DP3_N2: CV70.1 UC1.E33
CPU_DP3_N2_C_RD: CV70.2 UV9.45
CPU_DP3_N3: CV72.1 UC1.B33
CPU_DP3_N3_C_RD: CV72.2 UV9.48
CPU_DP3_P0: CV65.1 UC1.C34
CPU_DP3_P0_C: CV107.2 UV6.5
CPU_DP3_P0_C_RD: CV65.2 UV9.38
CPU_DP3_P0_RD: CV107.1 UV9.23
CPU_DP3_P1: CV67.1 UC1.B36
CPU_DP3_P1_C: CV109.2 UV6.7
CPU_DP3_P1_C_RD: CV67.2 UV9.41
CPU_DP3_P1_RD: CV109.1 UV9.20
CPU_DP3_P2: CV69.1 UC1.F33
CPU_DP3_P2_C_RD: CV69.2 UV9.44
CPU_DP3_P3: CV71.1 UC1.C33
CPU_DP3_P3_C_RD: CV71.2 UV9.47
CPU_VIDALERT#: RC153.2 UC1.BH31
CPU_XDP_HOOK6: JXDP1.46 RC115.1 RC144.1
CPU_XDP_PRDY#: JXDP1.5 RC314.1 T189.1(TP-1) UC1.BP27
CPU_XDP_PREQ#: JXDP1.3 RC138.2 RC315.1 T190.1(TP-1) UC1.BL30
CPU_XDP_PRS: JXDP1.60 RC127.1
CPU_XDP_TCLK: JXDP1.57 RC139.1 RC143.1 T181.1(TP-1) UC1.BR28
CPU_XDP_TDI: JXDP1.56 RC229.1 T185.1(TP-1) UC1.BL32
CPU_XDP_TDO: CC306.1 JXDP1.52 RC135.1 RC230.1 T184.1(TP-1) UC1.BT28
CPU_XDP_TMS: JXDP1.58 RC228.1 T180.1(TP-1) UC1.BP28
CPU_XDP_TRST#: CC308.1 JXDP1.54 RC136.1 T179.1(TP-1) UC1.BP30 UH1.AM4
CSCOMP_2PH: PC1726.1 PC1728.1 PH1702.1 PR1742.2 PR1744.1 PU1700.31
CSCOMP_4PH: PC1724.1 PC1725.2 PH1701.1 PR1741.1 PR1743.1 PU1700.8
CSIN_ISL88738: PC925.2 PC927.1 PR910.2 PU901.14
CSIP_ISL88738: PC925.1 PC926.1 PR909.2 PU901.15
CSN_1PH: PH1700.1 PL2001.3 PR1703.1
CSN_1PH_R: PC1701.1 PC1704.1 PC1705.1 PR1703.2 PU1700.48
CSON_ISL88738: PC945.2 PC946.1 PR938.1 PU901.1
CSOP_ISL88738: PC942.1 PC945.1 PR937.1 PU901.2
CSP1_2PH: PC1734.2 PR1763.1 PR1776.2 PU1700.28
CSP1_4PH: PC1733.2 PR1757.2 PR1772.2 PU1700.11
CSP2_4PH: PC1735.2 PR1764.2 PR1773.2 PU1700.12
CSP3_4PH: PC1736.2 PR1765.2 PR1774.2 PU1700.13
CSP4_4PH: PC1737.2 PR1766.2 PR1775.2 PR2007.2 PU1700.26
CSP_1PH: PC1701.2 PC1705.2 PR1701.2 PR1702.1 PU1700.47
CSREF_2PH: PC1727.1 PC1734.1 PR1776.1 PR2002.2 PU1700.29
CSREF_4PH: PC1723.2 PC1733.1 PC1735.1 PC1736.1 PC1737.1 PR1772.1 PR1773.1 PR1774.1 PR1775.1 PR1802.2 PR1806.2 PR1902.2 PR1906.2 PU1700.10
CSSUM_2PH: PC1726.2 PC1728.2 PR1748.2 PR1749.1 PU1700.30
CSSUM_4PH: PC1724.2 PC1725.1 PR1746.2 PR1747.2 PR1750.2 PR1751.2 PR1752.2 PU1700.9
CV2_ON: JUSH1.3 RE539.2
CV2_ON_R: RE539.1 RPE10.4 UE1.H8
DAT_DDC2_CRT: JCRT1.12 RV119.1 UV6.16
DAT_TP_SIO_I2C_CLK: CZ80.1 RZ22.2 RZ347.2 UE1.C12
DAT_TP_SIO_R: CZ88.1 JKBTP1.8 RZ18.2 RZ22.1
DCI_CLK: RT307.2 UT9.50
DCI_DATA: RT306.2 UT9.51
DCIN1_EN: PR1221.1 UE1.K4
DCIN2_EN: PR26.1 UE1.L12
DCIN3_EN: T262.1(TP-1) UE1.J6
DCIN_ISL88738: PC931.2 PR916.1 PU901.17
DDR4_DRAMRST#_PCH: RD11.2 RD12.2 UH1.BB46
DDR_A_ACT#: JDIMM1.114 UC1.AU3
DDR_A_ALERT#: JDIMM1.116 UC1.AU5
DDR_A_BA0: JDIMM1.150 UC1.AH5
DDR_A_BA1: JDIMM1.145 UC1.AH1
DDR_A_BG0: JDIMM1.115 UC1.AU1
DDR_A_BG1: JDIMM1.113 UC1.AU2
DDR_A_CKE0: JDIMM1.109 UC1.AT1
DDR_A_CKE1: JDIMM1.110 UC1.AT2
DDR_A_CLK0: JDIMM1.137 UC1.AG1
DDR_A_CLK1: JDIMM1.138 UC1.AK2
DDR_A_CLK#0: JDIMM1.139 UC1.AG2
DDR_A_CLK#1: JDIMM1.140 UC1.AK1
DDR_A_CS#0: JDIMM1.149 UC1.AD5
DDR_A_CS#1: JDIMM1.157 UC1.AE2
DDR_A_D0: JDIMM1.8 UC1.BR6
DDR_A_D1: JDIMM1.7 UC1.BT6
DDR_A_D2: JDIMM1.17 UC1.BP3
DDR_A_D3: JDIMM1.21 UC1.BR3
DDR_A_D4: JDIMM1.4 UC1.BN5
DDR_A_D5: JDIMM1.3 UC1.BP6
DDR_A_D6: JDIMM1.16 UC1.BP2
DDR_A_D7: JDIMM1.20 UC1.BN3
DDR_A_D8: JDIMM1.29 UC1.BL4
DDR_A_D9: JDIMM1.25 UC1.BL5
DDR_A_D10: JDIMM1.41 UC1.BL2
DDR_A_D11: JDIMM1.42 UC1.BM1
DDR_A_D12: JDIMM1.24 UC1.BK4
DDR_A_D13: JDIMM1.28 UC1.BK5
DDR_A_D14: JDIMM1.38 UC1.BK1
DDR_A_D15: JDIMM1.37 UC1.BK2
DDR_A_D16: JDIMM1.170 UC1.BT11
DDR_A_D17: JDIMM1.169 UC1.BR11
DDR_A_D18: JDIMM1.186 UC1.BT9
DDR_A_D19: JDIMM1.187 UC1.BR8
DDR_A_D20: JDIMM1.174 UC1.BP11
DDR_A_D21: JDIMM1.173 UC1.BN11
DDR_A_D22: JDIMM1.183 UC1.BP8
DDR_A_D23: JDIMM1.182 UC1.BN8
DDR_A_D24: JDIMM1.194 UC1.BL12
DDR_A_D25: JDIMM1.191 UC1.BL11
DDR_A_D26: JDIMM1.195 UC1.BL8
DDR_A_D27: JDIMM1.208 UC1.BJ8
DDR_A_D28: JDIMM1.203 UC1.BJ11
DDR_A_D29: JDIMM1.207 UC1.BJ10
DDR_A_D30: JDIMM1.190 UC1.BL7
DDR_A_D31: JDIMM1.204 UC1.BJ7
DDR_A_D32: JDIMM1.46 UC1.BG4
DDR_A_D33: JDIMM1.45 UC1.BG5
DDR_A_D34: JDIMM1.59 UC1.BF4
DDR_A_D35: JDIMM1.63 UC1.BF5
DDR_A_D36: JDIMM1.49 UC1.BG2
DDR_A_D37: JDIMM1.50 UC1.BG1
DDR_A_D38: JDIMM1.58 UC1.BF1
DDR_A_D39: JDIMM1.62 UC1.BF2
DDR_A_D40: JDIMM1.71 UC1.BD2
DDR_A_D41: JDIMM1.67 UC1.BD1
DDR_A_D42: JDIMM1.79 UC1.BC4
DDR_A_D43: JDIMM1.83 UC1.BC5
DDR_A_D44: JDIMM1.66 UC1.BD5
DDR_A_D45: JDIMM1.70 UC1.BD4
DDR_A_D46: JDIMM1.84 UC1.BC1
DDR_A_D47: JDIMM1.80 UC1.BC2
DDR_A_D48: JDIMM1.212 UC1.BG11
DDR_A_D49: JDIMM1.211 UC1.BG10
DDR_A_D50: JDIMM1.215 UC1.BG8
DDR_A_D51: JDIMM1.229 UC1.BF8
DDR_A_D52: JDIMM1.228 UC1.BF11
DDR_A_D53: JDIMM1.224 UC1.BF10
DDR_A_D54: JDIMM1.216 UC1.BG7
DDR_A_D55: JDIMM1.225 UC1.BF7
DDR_A_D56: JDIMM1.246 UC1.BB11
DDR_A_D57: JDIMM1.236 UC1.BC11
DDR_A_D58: JDIMM1.249 UC1.BB8
DDR_A_D59: JDIMM1.237 UC1.BC8
DDR_A_D60: JDIMM1.233 UC1.BC10
DDR_A_D61: JDIMM1.245 UC1.BB10
DDR_A_D62: JDIMM1.232 UC1.BC7
DDR_A_D63: JDIMM1.250 UC1.BB7
DDR_A_DQS0: JDIMM1.13 UC1.BP5
DDR_A_DQS1: JDIMM1.34 UC1.BK3
DDR_A_DQS2: JDIMM1.179 UC1.BP9
DDR_A_DQS3: JDIMM1.200 UC1.BJ9
DDR_A_DQS4: JDIMM1.55 UC1.BF3
DDR_A_DQS5: JDIMM1.76 UC1.BC3
DDR_A_DQS6: JDIMM1.221 UC1.BF9
DDR_A_DQS7: JDIMM1.242 UC1.BB9
DDR_A_DQS#0: JDIMM1.11 UC1.BR5
DDR_A_DQS#1: JDIMM1.32 UC1.BL3
DDR_A_DQS#2: JDIMM1.177 UC1.BN9
DDR_A_DQS#3: JDIMM1.198 UC1.BL9
DDR_A_DQS#4: JDIMM1.53 UC1.BG3
DDR_A_DQS#5: JDIMM1.74 UC1.BD3
DDR_A_DQS#6: JDIMM1.219 UC1.BG9
DDR_A_DQS#7: JDIMM1.240 UC1.BC9
DDR_A_MA0: JDIMM1.144 UC1.AH3
DDR_A_MA1: JDIMM1.133 UC1.AP4
DDR_A_MA2: JDIMM1.132 UC1.AN4
DDR_A_MA3: JDIMM1.131 UC1.AP5
DDR_A_MA4: JDIMM1.128 UC1.AP2
DDR_A_MA5: JDIMM1.126 UC1.AP1
DDR_A_MA6: JDIMM1.127 UC1.AP3
DDR_A_MA7: JDIMM1.122 UC1.AN1
DDR_A_MA8: JDIMM1.125 UC1.AN3
DDR_A_MA9: JDIMM1.121 UC1.AT4
DDR_A_MA10: JDIMM1.146 UC1.AH2
DDR_A_MA11: JDIMM1.120 UC1.AN2
DDR_A_MA12: JDIMM1.119 UC1.AU4
DDR_A_MA13: JDIMM1.158 UC1.AE3
DDR_A_MA14: JDIMM1.151 UC1.AG4
DDR_A_MA15: JDIMM1.156 UC1.AD1
DDR_A_MA16: JDIMM1.152 UC1.AH4
DDR_A_ODT0: JDIMM1.155 UC1.AD3
DDR_A_ODT1: JDIMM1.161 UC1.AE4
DDR_A_PAR: JDIMM1.143 UC1.AG3
DDR_B_ACT#: JDIMM2.114 UC1.AT9
DDR_B_ALERT#: JDIMM2.116 UC1.AR8
DDR_B_BA0: JDIMM2.150 UC1.AH8
DDR_B_BA1: JDIMM2.145 UC1.AH9
DDR_B_BG0: JDIMM2.115 UC1.AR9
DDR_B_BG1: JDIMM2.113 UC1.AR7
DDR_B_CKE0: JDIMM2.109 UC1.AT8
DDR_B_CKE1: JDIMM2.110 UC1.AT10
DDR_B_CLK0: JDIMM2.137 UC1.AM9
DDR_B_CLK1: JDIMM2.138 UC1.AM7
DDR_B_CLK#0: JDIMM2.139 UC1.AN9
DDR_B_CLK#1: JDIMM2.140 UC1.AM8
DDR_B_CS#0: JDIMM2.149 UC1.AF11
DDR_B_CS#1: JDIMM2.157 UC1.AE7
DDR_B_D0: JDIMM2.3 UC1.AB1
DDR_B_D1: JDIMM2.4 UC1.AB2
DDR_B_D2: JDIMM2.16 UC1.AA4
DDR_B_D3: JDIMM2.17 UC1.AA5
DDR_B_D4: JDIMM2.7 UC1.AB5
DDR_B_D5: JDIMM2.8 UC1.AB4
DDR_B_D6: JDIMM2.20 UC1.AA2
DDR_B_D7: JDIMM2.21 UC1.AA1
DDR_B_D8: JDIMM2.24 UC1.V5
DDR_B_D9: JDIMM2.29 UC1.V2
DDR_B_D10: JDIMM2.41 UC1.U1
DDR_B_D11: JDIMM2.37 UC1.U2
DDR_B_D12: JDIMM2.25 UC1.V1
DDR_B_D13: JDIMM2.28 UC1.V4
DDR_B_D14: JDIMM2.38 UC1.U5
DDR_B_D15: JDIMM2.42 UC1.U4
DDR_B_D16: JDIMM2.187 UC1.AA11
DDR_B_D17: JDIMM2.183 UC1.AA10
DDR_B_D18: JDIMM2.174 UC1.AC11
DDR_B_D19: JDIMM2.170 UC1.AC10
DDR_B_D20: JDIMM2.186 UC1.AA7
DDR_B_D21: JDIMM2.182 UC1.AA8
DDR_B_D22: JDIMM2.169 UC1.AC8
DDR_B_D23: JDIMM2.173 UC1.AC7
DDR_B_D24: JDIMM2.191 UC1.W8
DDR_B_D25: JDIMM2.195 UC1.W7
DDR_B_D26: JDIMM2.203 UC1.V10
DDR_B_D27: JDIMM2.207 UC1.V11
DDR_B_D28: JDIMM2.190 UC1.W11
DDR_B_D29: JDIMM2.194 UC1.W10
DDR_B_D30: JDIMM2.208 UC1.V7
DDR_B_D31: JDIMM2.204 UC1.V8
DDR_B_D32: JDIMM2.49 UC1.R2
DDR_B_D33: JDIMM2.58 UC1.P5
DDR_B_D34: JDIMM2.50 UC1.R4
DDR_B_D35: JDIMM2.59 UC1.P4
DDR_B_D36: JDIMM2.46 UC1.R5
DDR_B_D37: JDIMM2.63 UC1.P2
DDR_B_D38: JDIMM2.45 UC1.R1
DDR_B_D39: JDIMM2.62 UC1.P1
DDR_B_D40: JDIMM2.67 UC1.M4
DDR_B_D41: JDIMM2.70 UC1.M1
DDR_B_D42: JDIMM2.83 UC1.L4
DDR_B_D43: JDIMM2.80 UC1.L2
DDR_B_D44: JDIMM2.71 UC1.M5
DDR_B_D45: JDIMM2.66 UC1.M2
DDR_B_D46: JDIMM2.79 UC1.L5
DDR_B_D47: JDIMM2.84 UC1.L1
DDR_B_D48: JDIMM2.216 UC1.R11
DDR_B_D49: JDIMM2.229 UC1.P11
DDR_B_D50: JDIMM2.228 UC1.P7
DDR_B_D51: JDIMM2.211 UC1.R8
DDR_B_D52: JDIMM2.212 UC1.R10
DDR_B_D53: JDIMM2.225 UC1.P10
DDR_B_D54: JDIMM2.215 UC1.R7
DDR_B_D55: JDIMM2.224 UC1.P8
DDR_B_D56: JDIMM2.249 UC1.L11
DDR_B_D57: JDIMM2.236 UC1.M11
DDR_B_D58: JDIMM2.250 UC1.L7
DDR_B_D59: JDIMM2.237 UC1.M8
DDR_B_D60: JDIMM2.245 UC1.L10
DDR_B_D61: JDIMM2.232 UC1.M10
DDR_B_D62: JDIMM2.233 UC1.M7
DDR_B_D63: JDIMM2.246 UC1.L8
DDR_B_DQS0: JDIMM2.13 UC1.AB3
DDR_B_DQS1: JDIMM2.34 UC1.V3
DDR_B_DQS2: JDIMM2.179 UC1.AA9
DDR_B_DQS3: JDIMM2.200 UC1.V9
DDR_B_DQS4: JDIMM2.55 UC1.R3
DDR_B_DQS5: JDIMM2.76 UC1.M3
DDR_B_DQS6: JDIMM2.221 UC1.P9
DDR_B_DQS7: JDIMM2.242 UC1.L9
DDR_B_DQS#0: JDIMM2.11 UC1.AA3
DDR_B_DQS#1: JDIMM2.32 UC1.U3
DDR_B_DQS#2: JDIMM2.177 UC1.AC9
DDR_B_DQS#3: JDIMM2.198 UC1.W9
DDR_B_DQS#4: JDIMM2.53 UC1.P3
DDR_B_DQS#5: JDIMM2.74 UC1.L3
DDR_B_DQS#6: JDIMM2.219 UC1.R9
DDR_B_DQS#7: JDIMM2.240 UC1.M9
DDR_B_MA0: JDIMM2.144 UC1.AJ9
DDR_B_MA1: JDIMM2.133 UC1.AK6
DDR_B_MA2: JDIMM2.132 UC1.AK5
DDR_B_MA3: JDIMM2.131 UC1.AL5
DDR_B_MA4: JDIMM2.128 UC1.AL6
DDR_B_MA5: JDIMM2.126 UC1.AM6
DDR_B_MA6: JDIMM2.127 UC1.AN7
DDR_B_MA7: JDIMM2.122 UC1.AN10
DDR_B_MA8: JDIMM2.125 UC1.AN8
DDR_B_MA9: JDIMM2.121 UC1.AR11
DDR_B_MA10: JDIMM2.146 UC1.AH7
DDR_B_MA11: JDIMM2.120 UC1.AN11
DDR_B_MA12: JDIMM2.119 UC1.AR10
DDR_B_MA13: JDIMM2.158 UC1.AF9
DDR_B_MA14: JDIMM2.151 UC1.AH11
DDR_B_MA15: JDIMM2.156 UC1.AF8
DDR_B_MA16: JDIMM2.152 UC1.AH10
DDR_B_ODT0: JDIMM2.155 UC1.AF7
DDR_B_ODT1: JDIMM2.161 UC1.AE8
DDR_B_PAR: JDIMM2.143 UC1.AJ7
DDR_DRAMRST#: CD29.1 CD61.1 JDIMM1.108 JDIMM2.108 RD12.1
DDR_RCOMP0: RC5.2 UC1.G1
DDR_RCOMP1: RC6.2 UC1.H1
DDR_RCOMP2: RC7.2 UC1.J2
DDR_VTT_CTRL: UC1.BT13 UD1.2
DDR_XDP_WAN_SMBCLK: JDIMM1.253 JDIMM2.253 JXDP1.53 LGA1.1 QH4.1 RH333.1
DDR_XDP_WAN_SMBDAT: JDIMM1.254 JDIMM2.254 JXDP1.51 LGA1.4 QH4.4 RH374.1
DEBUG_TX: JDEG1.9 RE30.2 RE74.2
DEW1: RN16.2 RN17.2 UN7.16
DEW2: RN14.2 RN15.2 UN7.6
DGPU_HOLD_RST#: T37.1(TP-1) UH1.BB20
DGPU_PWR_EN: T38.1(TP-1) UH1.AN18
DGPU_PWROK: RE525.1 UE1.M4
DIFFOUT_2PH: PR1738.1 PR1739.2 PU1700.35
DIFFOUT_4PH: PC1715.2 PR1734.2 PU1700.4
DIMM1_SA0: JDIMM1.256 RD4.2 RD5.1
DIMM1_SA1: JDIMM1.260 RD6.2 RD7.1
DIMM1_SA2: JDIMM1.166 RD8.2 RD9.1
DIMM2_SA0: JDIMM2.256 RD20.2 RD21.1
DIMM2_SA1: JDIMM2.260 RD22.2 RD23.1
DIMM2_SA2: JDIMM2.166 RD24.2 RD25.1
DISP_ON: DV2.1 JEDP1.22 RV2.1
DMI_CRX_PTX_N0: UC1.E8 UH1.C33
DMI_CRX_PTX_N1: UC1.F6 UH1.C32
DMI_CRX_PTX_N2: UC1.E5 UH1.C31
DMI_CRX_PTX_N3: UC1.J9 UH1.C29
DMI_CRX_PTX_P0: UC1.D8 UH1.B33
DMI_CRX_PTX_P1: UC1.E6 UH1.B32
DMI_CRX_PTX_P2: UC1.D5 UH1.B31
DMI_CRX_PTX_P3: UC1.J8 UH1.B29
DMI_CTX_PRX_N0: UC1.A8 UH1.K34
DMI_CTX_PRX_N1: UC1.B6 UH1.G33
DMI_CTX_PRX_N2: UC1.A5 UH1.K32
DMI_CTX_PRX_N3: UC1.B4 UH1.G30
DMI_CTX_PRX_P0: UC1.B8 UH1.J35
DMI_CTX_PRX_P1: UC1.C6 UH1.F34
DMI_CTX_PRX_P2: UC1.B5 UH1.J32
DMI_CTX_PRX_P3: UC1.D4 UH1.F30
DMIC0: CA6.1 JEDP1.7 RA52.2 UA1.2
DMIC_CLK0: CA5.1 CA54.1 JEDP1.9 RA14.1
DMIC_CLK_CODEC: RA14.2 UA1.3
DP2_AUXN_SBU2: RT109.1 UT5.L8
DP2_AUXP_SBU1: RT108.1 UT5.K8
DP2_MIC_SBU1: DT39.5 DT39.6 JUSBC1.A8 RT108.2 RT132.2
DP2_MIC_SBU2: DT39.4 DT39.7 JUSBC1.B8 RT109.2 RT133.2
DP_RP_CADET: RV74.1 UV9.10
DP_RP_CEXT: CV75.1 UV9.2
DP_RP_CFG0: RV83.1 RV84.1 UV9.5
DP_RP_CFG1: RV81.1 RV82.1 UV9.40
DP_RP_I2C: RV76.1 UV9.3
DP_RP_PD#: RV89.2 UV9.26
DP_RP_PEQ: RV79.1 RV80.1 UV9.4
DP_RP_REXT: RV50.1 UV9.7
DP_RP_RST#: CV631.1 RV621.2 UV9.35
DRON: PU1700.17 PU1800.16 PU1801.16 PU1900.16 PU1901.16 PU2000.16 PU2001.16
EC_FPM_EN: JUSH1.5 UE1.D6
EDP_AUXN: CV1.1 UC1.B26
EDP_AUXN_C: CV1.2 JEDP1.33
EDP_AUXP: CV2.1 UC1.C26
EDP_AUXP_C: CV2.2 JEDP1.34
EDP_COMP: RC1.1 UC1.D37
EDP_HPD: JEDP1.26 RH1.2 RV7.1 UH1.AN6
EDP_TXN0: CV4.1 UC1.E29
EDP_TXN0_C: CV4.2 JEDP1.36
EDP_TXN1: CV6.1 UC1.E28
EDP_TXN1_C: CV6.2 JEDP1.38
EDP_TXP0: CV3.1 UC1.D29
EDP_TXP0_C: CV3.2 JEDP1.35
EDP_TXP1: CV5.1 UC1.F28
EDP_TXP1_C: CV5.2 JEDP1.37
EN_0.6V: PC222.1 PR210.1 PR212.1 PU200.2
EN_1.2RUN: PC510.1 PR509.1 PR511.2 PR2010.2 PU502.5
EN_1.2V: PC221.1 PR208.1 PR209.1 PU200.1
EN_1.8VALW: PC505.1 PR504.2 PR505.1 PU501.1
EN_1VS_VCCIO: PC415.1 PR402.2 PR403.1 PU401.13
EN_+1VALWP: PC314.1 PR302.1 PR312.2 PU301.11
EN_INVPWR: QV2.2 RE55.1 UE1.B2
EN_LCDPWR: DV3.1 RV3.2 UV24.4
EN_PD_HV_1: PQ1214.5 PR1210.1 PR1211.1 PR1250.2 PR1254.1 PR1260.1 RT70.2
EN_PD_HV_1#: PQ1214.2 PQ1214.3 PR1253.2
EN_PD_HV_1_R: RT70.1 UT5.C2
ENABLE_DS#: RE549.2 RE550.1 UE1.L2
ENLDO_3V5V: PR102.1 PR103.1 PU100.11 PU102.11
ENVDD_PCH: DV3.3 UH1.AV44
ESPI_ALERT#: RH340.1 UE1.H7 UH1.AW35
ESPI_CLK: RH97.1 UH1.BB36
ESPI_CLK_5105: CC316.1 JESPI.10 RE350.1 RH97.2 UE1.G7
ESPI_CS#: JESPI.7 UE1.H6 UH1.BE38
ESPI_IO0: JESPI.3 RC366.2 UE1.K5
ESPI_IO0_R: RC366.1 UH1.BB39
ESPI_IO1: JESPI.4 RC367.2 UE1.L4
ESPI_IO1_R: RC367.1 UH1.AW37
ESPI_IO2: JESPI.5 RC368.2 UE1.G6
ESPI_IO2_R: RC368.1 UH1.AV37
ESPI_IO3: JESPI.6 RC369.2 UE1.L5
ESPI_IO3_R: RC369.1 UH1.BA38
ESPI_RESET#: CH348.1 RE560.2 RH95.1 RH633.1 UE1.K6 UH1.BF38
FB_1.8VALW: PC503.2 PR501.2 PR506.1 PU501.6
FB_2PH: PC1717.1 PC1720.2 PR1739.1 PR1740.1 PU1700.34
FB_4PH: PC1714.2 PC1716.2 PR1731.1 PR1734.1 PU1700.5
FB_+1VALWP: PR306.2 PR311.1 PR2008.2 PU301.14
FFS_INT2: LGA1.11 QN1.2 RH378.2 UH1.BE14
FFS_INT2_Q: JSATA1.19 QN1.3 RN1.2
FIVR_EN: RC217.1 RC218.2 RC219.2
FIVR_EN_R: JXDP1.45 RC126.2 RC132.2 RC217.2
GPIO011: T143.1(TP-1) UE1.K7
GPIO100: T144.1(TP-1) UE1.M1
GPP_B23: RH329.1 UH1.BD33
GPP_C5: RH78.2 UH1.BF24
GPP_C23: T304.1(TP-1) UH1.AV21
GPP_H12: RH615.2 UH1.AB47
GPP_H15: RH601.2 UH1.AC47
GPP_J1: RH616.2 UH1.AY3
GPPJ_RCOMP: RH609.2 UH1.BD1 UH1.BE1 UH1.BE2
GPS_DISABLE#: DZ6.1 RE12.1 UE1.H5
GPU_PWR_LEVEL: RE5.1 UE1.E12
GPU_SMCLK: RPE12.1 UE1.F7
GPU_SMDAT: RPE12.2 UE1.B6
GREEN: CV130.1 DV5.3 JCRT1.2 LV17.2
GREEN_CRT: CV127.1 LV17.1 RV117.1 UV6.22
GT_SW1: PC2009.1 PL2000.1 PU2000.11 PU2000.12
H_CATERR#: RC79.2 UC1.BM30
H_PECI: RE60.2 RH73.2 UC1.BT34
H_PM_DOWN: RC168.1 UH1.AE2
H_PM_DOWN_R: RC168.2 UC1.BP31
H_PM_SYNC: RH156.2 UC1.BM34
H_PM_SYNC_R: RH156.1 UH1.AF3
H_PROCHOT#_R: RC84.2 UC1.BR30
H_PWRGD: CC300.1 UC1.BT31 UH1.AE3
H_SKTOCC#: RC319.2 UC1.BR33
H_THERMTRIP#: CC323.1 QE4.3 RC80.2 RC169.1 RD14.2 RD27.2 RH75.2
H_THERMTRIP#_R: RC169.2 UC1.J31
H_VCCST_PWRGD_XDP: CC307.1 JXDP1.39 RC124.2
HDA_BIT_CLK: CA75.1 RH46.2 RH637.2 UH1.BD11
HDA_BIT_CLK_R: CH268.2 RA17.1 RH46.1 UA1.6
HDA_RST#: RH50.2 RH636.2 UH1.BE10
HDA_RST#_R: RA50.1 RH50.1
HDA_SDIN0: CA73.1 RA9.1 UH1.BE11
HDA_SDIN0_R: RA9.2 UA1.8
HDA_SDOUT: CA76.1 RH45.2 RH328.2 UH1.BF12
HDA_SDOUT_R: RH45.1 UA1.5
HDA_SYNC: CA74.1 RH48.2 UH1.BG13
HDA_SYNC_R: RH48.1 UA1.10
HDD_A_EQ: RN10.1 RN11.2 UN7.17
HDD_A_EQ2: RN20.2 RN21.1 UN7.18
HDD_A_PRE: RN6.2 RN7.2 UN7.9
HDD_B_EQ: RN12.2 RN13.2 UN7.19
HDD_B_EQ2: RN18.2 RN19.1 UN7.13
HDD_B_PRE: RN8.1 RN9.2 UN7.8
HDD_DET#: JSATA1.13 QN6.2 RH324.2 UH1.AK47
HDD_DEVSLP: JSATA1.11 RN3.2 UH1.AH40
HDD_EN: RE566.1 RH625.2 RN4.2 RN5.1 UZ23.3
HDD_EN_EC: RE566.2 T141.1(TP-1) UE1.D1
HDD_EN_PCH: RH625.1 UH1.BD21
HDD_FALL_INT: LGA1.12 RH355.2 UH1.AW26
HDD_UN7_EN: QN6.1 RN226.2 RN227.1
HDD_UN7_EN_R: RN227.2 UN7.7
HDMI_CEC: JHDMI1.13 RV19.1
HDMI_CLKN: CV38.1 LV12.2 RV17.1 RV33.1
HDMI_CLKP: CV37.1 LV12.1 RV16.1 RV34.1
HDMI_CTRL_CLK: JHDMI1.15 QV3.6 RV22.1
HDMI_CTRL_DATA: JHDMI1.16 QV3.3 RV23.1
HDMI_HPD: JHDMI1.19 QV5.1 RV21.1
HDMI_L_CLKN: JHDMI1.12 LV12.3 RV33.2 RV35.2
HDMI_L_CLKP: JHDMI1.10 LV12.4 RV34.2 RV35.1
HDMI_L_TX_N0: JHDMI1.9 LV9.3 RV30.2 RV32.2
HDMI_L_TX_N1: JHDMI1.6 LV6.3 RV27.2 RV29.2
HDMI_L_TX_N2: JHDMI1.3 LV3.3 RV24.2 RV26.2
HDMI_L_TX_P0: JHDMI1.7 LV9.4 RV31.2 RV32.1
HDMI_L_TX_P1: JHDMI1.4 LV6.4 RV28.2 RV29.1
HDMI_L_TX_P2: JHDMI1.1 LV3.4 RV25.2 RV26.1
HDMI_OB: QV4.1 RV10.2 RV11.2 RV12.2 RV13.2 RV14.2 RV15.2 RV16.2 RV17.2
HDMI_TX_N0: CV36.2 LV9.2 RV15.1 RV30.1
HDMI_TX_N1: CV34.2 LV6.2 RV13.1 RV27.1
HDMI_TX_N2: CV32.2 LV3.2 RV11.1 RV24.1
HDMI_TX_P0: CV35.2 LV9.1 RV14.1 RV31.1
HDMI_TX_P1: CV33.2 LV6.1 RV12.1 RV28.1
HDMI_TX_P2: CV31.2 LV3.1 RV10.1 RV25.1
HOST_DEBUG_TX: JDEG1.8 RE73.2 RE306.2 RZ132.1 UE1.G11
HOST_SD_WP#: QR1.2 RH214.2 UH1.BE8
HP_OUT_L: CA43.2 RA7.1 UA1.32
HP_OUT_R: CA44.2 RA8.1 UA1.33
HSYNC_CONN: CV133.1 JCRT1.13 RV122.1 RV1650.2
HSYNC_CRT: RV1650.1 UV6.19
HV_GATE1_A: RT64.1 UT5.B9
HV_GATE2_A: RT65.1 UT5.A9
HW_ACAVIN_NB: PC1207.1 PR21.1 PR941.1 PR1203.2 PR1206.2 PR1241.1 PR1258.1 PU1201.1 UE1.N6
HW_GPS_DISABLE#_R: DZ6.2 JNGFF2.26
I2C1_SCK_TP: RZ21.2 RZ29.1 UH1.BE21
I2C1_SCK_TP_R: JKBTP1.2 RZ29.2 RZ117.2 RZ347.1
I2C1_SDA_TP: RZ20.2 RZ26.1 UH1.BF21
I2C1_SDA_TP_R: JKBTP1.3 RZ26.2 RZ116.2 RZ346.1
I_ADP: PR935.2 UE1.B11
I_BATT: PR947.2 RE64.2
I_BATT_R: CE3.1 RE64.1 UE1.J4
I_SYS: PR936.2 PR1755.1 PU1700.24 RE312.2
I_SYS_R: CE4.1 RE312.1 RE313.1 UE1.J5
ILIM_1PH: PC1708.2 PR1718.2 PU1700.49
ILIM_2PH: PR1742.1 PU1700.32
ILIM_4PH: PR1741.2 PU1700.7
ILIM_SEL: RI13.1 UI3.4
ILMT_+1VALWP: PR607.2 PR609.1 PU301.13
ILMT_DDR: PR205.1 PR207.2 PU200.17
IMON_1PH: PC1706.2 PR1713.2 PU1700.46
IMVP_VR_ON: PR1724.2 RE304.1 UE3.4 UE4.2
IMVP_VR_ON_EC: RE304.2 RPE10.1 UE1.N7 UE3.1
INT_SPK_L+: CA22.1 LA6.1 UA1.42
INT_SPK_L-: CA23.1 LA7.1 UA1.43
INT_SPK_R+: CA19.1 LA8.1 UA1.45
INT_SPK_R-: CA24.1 LA9.1 UA1.44
INT_SPKR_L+: DA6.2 JSPK1.1 LA6.2
INT_SPKR_L-: DA6.3 JSPK1.2 LA7.2
INT_SPKR_R+: DA7.2 JSPK1.3 LA8.2
INT_SPKR_R-: DA7.3 JSPK1.4 LA9.2
IR_CAM_DET#: JIR1.1 RH373.1 UH1.BD16
ISH_UART0_CTS#: RZ80.1 UH1.BF14
ISH_UART0_CTS#_R: JNGFF1.62 RZ80.2
ISH_UART0_RTS#: RZ81.1 UH1.AR18
ISH_UART0_RTS#_R: JNGFF1.64 RZ81.2 RZ371.2
ISH_UART0_RXD: RZ78.1 UH1.BE17
ISH_UART0_RXD_R: JNGFF1.58 RZ78.2
ISH_UART0_TXD: RZ79.1 UH1.BF17
ISH_UART0_TXD_R: JNGFF1.60 RZ79.2
ISPSCL: RV106.1 UV6.30
ISPSDA: RV107.1 UV6.29
IST_TRIG: T3.1(TP-1) UC1.E3
ITP_PMODE_CPU: RC144.2 T192.1(TP-1) UH1.AL3
JCRT-11: JCRT1.11 T200.1(TP-1)
JDIMM1_EVENT#: JDIMM1.134 RD14.1
JDIMM2_EVENT#: JDIMM2.134 RD27.1
JTAG_CLK: JDEG1.4 RPE7.2 UE1.C8
JTAG_RST#: CE30.1 JTAG1.1 RE63.1 RE65.1 UE1.G13
JTAG_TDI: JDEG1.2 RPE7.4 UE1.E9
JTAG_TDO: JDEG1.5 RPE7.1 UE1.F6
JTAG_TMS: JDEG1.3 RPE7.3 UE1.C5
KB_DET#: CZ84.1 JKBTP1.20 RC74.2 UH1.AW15
LAN_ACTLED_YEL#: QL1.6 RL14.1
LAN_ACTLED_YEL_R#: JLOM1.10 RL14.2
LAN_DISABLE#_R: RL5.1 RL7.2 RL9.1 UL1.3
LAN_MDIN0: RL72.1 UL1.14
LAN_MDIN0_L: RL72.2 TL1.11
LAN_MDIN1: RL74.1 UL1.18
LAN_MDIN1_L: RL74.2 TL1.5
LAN_MDIN2: RL76.1 UL1.21
LAN_MDIN2_L: RL76.2 TL1.8
LAN_MDIN3: RL78.1 UL1.24
LAN_MDIN3_L: RL78.2 TL1.2
LAN_MDIP0: RL71.1 UL1.13
LAN_MDIP0_L: RL71.2 TL1.12
LAN_MDIP1: RL73.1 UL1.17
LAN_MDIP1_L: RL73.2 TL1.6
LAN_MDIP2: RL75.1 UL1.20
LAN_MDIP2_L: RL75.2 TL1.9
LAN_MDIP3: RL77.1 UL1.23
LAN_MDIP3_L: RL77.2 TL1.3
LAN_TEST_EN: RL12.1 UL1.30
LAN_WAKE#: RH93.1 RL70.2 UE1.L3 UH1.BG44 UL1.2
LCD_CBL_DET#: JEDP1.40 RC370.1 UH1.AW24
LCD_TST: JEDP1.29 RE20.1 UE1.M2
LCD_VCC_TEST_EN: DV3.2 UE1.E1
LCDVDD_MONITOR: QV21.2 RV630.2
LDO_3V: PC312.1 PU301.16 PU301.17
LED_10_GRN#: QL2.6 RL19.1
LED_10_GRN_R#: JLOM1.11 RL19.2
LED_100_ORG#: QL1.3 RL20.1
LED_100_ORG_R#: JLOM1.13 RL20.2
LED_MASK#: QL1.2 QL1.5 QL2.2 RE21.1 UE1.A12 UZ10.1
LG1_ISL88738: PQ903.4 PU901.9
LG2_ISL88738: PQ1302.6 PU901.7
LID_CL#: JLED1.2 RE26.1 UZ10.2
LID_CL#_PCH: T268.1(TP-1) UH1.AV34
LID_CL_SIO#: CE8.1 RE25.2 RE26.2 UE1.N11
LINE1_L: CA43.1 UA1.22
LINE1_R: CA44.1 UA1.21
LM393_P: PC949.2 PC1201.2 PD1801.1 PR950.2 PU903.5 PU1201.8
LOM_ACTLED_YEL#: QL1.1 UL1.26
LOM_CABLE_DETECT#: RE505.1 UE1.D2 UL2.4
LOM_SPD10LED_GRN#: QL2.1 RL30.2 UL1.25 UL2.2
LOM_SPD100LED_ORG#: QL1.4 RL29.2 UL1.27 UL2.1
LPS_PROTECT#: PR1248.2 PT1.1(TP-1)
LPSS_UART2_RXD: RH361.2 RH376.2 UH1.BD20
LPSS_UART2_TXD: RH330.2 RH360.2 RH621.2 RH624.1 UH1.BE20
LX1_ISL88738: PC930.2 PL902.1 PQ902.1 PQ902.2 PQ902.3 PQ903.5 PR923.1 PU901.10
LX2_ISL88738: PL902.2 PQ1302.7 PR921.1 PR924.1 PU901.6
LX_1.8VALW: PL501.1 PR502.1 PU501.3
LX_1VS_VCCIO: PL401.1 PR404.1 PU401.2 PU401.3
LX_3V: PC102.2 PL100.1 PR106.1 PU100.6 PU100.19 PU100.20
LX_5V: PC114.2 PL101.1 PR112.1 PU102.6 PU102.19 PU102.20
LX_+1VALWP: PL301.1 PR303.1 PR304.2 PU301.6 PU301.19 PU301.20
LX_DDR: PC205.2 PL201.1 PR202.1 PU200.11
M2280_DEVSLP: JNGFF3.38 RN37.2 UH1.AH35
M2280_PCIE_SATA#: JNGFF3.69 RH317.2 RH318.2 UH1.AJ43
M3042_DEVSLP: JNGFF2.38 UH1.AR47
M3042_PCIE#_SATA: RH344.2 UE1.J12 UH1.AM46
M_ID2#: CV135.1 JCRT1.4
MASK_BASE_LEDS#: QZ7.5 UZ10.4
MASK_SATA_LED#: QZ2.5 UE1.L6
ME_FWP: RH100.1 SW1.1 UE1.G12
ME_FWP_PCH: RH100.2 RH328.1 SW1.3
ME_RESET#: RH70.1 UC3.2
ME_SUS_PWR_ACK: RH444.2 UE1.B13
ME_SUS_PWR_ACK_R: RH444.1 UH1.BC37
MEC_XTAL1: CE28.1 UE1.A1 YE1.1
MEC_XTAL2: CE29.1 RE290.2 YE1.2
MEC_XTAL2_R: RE290.1 UE1.A3
MEDIACARD_IRQ#: RR19.1 UH1.BB26 UR1.32
MEM_INTERLEAVED: RH371.1 RH372.1 UH1.BA20
MEM_SMBCLK: CC320.1 QH4.6 RH56.2 UH1.BE26
MEM_SMBDATA: QH4.3 RH57.2 UH1.BF26
MSCLK: JDEG1.6 RE30.1 RE72.2 UE1.H10
MSDATA: JDEG1.7 RE75.2 RE86.1 UE1.G9
MUX1_DP_SEL: RT89.1 UT9.35
MUX1_FLIP_SEL: RT69.2 UT9.37
MUX1_FLIP_SEL_R: RT69.1 UT5.B2
MUX1_USB_SEL: RT90.1 RT308.1 UT9.36
NB_MUTE#: DA8.1 RA48.1 UE1.A4
NB_PSID: PD4.2 PD4.3 PJPDC1.1 PL3.2
NGFF_CONFIG_0: JNGFF2.21 RPE9.3 UE1.N9
NGFF_CONFIG_1: JNGFF2.69 RPE9.1 UE1.M10 UZ29.9
NGFF_CONFIG_2: JNGFF2.75 RPE9.2 UE1.N10
NGFF_CONFIG_3: JNGFF2.1 RPE9.4 UE1.F4
NRB_BIT: RH331.2 UH1.BE30
NVME_LED#: JNGFF3.10 RN100.1
ONE_DIMM#: RH267.1 RH268.1 UH1.BF29
OTG_ID: RT74.1 UT5.E10
OTGEN/CMIN: PR919.2 PR960.2 PU901.20
PANEL_BKEN_EC: DV2.2 UE1.J9
PANEL_BKEN_PCH: DV2.3 UH1.AV46
PANEL_MONITOR: RV628.2 UE1.M8
PANEL_PWRGD: CV632.1 QV19.1 QV21.1 RV623.2 RV624.1 RV628.1
PBAT_CHARGER_SMBCLK: PD2.3 PR922.1 PRP1.3 RE43.1 UE1.N2
PBAT_CHARGER_SMBDAT: PD1.2 PR920.1 PRP1.2 RE37.1 UE1.M3
PBAT_PRES#: PD1.3 PR1.2 PR931.1 PRP1.1 UE1.F9
PBAT_PRES#_C: PBATT1.6 PRP1.8
PBAT_SMBCLK_C: PBATT1.4 PRP1.6
PBAT_SMBDAT_C: PBATT1.5 PRP1.7
PBATT+_C: PBATT1.1 PBATT1.2 PBATT1.3 PC1.1 PL1.1 PL2.1
PCH_2_CPU_TRIGGER: RH42.2 UC1.H23
PCH_2_CPU_TRIGGER_R: RH42.1 UH1.AK3
PCH_3.3V_TS_EN: RH375.2 RV324.1 UH1.BD30
PCH_BATLOW#: RH94.1 UH1.BF44
PCH_CL_CLK1: JNGFF1.42 UH1.AR2
PCH_CL_DATA1: JNGFF1.40 UH1.AT5
PCH_CL_RST1#: JNGFF1.38 UH1.AU4
PCH_CPU_BCLK_D: RH161.2 UH1.B8
PCH_CPU_BCLK_D#: RH166.2 UH1.C8
PCH_CPU_BCLK_R_D: RH161.1 UC1.B31
PCH_CPU_BCLK_R_D#: RH166.1 UC1.A32
PCH_CPU_NSSC_CLK_D: RH169.2 UH1.D7
PCH_CPU_NSSC_CLK_D#: RH170.2 UH1.C6
PCH_CPU_PCIBCLK_D: RH167.1 UH1.A6
PCH_CPU_PCIBCLK_D#: RH168.1 UH1.B6
PCH_CPU_PCIBCLK_R_D: RH167.2 UC1.D35
PCH_CPU_PCIBCLK_R_D#: RH168.2 UC1.C36
PCH_DP1_CTRL_CLK: QV3.1 RH222.1 UH1.AL13
PCH_DP1_CTRL_DATA: QV3.4 RH223.1 UH1.AR8
PCH_DP1_HPD: QV5.3 RV20.1 UH1.AT6
PCH_DP2_CTRL_DATA: RH221.1 UH1.AL10
PCH_DP2_HPD: RT73.2 RT380.1 UH1.AN10
PCH_DP2_HPD_R: RT73.1 UT5.C10
PCH_DP3_CTRL_CLK: RH224.1 UH1.AL9 UV9.33
PCH_DP3_CTRL_DATA: RH225.1 UH1.AR3 UV9.34
PCH_DP3_HPD: UH1.AP9 UV9.9
PCH_DP3_RD_HPD: RV102.1 UV6.32 UV9.11
PCH_DPWROK: CH266.1 RE536.1 RH215.1 RH308.1 UH1.AW41
PCH_DPWROK_EC: RE536.2 UE1.F8
PCH_INTRUDER_HDR#: RH198.2 UH1.BB44
PCH_JTAG_TCK: JXDP1.55 RH313.1 T188.1(TP-1) UH1.AJ3
PCH_JTAG_TDI: CC304.1 RC229.2 RH314.1 T187.1(TP-1) UH1.AH2
PCH_JTAG_TDO: CC303.1 RC230.2 RH315.1 T186.1(TP-1) UH1.AH3
PCH_JTAG_TMS: RC228.2 RH312.1 T183.1(TP-1) UH1.AJ4
PCH_JTAGX: CC305.1 RC143.2 RC166.2 T182.1(TP-1) UH1.AH4
PCH_PCIE_WAKE#: RE274.2 RH92.1 UE1.L1 UH1.BB47
PCH_PECI: RH73.1 RH74.1 UH1.AF2
PCH_PLTRST#: RH60.1 RH62.2 RH244.2 RH635.1 UH1.AV29 UH7.1 UH7.2
PCH_PLTRST#_5105: RE340.1 UE1.K1 UE6.4
PCH_PLTRST#_AND: CZ61.1 JNGFF1.52 JNGFF2.50 JNGFF3.50 RH65.1 RH187.2 RZ114.1 UH7.4 UR1.1
PCH_PLTRST#_EC: RE375.2 RH244.1 UE6.2
PCH_PRIM_EN: PR312.1 PR504.1 PR511.1 RH441.2 RH442.2 RZ64.1 UZ34.1
PCH_PWROK: PR1716.2 PU1700.45 RH424.1 UH1.AY42
PCH_RSMRST#: RE342.1 UE1.M5 UZ6.1
PCH_RSMRST#_AND: RC75.1 RC124.1 RH215.2 T191.1(TP-1) UH1.BA47 UZ6.4
PCH_RTCRST#: CH40.2 CMOS1.2 JAPS1.9 RE94.2 RH200.2 UH1.BE47
PCH_RTCX1: RH43.2 RH44.1 UH1.BA49
PCH_RTCX1_R: CH4.2 RH43.1 YH1.1
PCH_RTCX2: CH5.2 RH44.2 UH1.BA48 YH1.2
PCH_SMB_ALERT#: RH61.2 UH1.BE25
PCH_SPI_CLK: JSPI1.8 RH181.2 RH634.1 UH1.AW47
PCH_SPI_CLK_0_R: RH29.1 RPC1.6 UC5.6
PCH_SPI_CLK_1_R: RH28.1 RPC2.7 UC6.6
PCH_SPI_CLK_2_R: RZ60.2 RZ63.2 UZ12.19
PCH_SPI_CLK_R1: JSPI1.7 RH181.1 RPC1.3 RPC2.2 RZ60.1
PCH_SPI_CS#0: JSPI1.10 RH182.2 UH1.AY47
PCH_SPI_CS#0_R1: JSPI1.9 RH37.1 RH182.1 RH352.1
PCH_SPI_CS#0_R2: RH37.2 UC5.1
PCH_SPI_CS#0_R3: RH352.2 UC6.1
PCH_SPI_CS#1: JSPI1.2 RH177.2 UH1.AW48
PCH_SPI_CS#1_R1: JSPI1.1 RH177.1
PCH_SPI_CS#2: RZ61.1 UH1.AT40
PCH_SPI_CS#2_R: RZ61.2 UZ12.20
PCH_SPI_D0: JSPI1.4 RC128.1 RH178.2 RH600.2 UH1.AU41
PCH_SPI_D0_0_R: RPC1.5 UC5.5
PCH_SPI_D0_1_R: RPC2.8 UC6.5
PCH_SPI_D0_2_R: RZ59.2 UZ12.21
PCH_SPI_D0_R1: JSPI1.3 RH178.1 RPC1.4 RPC2.1 RZ59.1
PCH_SPI_D1: JSPI1.6 RH179.2 UH1.BA45
PCH_SPI_D1_0_R: RPC1.8 UC5.2
PCH_SPI_D1_1_R: RPC2.5 UC6.2
PCH_SPI_D1_2_R: RZ58.2 UZ12.24
PCH_SPI_D1_R1: JSPI1.5 RH179.1 RPC1.1 RPC2.4 RZ58.1
PCH_SPI_D2: JSPI1.12 RH30.2 RH180.2 RH183.2 UH1.AY48
PCH_SPI_D2_0_R: RH351.2 UC5.3
PCH_SPI_D2_1_R: RH353.2 UC6.3
PCH_SPI_D2_R1: JSPI1.11 RH183.1 RH351.1 RH353.1
PCH_SPI_D2_XDP: RC127.2 RH180.1
PCH_SPI_D3: JSPI1.14 RH184.2 RH334.2 RH335.2 UH1.BA46
PCH_SPI_D3_0_R: RPC1.7 UC5.7
PCH_SPI_D3_1_R: RPC2.6 UC6.7
PCH_SPI_D3_R1: JSPI1.13 RH184.1 RPC1.2 RPC2.3
PCH_TBT_PERST#: RC557.1 RC558.1 RH207.2 UH1.BE23
PCH_THERMTRIP#: RH75.1 UH1.AD3
PCH_XDP_CLK_DN: JXDP1.42 RH154.2
PCH_XDP_CLK_DN_R: RH154.1 UH1.Y3
PCH_XDP_CLK_DP: JXDP1.40 RH155.2
PCH_XDP_CLK_DP_R: RH155.1 UH1.Y4
PCH_XDP_PRDY#: RC314.2 UH1.AM5
PCH_XDP_PREQ#: RC315.2 UH1.AL2
PCI_CLK_LPC1: RH99.1 UH1.BB34
PCIE_PRX_C_DTX_N5: CL2.2 UL1.39
PCIE_PRX_C_DTX_N6: CR14.2 UR1.8
PCIE_PRX_C_DTX_P5: CL1.2 UL1.38
PCIE_PRX_C_DTX_P6: CR13.2 UR1.7
PCIE_PRX_DTX_N5: CL2.1 UH1.F20
PCIE_PRX_DTX_N6: CR14.1 UH1.K21
PCIE_PRX_DTX_N7: JNGFF1.43 UH1.L24
PCIE_PRX_DTX_N9: JNGFF3.5 UH1.G36
PCIE_PRX_DTX_N10: JNGFF3.17 UH1.K37
PCIE_PRX_DTX_N11: JNGFF3.29 UH1.G38
PCIE_PRX_DTX_N12: JNGFF3.43 UH1.H42
PCIE_PRX_DTX_N17: JNGFF2.43 UH1.K43
PCIE_PRX_DTX_N18: UH1.P41 UZ29.14
PCIE_PRX_DTX_P5: CL1.1 UH1.G20
PCIE_PRX_DTX_P6: CR13.1 UH1.J21
PCIE_PRX_DTX_P7: JNGFF1.41 UH1.J24
PCIE_PRX_DTX_P9: JNGFF3.7 UH1.F36
PCIE_PRX_DTX_P10: JNGFF3.19 UH1.J37
PCIE_PRX_DTX_P11: JNGFF3.31 UH1.F39
PCIE_PRX_DTX_P12: JNGFF3.41 UH1.J41
PCIE_PRX_DTX_P17: JNGFF2.41 UH1.K44
PCIE_PRX_DTX_P18: UH1.R40 UZ29.15
PCIE_PRX_L_DTX_N18: JNGFF2.29 LI16.2 RI27.2
PCIE_PRX_L_DTX_P18: JNGFF2.31 LI16.3 RI28.2
PCIE_PRX_SW_DTX_N18: LI16.1 RI27.1 UZ29.4
PCIE_PRX_SW_DTX_P18: LI16.4 RI28.1 UZ29.3
PCIE_PTX_C_DRX_N5: CL6.2 UL1.42
PCIE_PTX_C_DRX_N6: CR12.2 UR1.4
PCIE_PTX_C_DRX_N7: CZ13.2 JNGFF1.37
PCIE_PTX_C_DRX_N9: CN65.1 JNGFF3.11
PCIE_PTX_C_DRX_N10: CN67.1 JNGFF3.23
PCIE_PTX_C_DRX_N11: CN69.1 JNGFF3.35
PCIE_PTX_C_DRX_N12: CN71.1 JNGFF3.47
PCIE_PTX_C_DRX_N17: CZ10.2 JNGFF2.47
PCIE_PTX_C_DRX_N18: JNGFF2.35 RZ1.2
PCIE_PTX_C_DRX_P5: CL5.2 UL1.41
PCIE_PTX_C_DRX_P6: CR11.2 UR1.3
PCIE_PTX_C_DRX_P7: CZ12.2 JNGFF1.35
PCIE_PTX_C_DRX_P9: CN66.1 JNGFF3.13
PCIE_PTX_C_DRX_P10: CN68.1 JNGFF3.25
PCIE_PTX_C_DRX_P11: CN70.1 JNGFF3.37
PCIE_PTX_C_DRX_P12: CN72.1 JNGFF3.49
PCIE_PTX_C_DRX_P17: CZ11.2 JNGFF2.49
PCIE_PTX_C_DRX_P18: JNGFF2.37 RZ2.2
PCIE_PTX_C_SW_DRX_N18: CZ153.2 UZ29.12
PCIE_PTX_C_SW_DRX_P18: CZ152.2 UZ29.13
PCIE_PTX_DRX_N5: CL6.1 UH1.B21
PCIE_PTX_DRX_N6: CR12.1 UH1.D21
PCIE_PTX_DRX_N7: CZ13.1 UH1.C23
PCIE_PTX_DRX_N9: CN65.2 UH1.C34
PCIE_PTX_DRX_N10: CN67.2 UH1.C35
PCIE_PTX_DRX_N11: CN69.2 UH1.B36
PCIE_PTX_DRX_N12: CN71.2 UH1.D38
PCIE_PTX_DRX_N17: CZ10.1 UH1.A42
PCIE_PTX_DRX_N18: CZ153.1 UH1.C42
PCIE_PTX_DRX_P5: CL5.1 UH1.A22
PCIE_PTX_DRX_P6: CR11.1 UH1.C21
PCIE_PTX_DRX_P7: CZ12.1 UH1.B23
PCIE_PTX_DRX_P9: CN66.2 UH1.D34
PCIE_PTX_DRX_P10: CN68.2 UH1.B35
PCIE_PTX_DRX_P11: CN70.2 UH1.C36
PCIE_PTX_DRX_P12: CN72.2 UH1.E37
PCIE_PTX_DRX_P17: CZ11.1 UH1.B42
PCIE_PTX_DRX_P18: CZ152.1 UH1.D42
PCIE_PTX_L_DRX_N18: LI17.2 RI29.2 RZ1.1
PCIE_PTX_L_DRX_P18: LI17.3 RI30.2 RZ2.1
PCIE_PTX_SW_DRX_N18: LI17.1 RI29.1 UZ29.8
PCIE_PTX_SW_DRX_P18: LI17.4 RI30.1 UZ29.7
PCIE_WAKE#: JNGFF1.55 JNGFF2.54 JNGFF3.54 RE274.1 RE275.1
PCIE_WAKE#_R: RE35.1 RE275.2 UE1.N13
PCIECOMP: RH192.1 UH1.A13
PCIECOMP#: RH192.2 UH1.B12
PD1_GPIO2: RT71.1 UT5.D10
PD1_GPIO6: RT75.1 UT5.G10
PD1_GPIO7: RT339.1 UT5.D7
PD1_GPIO8: RT76.1 RT377.1 UT5.H6
PD#: CA31.1 DA8.2 RA18.1 RA48.2 RA50.2 UA1.47
PECI_EC_R: RE60.1 UE1.K13
PEG_COMP: RC2.2 UC1.G2
PG_1.8VALW: PR517.1 PR2011.1 PU501.5
PG_+1VALWP: PR2012.1 PR2013.2 PU301.9
PGOOD_3V: PR107.2 PR119.1 PU100.9
PGOOD_5V: PR113.2 PR120.1 PU102.9
PLTRST_CPU#: UC1.BP35 UH1.AG5
PLTRST_LAN#: RH62.1 UL1.36
PLTRST_TPM#: RH60.2 RH187.1 UZ12.17
PM_LANPHY_ENABLE: RL7.1 UH1.BF41
PME#: T178.1(TP-1) UH1.BE36
POA_WAKE#: RE324.1 RZ364.1 UE1.E4
POA_WAKE#_R: JUSH1.4 RZ364.2
POWER_SW#_MB: CE10.1 JAPS1.11 RE33.2 SW3.2 SW3.4
POWER_SW_IN#: CE12.1 RE31.2 RE33.1 UE1.D5
PROCHOT#: CC324.1 PR926.1 PR1704.2 PR1712.2 RC83.2 RC84.1 RE288.2
PROCHOT#_ISL88738: PQ1216.1 PR926.2 PU901.23
PROCHOT#_R1: RE288.1 UE1.H13
PS8802_ADDR: RT135.1 RT136.1 UT9.19
PS8802_CEQ: RT139.1 RT140.1 UT9.48
PS8802_CSCL: RT305.1 RT375.1 UT9.28
PS8802_CSDA: RT304.1 RT376.1 UT9.29
PS8802_DPEQ: RT137.1 RT138.1 UT9.22
PS8802_HPD: RT380.2 UT9.40
PS8802_REXT: RT300.1 UT9.39
PS8802_RST#: CT122.1 RT246.2 UT9.43
PS8802_SBU1_R: RT132.1 RT414.1 UT9.33
PS8802_SBU2_R: RT133.1 RT415.1 UT9.34
PS8802_SSEQ: RT141.1 RT142.1 UT9.46
PS_ID: PR4.1 PR5.2 UE1.J8
PWM1_1PH/ICCMAX1: PR1722.1 PU1700.44 PU2001.1
PWM1_2PH/ICCMAX2: PR1756.1 PU1700.23 PU2000.1
PWM1_4PH/ICCMAX4: PR1758.1 PU1700.18 PU1800.1
PWM2_2PH/ROSC1: PR1762.1 PU1700.22
PWM2_4PH/ADDR: PR1759.1 PU1700.19 PU1801.1
PWM3_4PH/VBOOT: PR1760.1 PU1700.20 PU1900.1
PWM4_4PH/ROSCM: PR1761.1 PU1700.21 PU1901.1
PWM_FAN1: JFAN1.2 RE48.2 UE1.L10
RED: CV129.1 DV5.2 JCRT1.1 LV16.2
RED_CRT: CV126.1 LV16.1 RV116.1 UV6.23
REFCLK_CNV: RH110.1 RZ371.1 UH1.R6
REM_DIODE1_N: CE24.1 CE35.1 QE3.3 UE1.A8
REM_DIODE1_P: CE24.2 CE35.2 QE3.1 QE3.2 UE1.A7
REM_DIODE2_N: CE26.1 CE37.2 CE46.2 QE5.3 QE7.1 QE7.2 UE1.A10
REM_DIODE2_P: CE26.2 CE37.1 CE46.1 QE5.1 QE5.2 QE7.3 UE1.A9
REM_DIODE4_N: CE27.1 CE39.1 QE6.3 UE1.A11
REM_DIODE4_P: CE27.2 CE39.2 QE6.1 QE6.2 UE1.B10
RES_BIAS: RL13.1 UL1.12
RESET_IN#: RE362.1 UE1.C1
RESET_OUT: RE548.2 UE1.G4
RING2: LA10.1 RA5.2 UA1.17
RING2_R: CA4.1 CA13.2 DA3.3 JHP1.3 LA10.2
RJ45_MDIN0: JLOM1.2 TL1.14
RJ45_MDIN1: JLOM1.6 TL1.20
RJ45_MDIN2: JLOM1.5 TL1.17
RJ45_MDIN3: JLOM1.8 TL1.23
RJ45_MDIP0: JLOM1.1 TL1.13
RJ45_MDIP1: JLOM1.3 TL1.19
RJ45_MDIP2: JLOM1.4 TL1.16
RJ45_MDIP3: JLOM1.7 TL1.22
RTCRST_ON: QE12.2 RE93.1 RE565.2 UE1.F11
RTCRST_ON_R: CE65.1 DE2.2 QE17.2 RE543.1
RTCRST_ON_R1: CE64.1 DE2.1 QE15.2 RE541.2 RE543.2 RE565.1
RTD3_CIO_PWR_EN: T259.1(TP-1) UH1.AP21
RTD3_SELECT_EC: T264.1(TP-1) UE1.F13
RUN_ON: PR402.1 PR2010.1 QE2.2 RE280.2 RE292.1 RZ320.1 RZ345.1 UE5.4 UZ3.5 UZ4.3 UZ35.2
RUN_ON#: QE2.5 QE2.6 QZ4.2 RE68.1
RUN_ON_1.8V: CZ197.1 RZ345.2 UZ8.3
RUN_ON_EC: RE292.2 RPE10.2 UE1.E8 UE5.2
RUNPWROK: QE2.3 RE67.1 UE1.G3
SA_SW: PC2019.1 PL2001.1 PU2001.11 PU2001.12
SATA_PRX_C_DTX_N2: CN6.1 JSATA1.5
SATA_PRX_C_DTX_P2: CN7.1 JSATA1.6
SATA_PRX_C_RD_DTX_N2: CN14.2 UN7.4
SATA_PRX_C_RD_DTX_P2: CN15.2 UN7.5
SATA_PRX_DTX_N2: CN14.1 UH1.F44
SATA_PRX_DTX_P2: CN15.1 UH1.E45
SATA_PRX_RD_DTX_N2: CN6.2 UN7.12
SATA_PRX_RD_DTX_P2: CN7.2 UN7.11
SATA_PTX_C_DRX_N2: CN5.1 JSATA1.3
SATA_PTX_C_DRX_P2: CN4.1 JSATA1.2
SATA_PTX_C_RD_DRX_N2: CN13.2 UN7.2
SATA_PTX_C_RD_DRX_P2: CN12.2 UN7.1
SATA_PTX_DRX_N2: CN13.1 UH1.B40
SATA_PTX_DRX_P2: CN12.1 UH1.C40
SATA_PTX_RD_DRX_N2: CN5.2 UN7.14
SATA_PTX_RD_DRX_P2: CN4.2 UN7.15
SATAGP0: RH316.2 RH377.2 UH1.AH41
SATAGP3: RH323.2 UH1.AN47
SATAGP5: RH325.2 UH1.AM43
SATAGP6: RH326.2 UH1.AM47
SATAGP7: RH322.2 UH1.AM48
SATALED#: QZ2.4 RH380.2 RN100.2 RN101.2 UH1.AK48
SBIOS_TX: RE306.1 UH1.BB24
SD_1_CD#: JSD1.18 UR1.30
SD_1_CLK: RR5.1 UR1.17
SD_1_CLK_R: CR21.1 JSD1.5 RR5.2
SD_1_CMD: RR6.1 UR1.19
SD_1_CMD_R: JSD1.2 RR6.2
SD_1_DAT0: RR10.1 UR1.16
SD_1_DAT0_R: JSD1.7 RR10.2
SD_1_DAT1: RR9.1 UR1.15
SD_1_DAT1_R: JSD1.8 RR9.2
SD_1_DAT2: RR8.1 UR1.21
SD_1_DAT2_R: JSD1.9 RR8.2
SD_1_DAT3: RR7.1 UR1.20
SD_1_DAT3_R: JSD1.1 RR7.2
SD_1_N0: JSD1.12 UR1.25
SD_1_N1: JSD1.15 UR1.23
SD_1_P0: JSD1.11 UR1.26
SD_1_P1: JSD1.16 UR1.22
SD_GPIO: RR3.2 UR1.28
SD_RCOMP_1P8: RH611.2 UH1.BE5
SD_RCOMP_3P3: RH610.2 UH1.BE4
SDWP: QR1.1 UR1.29
SDWP_Q: JSD1.19 QR1.3
SIM_DET: JNGFF2.66 JSIM1.9
SIO_EXT_SMI#: RH310.2 UH1.AL47
SIO_EXT_WAKE#: RE703.1 RH309.2 UH1.AU24
SIO_EXT_WAKE#_EC: RE703.2 UE1.M12
SIO_PWRBTN#: CC269.1 JXDP1.41 RC241.2 UE1.K11 UH1.BE46
SIO_RCIN#: T286.1(TP-1) UH1.BE39
SIO_SLP_A#: CH343.1 JAPS1.6 RH628.1 UE1.M11 UH1.BE40
SIO_SLP_LAN#: CH346.1 RH204.1 RH631.1 UE1.H9 UH1.BF40 UZ2.5
SIO_SLP_S0#: JAPS1.15 PR425.1 RH619.1 RZ112.1 RZ362.2 RZ363.1 UH1.BC28
SIO_SLP_S3#: CH341.1 JAPS1.2 QE11.2 RE280.1 RH626.1 UE1.K9 UE3.2 UE5.1 UH1.BF42
SIO_SLP_S4#: CH342.1 JAPS1.5 PR208.2 PR513.1 RH627.1 UE1.N12 UH1.BE42 UZ21.4 UZ34.2
SIO_SLP_S5#: CH347.1 JAPS1.4 RH632.1 UE1.N8 UH1.BC42
SIO_SLP_SUS#: CH345.1 RE349.1 RH441.1 RH630.1 UH1.BD39
SIO_SLP_SUS#_R: RE349.2 RE561.1 UE1.N4
SIO_SLP_WLAN#: CH344.1 QZ15.1 RH629.1 UE1.D9 UH1.BD42
SKL_CNL#: RC171.2 UC1.BN1
SLEEVE: LA11.1 RA6.2 UA1.18
SLEEVE_R: CA1.2 CA12.1 DA3.2 JHP1.4 LA11.2
SLOT2_SATA_LED#: JNGFF2.10 RN101.1
SLP_WLAN#_GATE: QZ15.2 QZ16.2 RE552.1 RZ518.2
SLP_WLAN#_M: DZ9.3 QZ15.3 QZ16.3 RZ71.1 RZ375.2
SML0_SMBCLK: CC318.1 RH67.2 UH1.BF25 UL1.28
SML0_SMBDATA: RH77.2 UH1.BE24 UL1.31
SML1_SMBCLK: CC319.1 RH80.2 UE1.D8 UH1.BF27
SML1_SMBDATA: RH81.2 UE1.E11 UH1.BE27
SNUB_1.8VALW: PC506.1 PR502.2
SNUB_1VS_VCCIO: PC403.1 PR404.2
SNUB_+1VALWP: PC302.1 PR303.2
SNUB_CHG1: PC940.1 PR923.2
SNUB_CHG2: PC941.1 PR924.2
SPKR: RA12.2 RH86.2 UH1.AW29
SPKR_R: CA27.1 CA72.1 RA12.1 RA51.1
SRTCRST#: CH41.2 RH201.2 UH1.BD46
SS_1VS_VCCIO: PC409.1 PR427.2 PU401.7
SUSACK#: RH443.2 UE1.K12
SUSACK#_R: RH327.1 RH443.1 UH1.BE35
SUSCLK: RH83.1 RN99.2 RZ56.1 UH1.BE45
SUSCLK_R: JNGFF3.68 RN99.1
SW1_2PH: PL2000.2 PR1749.2 PR1763.2
SW1_4PH: PL1802.2 PR1747.1 PR1757.1
SW2_4PH: PL1803.2 PR1750.1 PR1764.1
SW3_4PH: PL1900.2 PR1751.1 PR1765.1
SW4_4PH: PL1901.2 PR1752.1 PR1766.1
SW_1PH: PL2001.2 PR1702.2
SW_USB20_1_N4: RT122.2 UT5.L7
SW_USB20_1_N4_R: DT40.1 DT40.9 JUSBC1.B7 RT122.1
SW_USB20_1_P4: RT123.2 UT5.K7
SW_USB20_1_P4_R: DT40.2 DT40.8 JUSBC1.B6 RT123.1
SW_USB20_2_N4: RT121.1 UT5.L6
SW_USB20_2_N4_R: DT39.2 DT39.8 JUSBC1.A7 RT121.2
SW_USB20_2_P4: RT120.1 UT5.K6
SW_USB20_2_P4_R: DT39.1 DT39.9 JUSBC1.A6 RT120.2
SYS_PWROK: RC129.1 RE56.1 RE548.1 RH199.1 UH1.AU3
SYS_PWROK_R: CC33.1 JXDP1.47 RC128.2 RC129.2 RC133.2
SYS_RESET#: CC302.1 JAPS1.13 RH66.2 UC3.4 UH1.AU2
SYSTEM_ID: CE47.1 RE300.2 UE1.J10
TACH_FAN1: JFAN1.3 RE51.2 UE1.E3
TBT_FORCE_PWR: T260.1(TP-1) UH1.BE15
TBT_PWR_EN: T269.1(TP-1) UH1.BF15
TBT_RESET_N_EC_R: RE95.2 UE1.L8
TBT_RTD3_WAKE#: RH125.1 UH1.AR32
TBTA_CC1: CT86.1 DT40.4 DT40.7 JUSBC1.A5 RT104.2 UT5.L9
TBTA_CC2: CT85.1 DT40.5 DT40.6 JUSBC1.B5 RT105.2 UT5.L10
TBTA_DBG_CTL1: RT106.1 UT5.E4
TBTA_DBG_CTL2: RT107.1 UT5.D5
TBTA_DEBUG1: RT92.2 UT5.L2
TBTA_DEBUG2: RT93.2 UT5.K2
TBTA_DEBUG3: RT89.2 UT5.L3
TBTA_DEBUG4: RT90.2 UT5.K3
TBTA_LSRX_R: RT88.2 UT5.K4
TBTA_LSTX_R: RT87.2 UT5.L4
TBTA_MRESET: RT86.1 UT5.E11
TBTA_RESET_N_EC_R: RT110.2 UT5.F11
TBTA_ROM_CLK_PD: RT54.1 UT5.A3
TBTA_ROM_CLK_PD_R: JDB1.2 RT54.2 UT6.6
TBTA_ROM_CS#_PD: RT57.1 UT5.B3
TBTA_ROM_CS#_PD_R: JDB1.5 RT51.2 RT57.2 UT6.1
TBTA_ROM_DI_PD: RT55.1 UT5.B4
TBTA_ROM_DI_PD_R: JDB1.3 RT55.2 UT6.5
TBTA_ROM_DO_PD: RT56.1 UT5.A4
TBTA_ROM_DO_PD_R: JDB1.4 RT52.2 RT56.2 UT6.2
TBTA_ROM_HOLD#_PD: RT50.2 UT6.7
TBTA_ROM_WP#_PD: RT53.2 UT6.3
TBTA_ROSC: RT100.1 UT5.G2
THERMTRIP1#: RE301.1 UE1.B12
THERMTRIP2#: CE36.1 QE4.1 RE69.2 UE1.H3
TOUCH_SCREEN_DET#: JEDP1.32 RV8.1 UH1.BC33
TOUCH_SCREEN_PD#: JEDP1.5 RH348.2 UH1.AM45
TOUCHPAD_INTR#: JKBTP1.5 RE318.2 RH402.2 UH1.BF32
TP_LAN_JTAG_TCK: RL2.1 UL1.35
TP_LAN_JTAG_TDI: T88.1(TP-1) UL1.32
TP_LAN_JTAG_TDO: T89.1(TP-1) UL1.34
TP_LAN_JTAG_TMS: RL1.1 UL1.33
TP_SKL_E30: T284.1(TP-1) UC1.E30
TP_SKL_F30: T285.1(TP-1) UC1.F30
TPM_GPIO0: RZ112.2 UZ12.29
TPM_GPIO4: T283.1(TP-1) UZ12.13
TPM_LPM#: RZ363.2 UZ12.3
TPM_PIRQ#: RC560.1 RC561.1 RZ69.2 UZ12.18
TPM_PIRQ#_B20: RC561.2 RH339.2 UH1.AU26
TPM_PIRQ#_R: RC560.2 UH1.BD29
TPM_TYPE: RH379.1 UH1.AW32
TSENSE_2PH: PC1731.1 PR1768.1 PU1700.25
TSENSE_4PH: PC1729.1 PR1767.1 PU1700.14
TYPEC_CON_SEL1: RH555.1 RH556.1 UH1.BA24
TYPEC_CON_SEL2: RH553.1 RH554.1 UH1.AP24
TYPEC_ID: CE62.1 RE343.1 UE1.F2
UART_MISO: RT82.1 RT83.2 UT5.F2
UART_MOSI: RT81.1 RT83.1 UT5.E2
UG1_ISL88738: PQ902.4 PU901.11
UG2_ISL88738: PQ1302.1 PU901.5
UIM_CLK: CZ38.1 JNGFF2.32 JSIM1.3
UIM_DATA: CZ39.1 JNGFF2.34 JSIM1.7 RZ335.2
UIM_RESET: CZ40.1 JNGFF2.30 JSIM1.2
UPD1_SMBCLK: QT1.1 RE303.1 RT58.1 UE1.C3
UPD1_SMBCLK_Q: QT1.6 RT58.2 RT67.1 RT92.1 RT375.2 UT5.B5
UPD1_SMBDAT: QT1.4 RE302.1 RT59.1 UE1.B4
UPD1_SMBDAT_Q: QT1.3 RT59.2 RT66.1 RT93.1 RT376.2 UT5.A5
UPD1_SMBINT#: RE91.1 RT60.1 UE1.F10
UPD1_SMBUS_ALERT#: RT60.2 RT68.1 UT5.B6
UPD2_SMBCLK: RPE12.3 UE1.D7
UPD2_SMBDAT: RPE12.4 UE1.E7
UPD2_SMBINT#: RE92.1 UE1.F5
USB2_COMP: RH193.1 UH1.F4
USB2_ID: RH365.1 RT74.2 UH1.G3
USB2_VBUSSENSE: RH364.1 UH1.F3
USB3_DP2_1_MRX_C_DTX_N5: CT633.2 JUSBC1.B10 RT419.1
USB3_DP2_1_MRX_C_DTX_P5: CT632.2 JUSBC1.B11 RT418.1
USB3_DP2_1_MRX_DTX_N5: CT633.1 DT6.2 UT9.3
USB3_DP2_1_MRX_DTX_P5: CT632.1 DT5.2 UT9.2
USB3_DP2_1_MTX_C_DRX_N5: CT96.2 JUSBC1.A3
USB3_DP2_1_MTX_C_DRX_P5: CT95.2 JUSBC1.A2
USB3_DP2_1_MTX_DRX_N5: CT96.1 DT14.2 UT9.42
USB3_DP2_1_MTX_DRX_P5: CT95.1 DT13.2 UT9.41
USB3_DP2_2_MRX_C_DTX_N5: CT630.2 JUSBC1.A10 RT416.1
USB3_DP2_2_MRX_C_DTX_P5: CT631.2 JUSBC1.A11 RT417.1
USB3_DP2_2_MRX_DTX_N5: CT630.1 DT17.2 UT9.8
USB3_DP2_2_MRX_DTX_P5: CT631.1 DT18.2 UT9.9
USB3_DP2_2_MTX_C_DRX_N5: CT98.2 JUSBC1.B3
USB3_DP2_2_MTX_C_DRX_P5: CT97.2 JUSBC1.B2
USB3_DP2_2_MTX_DRX_N5: CT98.1 DT10.2 UT9.44
USB3_DP2_2_MTX_DRX_P5: CT97.1 DT9.2 UT9.45
USB3_PRX_C_MTX_N5: CT112.2 UT9.11
USB3_PRX_C_MTX_P5: CT111.2 UT9.12
USB3_PRX_DTX_N1: DI4.1 DI4.9 JUSB1.5 UH1.D11
USB3_PRX_DTX_N2: UH1.B9 UZ29.18
USB3_PRX_DTX_N3: DI1.1 DI1.9 JUSB2.5 UH1.B10
USB3_PRX_DTX_N4: DI6.1 DI6.9 JUSB3.5 UH1.K16
USB3_PRX_DTX_P1: DI4.2 DI4.8 JUSB1.6 UH1.C11
USB3_PRX_DTX_P2: UH1.C9 UZ29.19
USB3_PRX_DTX_P3: DI1.2 DI1.8 JUSB2.6 UH1.C10
USB3_PRX_DTX_P4: DI6.2 DI6.8 JUSB3.6 UH1.J15
USB3_PRX_MTX_N5: CT112.1 UH1.J13
USB3_PRX_MTX_P5: CT111.1 UH1.K13
USB3_PTX_C_DRX_N1: CI13.1 DI4.4 DI4.7 JUSB1.8
USB3_PTX_C_DRX_N2: CZ151.2 UZ29.16
USB3_PTX_C_DRX_N3: CI5.1 DI1.4 DI1.7 JUSB2.8
USB3_PTX_C_DRX_N4: CI27.1 DI6.4 DI6.7 JUSB3.8
USB3_PTX_C_DRX_P1: CI16.1 DI4.5 DI4.6 JUSB1.9
USB3_PTX_C_DRX_P2: CZ150.2 UZ29.17
USB3_PTX_C_DRX_P3: CI4.1 DI1.5 DI1.6 JUSB2.9
USB3_PTX_C_DRX_P4: CI28.1 DI6.5 DI6.6 JUSB3.9
USB3_PTX_C_MRX_N5: CT114.2 UT9.14
USB3_PTX_C_MRX_P5: CT113.2 UT9.15
USB3_PTX_DRX_N1: CI13.2 UH1.F9
USB3_PTX_DRX_N2: CZ151.1 UH1.C3
USB3_PTX_DRX_N3: CI5.2 UH1.F11
USB3_PTX_DRX_N4: CI27.2 UH1.B14
USB3_PTX_DRX_P1: CI16.2 UH1.F7
USB3_PTX_DRX_P2: CZ150.1 UH1.D4
USB3_PTX_DRX_P3: CI4.2 UH1.G12
USB3_PTX_DRX_P4: CI28.2 UH1.C14
USB3_PTX_MRX_N5: CT114.1 UH1.C15
USB3_PTX_MRX_P5: CT113.1 UH1.B15
USB20_N1: UH1.J3 UI3.2
USB20_N2: LI3.1 UH1.N13
USB20_N2_R: DI2.3 JUSB2.2 LI3.2
USB20_N3: LI4.1 UH1.K4
USB20_N3_R: DI3.3 JUSB3.2 LI4.2
USB20_N4: UH1.M10 UT5.K5
USB20_N6: T300.1(TP-1) UH1.K7
USB20_N8: LI8.4 RI48.1 UH1.G4
USB20_N8_R: JNGFF2.9 LI8.3 RI48.2
USB20_N9: LV27.3 UH1.M6
USB20_N9_R: DV4.2 JEDP1.2 LV27.4
USB20_N10: JUSH1.8 UH1.H3
USB20_N11: LZ1.1 UH1.R10
USB20_N11_R: JEDP1.12 LZ1.2
USB20_N14: LI9.1 RI50.1 UH1.E5
USB20_N14_R: JNGFF1.5 LI9.2 RI50.2
USB20_P1: UH1.J2 UI3.3
USB20_P2: LI3.4 UH1.N15
USB20_P2_R: DI2.2 JUSB2.3 LI3.3
USB20_P3: LI4.4 UH1.K3
USB20_P3_R: DI3.2 JUSB3.3 LI4.3
USB20_P4: UH1.L9 UT5.L5
USB20_P6: T301.1(TP-1) UH1.K6
USB20_P8: LI8.1 RI47.1 UH1.G5
USB20_P8_R: JNGFF2.7 LI8.2 RI47.2
USB20_P9: LV27.2 UH1.N8
USB20_P9_R: DV4.3 JEDP1.3 LV27.1
USB20_P10: JUSH1.9 UH1.H2
USB20_P11: LZ1.4 UH1.P9
USB20_P11_R: JEDP1.13 LZ1.3
USB20_P14: LI9.4 RI49.1 UH1.F6
USB20_P14_R: JNGFF1.3 LI9.3 RI49.2
USB_OC0#: RPH6.3 RPH8.3 UH1.AH36 UI3.13
USB_OC1#: RPH6.2 RPH8.2 UH1.AL40 UI1.3
USB_OC2#: RPH6.4 RPH8.4 UH1.AJ44 UI2.3
USB_OC3#: RPH6.1 RPH8.1 UH1.AL41
USB_OC4#: RPH7.1 UH1.AV47
USB_OC5#: RPH7.2 UH1.AR35
USB_OC6#: RPH7.3 UH1.AR37
USB_OC7#: RPH7.4 UH1.AV43
USB_POWERSHARE_EN#: RPE11.3 UE1.J3 UI3.6
USB_POWERSHARE_VBUS_EN: RE702.1 RPE11.1 UE1.J2 UI3.5
USB_PWR_EN1#: RPE11.4 UE1.K3 UI1.4
USB_PWR_EN2#: RPE11.2 UE1.G5 UI2.4
USH_DET#: DZ7.2 RE526.2 RZ87.1 UE1.C13
USH_DET#_R: DZ7.1 JUSH1.26 RZ87.2
USH_EXPANDER_SMBCLK: CZ62.1 JUSH1.11 RZ8.2 UE1.B3
USH_EXPANDER_SMBDAT: CZ63.1 JUSH1.12 RZ9.2 UE1.E5
USH_PWR_STATE#: JUSH1.22 RZ10.2 UE1.H2
USH_RST#_R: JUSH1.21 RZ114.2
VCI_IN1#: RE507.1 UE1.B5
VCI_IN2#: RE508.1 UE1.D4
VCT_LAN_R1: RL3.1 UL1.6
VGA_IDENTIFY: RE84.1 RE85.1 UE1.L9
VID0_VCCIO: PR418.2 PR420.1 PU401.9
VID1_VCCIO: PR417.2 PR419.1 PU401.8
VR_SVID_ALERT#: PR1706.2 PR1717.1 RC152.2 RC153.1
VR_SVID_CLK: CC325.1 PR1707.2 PR1715.2 UC1.BH32
VR_SVID_DATA: PR1705.1 PR1719.2 RC157.2 UC1.BH29
VRALERT#: RH203.1 UH1.BE32
VSET_5105: CE38.1 RE77.1 UE1.C9
VSN_1PH: PC1700.2 PR1709.2 PU1700.51
VSN_2PH: PC1719.1 PR1730.1 PU1700.37
VSN_4PH: PC1712.2 PR1727.2 PU1700.2
VSP_1PH: PC1707.2 PR1711.2 PU1700.52
VSP_2PH: PC1713.1 PR1728.1 PU1700.38
VSP_4PH: PC1711.2 PR1723.2 PU1700.1
VSYNC_CONN: CV132.1 JCRT1.14 RV121.1 RV1651.2
VSYNC_CRT: RV1651.1 UV6.18
WIGIG_32KHZ: JNGFF1.50 RZ56.2
WLAN_COEX1: JNGFF1.48 RZ130.2
WLAN_COEX2: JNGFF1.46 RZ129.2
WLAN_COEX3: JNGFF1.44 RZ128.2
WLAN_PWR_EN: DZ9.1 RZ38.2 RZ70.2 RZ71.2 UZ4.5
WLAN_WIGIG60GHZ_DIS#: DZ1.1 RE8.1 UE1.L13
WLAN_WIGIG60GHZ_DIS#_R: DZ1.2 JNGFF1.56
WWAN_COEX1: JNGFF2.64 RZ130.1 RZ373.1
WWAN_COEX2: JNGFF2.62 RZ129.1 RZ372.1
WWAN_COEX3: JNGFF2.60 RZ128.1 RZ374.1
WWAN_PWR_EN: CZ198.1 JNGFF2.6 RZ43.1
WWAN_RADIO_DIS#: DZ5.1 RE10.1 UE1.F12
WWAN_RADIO_DIS#_R: DZ5.2 JNGFF2.8
WWAN_WAKE#: JNGFF2.23 RE38.1 UE1.M13
XCLK_RBIAS: RH171.2 RH435.2 UH1.T3
XDP_DBRESET#: CC32.1 JXDP1.48 RC137.1 RH66.1 UC3.1
XDP_OBS0: RC239.1 UC1.BR27
XDP_OBS0_R: JXDP1.21 RC239.2
XDP_OBS1: RC240.1 UC1.BT27
XDP_OBS1_R: JXDP1.23 RC240.2
XDP_PRSNT_PIN1: JXDP1.1 RC121.1 RC122.1
XTAL24_IN_R: CH13.1 RH153.1 RH436.2 YH2.3
XTAL24_IN_R1: RH436.1 UH1.U10
XTAL24_OUT: RH437.2 YH2.1
XTAL24_OUT_R: CH14.1 RH152.2 RH153.2 RH437.1
XTAL24_OUT_R1: RH152.1 UH1.U9
XTALI: CL14.1 RL11.2 UL1.10 YL1.1
XTALO: RL11.1 RL34.2 UL1.9
XTALO_R: CL13.1 RL34.1 YL1.3
Z2805: RL18.1 TL1.24
Z2806: RL16.1 TL1.18
Z2807: RL17.1 TL1.21
Z2808: RL15.1 TL1.15
N04748: PC939.1 PR929.1 PU901.3
N13770063: JDIMM1.165 T51.1(TP-1)
N13800829: CD31.2 RD18.1
N13826355: JDIMM2.165 T53.1(TP-1)
N13829184: CD62.2 RD31.1
N14169789: QN1.5 QN1.6 RN2.2
N14170537: CZ130.1 UZ23.6
N16400770: PR901.3 PR910.1
N16624469: CT90.1 RT111.2 UT7.3
N16775301: PC208.2 PR204.2 PR206.1 PU200.16
N16775385: PC218.1 PU200.3
N16775433: PC204.1 PR202.2
N16775513: PC205.1 PR203.2
N16775517: PR203.1 PU200.12
N16776853: PC207.1 PU200.14
N17114118: QV2.1 RV5.2
N17115081: JEDP1.21 LV1.1
N17142422: RI14.2 UI3.16
N17150215: CZ38.2 RZ334.1
N17185089: PQ1204.5 PR1218.2
N17185092: PQ1204.6 PR1214.2 PR1218.1
N17185371: PQ1204.2 PR1223.2
N17370862: PC4.2 PQ4.4 PQ5.1 PR11.2 PR16.1
N17370917: PQ5.2 PR10.2 PR15.1
N17370921: PQ1.6 PR15.2
N17370927: PQ7.1 PR16.2
N17370961: PL3.1 PQ2.1 PR3.1 PR6.2
N17370983: PQ2.3 PR3.2 PR5.1
N17370995: PQ3.2 PR6.1 PR8.2
N17370999: PQ2.2 PQ3.1 PR7.2
N17371043: PQ6.1 PR18.2
N17371125: PQ7.2 PR20.1
N17371182: PQ6.2 PR23.1 PR30.1
N17371184: PR23.2 PU1.4
N17371196: PR21.2 PU1.1
N17371202: PR22.2 PU1.2
N17371207: PQ8.1 PR22.1 PR27.1
N17372063: PQ1.3 PR17.2 PR19.1
N17372074: PQ1.5 PR25.2
N17372283: PQ1.2 PR19.2
N17372833: PC1206.1 PR1201.2 PR1203.1 PR1219.1 PU1201.3
N17494434: PC1211.1 PD1205.1 PQ1212.1 PR1238.1 PR1239.2 PR1246.1 PR1255.2 PU1201.5
N17509431: PC947.1 PR935.1 PR947.1 PR949.2
N17965667: PQ8.3 PR26.2 PR28.1
N17965677: PQ8.2 PR29.2
N18291828: RT97.2 RT98.1 RT99.1 UT5.F10
N18292036: RT84.1 UT5.F4
N18292038: RT85.1 UT5.G4
N18292318: RT104.1 UT5.K9
N18292320: RT105.1 UT5.K10
N18292328: RT103.1 UT5.L11
N18292433: RT84.2 T219.1(TP-1)
N18292435: RT85.2 T220.1(TP-1)
N18292515: CT87.1 UT5.H7
N18292570: RT101.1 UT5.D6
N18394104: QV4.2 RV18.2
N18394878: RE57.1 RE58.1 UE1.B1
N18394936: RE318.1 UE1.G2
N18398370: QE11.3 RE70.1 RE90.2
N18398380: QE4.2 RE70.2
N18601091: RT63.1 UT5.F1
N18676202: RV124.2 UV6.9
N18676204: RV123.2 UV6.10
N18739564: CA33.1 RA17.2
N18739670: CZ127.1 UZ5.10
N18739690: CZ126.1 UZ5.12
N18739867: CA51.1 RA44.1 UA1.27
N18739871: CA53.1 UA1.7
N18739873: CA52.1 UA1.39
N18739919: RA53.1 RA54.1 UA1.20
N18739929: CA29.1 UA1.35
N18739934: CA29.2 UA1.37
N18739944: CA35.1 UA1.28
N18739946: CA49.1 UA1.34
N18739956: CA25.1 UA1.19
N18877135: JESPI.8 RE375.1 RE560.1
N18964580: CZ109.1 UZ2.12
N18964619: CZ113.1 UZ3.12
N18964663: RZ64.2 RZ65.2 UZ3.3
N18964738: CZ121.1 UZ8.6
N18965068: CZ110.1 UZ2.10
N18965149: CZ117.1 UZ4.12
N18965206: CZ114.1 UZ3.10
N18965394: CZ118.1 UZ4.10
N19191267: JDIMM1.162 T50.1(TP-1)
N19196687: JDIMM2.162 T52.1(TP-1)
N19209026: CL21.1 TL1.10
N19209032: CL17.1 TL1.4
N19209034: CL20.1 TL1.7
N19209038: CL16.1 TL1.1
N19529559: RT378.1 UT5.D1
N19529561: RT379.1 UT5.D2
N20151644: PR901.2 PR909.1
N20163924: QZ3.1 RZ25.1
N20816750: PR2001.1 PU2000.5
N20816752: PC2007.2 PU2000.7
N20816771: PC2007.1 PR2001.2
N20816775: PC2000.2 PR2000.2 PU2000.3
N20816793: PL2000.3 PR2002.1
N20816800: PC2009.2 PR2003.1
N20816821: PC2017.2 PU2001.7
N20816822: PR2005.1 PU2001.5
N20816832: PC2016.2 PR2004.2 PU2001.3
N20816859: PC2017.1 PR2005.2
N20816888: PC2019.2 PR2006.1
N20820556: PL1802.3 PR1802.1
N20820665: PL1803.3 PR1806.1
N20820729: PL1900.3 PR1902.1
N20820776: PL1901.3 PR1906.1
N20872874: CZ56.1 RZ63.1
N20873025: RZ62.1 UZ12.27
N20875020: JNGFF2.58 RZ132.2
N21350915: PQ1205.2 PR1225.1
N21350917: PQ1205.1 PR1215.1 PR1226.2
N21350923: PQ1205.3 PR1221.2 PR1224.1
N21351080: PR1216.2 PU1200.4
N21351086: PR1211.2 PU1200.1
N21351092: PR1215.2 PU1200.2
N21351261: PQ1201.2 PR1216.1 PR1262.1
N21352487: PQ1215.2 PR1251.2 PR1252.1
N21352493: PQ1214.6 PR1252.2
N22120291: PR932.1 PU901.27
N22878895: PR917.3 PR938.2
N23124850: CE57.1 RE350.2
N23239263: RZ360.1 UZ29.2
N23456819: RV620.2 UV6.11
N23602829: QE12.1 RE94.1
N23766683: T194.1(TP-1) UC1.A33
N23770309: T199.1(TP-1) UC1.BP13
N23792182: RC114.1 UC1.BT25
N23795295: T42.1(TP-1) UC1.G13
N23795364: T18.1(TP-1) UC1.B30
N23795366: T19.1(TP-1) UC1.C30
N23795368: T21.1(TP-1) UC1.G3
N23795370: T20.1(TP-1) UC1.J3
N23795372: T24.1(TP-1) UC1.BR31
N23795374: T22.1(TP-1) UC1.BH30
N23795376: T23.1(TP-1) UC1.BR35
N23795378: T1.1(TP-1) UC1.D1
N23795380: T2.1(TP-1) UC1.E1
N23795385: T4.1(TP-1) UC1.E2
N23795387: T5.1(TP-1) UC1.BR1
N23795389: T6.1(TP-1) UC1.BT2
N23795391: T7.1(TP-1) UC1.BN35
N23795393: T8.1(TP-1) UC1.BL34
N23795395: T11.1(TP-1) UC1.BN33
N23795397: T9.1(TP-1) UC1.J24
N23795399: T10.1(TP-1) UC1.H24
N23795401: T12.1(TP-1) UC1.AA14
N23795403: T15.1(TP-1) UC1.AE29
N23795405: T14.1(TP-1) UC1.N29
N23795407: T13.1(TP-1) UC1.R14
N23795412: T28.1(TP-1) UC1.AP29
N23795414: T27.1(TP-1) UC1.AP14
N23795416: T29.1(TP-1) UC1.BK28
N23795418: T30.1(TP-1) UC1.BJ28
N23795436: T41.1(TP-1) UC1.AJ8
N23795438: T44.1(TP-1) UC1.BL31
N23795440: T43.1(TP-1) UC1.B2
N23795442: T45.1(TP-1) UC1.B38
N23795444: T46.1(TP-1) UC1.BP1
N23795446: T47.1(TP-1) UC1.BR2
N23795448: T48.1(TP-1) UC1.C1
N23795450: T49.1(TP-1) UC1.C38
N23797472: T25.1(TP-1) UC1.AW13
N23797474: T26.1(TP-1) UC1.AT13
N23797500: T32.1(TP-1) UC1.AY13
N23797502: T31.1(TP-1) UC1.AU13
N23807582: RZ120.2 UZ26.4 UZ34.4
N23944525: T34.1(TP-1) UH1.Y35
N23944527: T33.1(TP-1) UH1.Y36
N23944529: T36.1(TP-1) UH1.BC1
N23944531: T35.1(TP-1) UH1.AL35
N23948454: T40.1(TP-1) UH1.U13
N23950785: T60.1(TP-1) UH1.R15
N23950786: T61.1(TP-1) UH1.R13
N23950788: T62.1(TP-1) UH1.AN35
N23950789: T63.1(TP-1) UH1.AL37
N23950882: CH321.1 RH28.2
N23950883: CH322.1 RH29.2
N23952498: RH101.2 SW1.2
N23961117: T70.1(TP-1) UH1.U35
N23961134: T66.1(TP-1) UH1.AH14
N23961136: T67.1(TP-1) UH1.AH15
N23961138: T68.1(TP-1) UH1.R32
N23961140: T71.1(TP-1) UH1.U37
N23961142: T72.1(TP-1) UH1.Y15
N23961144: T73.1(TP-1) UH1.Y14
N23961148: T69.1(TP-1) UH1.N32
N23961156: QH6.1 RH433.2
N23961158: CH340.1 QH7.2 RH432.2 RH433.1
N23997893: T59.1(TP-1) UH1.BC22
N23997895: T58.1(TP-1) UH1.BF23
N24088922: QE17.1 RE546.2
N24094798: QV7.1 RV6.1 RV9.1 RV1400.1
N24426370: RV622.2 UV6.12
N24491677: CV633.1 DV11.1 RV626.1 RV627.2
N24491765: QV18.1 RV625.1
N24491790: QV18.2 RV627.1
N24493415: CV635.1 DV12.1 RV629.1 RV631.2
N24493479: QV20.1 RV630.1
N24493490: QV20.2 RV631.1
N24493530: QV20.3 RV632.1 RV1656.2
N25075615: T302.1(TP-1) UH1.AL48
N25137817: JNGFF2.67 T225.1(TP-1)
N25137936: JNGFF2.25 RZ326.1
N26091115: PR405.2 PR425.2 PR2009.2 PU401.14
N26108717: PD905.1 PU903.1
N26116844: PD901.1 PD903.1 PD904.1 PR916.2
N26116940: PC6.1 PQ9.4 PR12.2 PR18.1
N26497504: CV1635.1 QV8.2 RV1400.2
N26498681: QZ18.5 QZ18.6 RZ381.2
N27079153: PC944.1 PR934.2
N27079157: PC930.1 PR914.2
N27079171: PR917.2 PR937.2
N27089997: PC513.1 PR513.2 PR514.1 PU503.5
