# Allegro board LA-F711P R05-0112.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
BC_INT#_ECE1117: length 244.3
  TOP w0.102: v2(213.18,9.09) 213.18,9.08 v1(213.84,8.41) 213.84,7.4 213.18,6.74 213.18,3.56 v2(214.35,2.39)
  TOP w0.104: v2(281.71,11.01) 281.71,11.68 289.32,19.3 289.32,21.85 292.57,25.11 292.57,26.08 292.8,26.3 293.82,27.33 293.82,33.37 297.07,36.62 297.07,37.58 298.68,39.19 298.68,40.53 299.3,41.15 299.3,48.6 298.7,49.2 298.7,51.66 299.12,52.08 301.7,52.08 302.27,52.65 302.77,52.65 305.89,49.53 305.89,47.95 305.96,47.88 305.96,45.2 305.65,44.89 305.65,42.31 306.96,41 310.91,41 311.93,39.97 311.93,38.68 312.86,37.75 312.88,37.75 313.08,37.54 314.13,37.54 UE1.E2
  IN1 w0.099: v2(138.48,8.34) 138.92,8.79 142.35,8.79 142.62,9.06 147.29,9.06 148.31,10.08 161.88,10.08 162.5,10.7 171.07,10.7 171.67,11.31 174.15,11.31 174.15,11.31 177.11,11.31 178.3,12.51 180.86,12.51 184.19,9.18 188.27,9.18 192.83,4.62 193.39,4.62 193.71,4.29 198.58,4.29 199.03,4.75 199.96,4.75 201.87,2.84 203.03,2.84 204.22,1.65 213.85,1.65 214.35,2.14 v2(214.35,2.39)
  IN2 w0.102: v2(281.71,11.01) 281.71,10.73 281.63,10.65 279.83,10.65 277.92,12.56 260.22,12.56 257.08,9.42 243.49,9.42 242.96,9.96 238.8,9.96 238.36,9.52 236.04,9.52 235.35,8.83 232.34,8.83 232.11,9.07 225.24,9.07 224.42,8.24 216.16,8.24 214.85,9.55 213.63,9.55 v2(213.18,9.09)
  BOTTOM w0.102: CZ85.1 136.17,10.79 137.04,10.79 137.52,10.32 JKBTP1.14 137.52,9.49 138.48,8.53 v2(138.48,8.34)
BCM5882_ALERT#: length 43.8
  TOP w0.104: UE1.G10 v2(320.52,35.95)
  IN1 w0.099: v2(320.52,35.95) 320.52,35.13 320.15,34.76 320.15,33.88 320.11,33.85 320.11,27.48 319.07,26.44 v2(318.93,26.44)
  BOTTOM w0.102: JUSH1.13 306.33,6.79 306.35,6.78 306.35,5.99 306.85,5.49 310.33,5.49 311.6,6.76 313.07,6.76 314.48,8.17 314.64,8.17 315.16,8.69 315.16,11.03 319.19,15.05 319.19,20.28 318.46,21.01 318.46,22.63 318.99,23.16 318.99,23.86 RE532.2 318.35,24.51 318.35,25.34 318.64,25.63 318.64,26.14 v2(318.93,26.44)
BEEP: length 52.3
  TOP w0.102: RA13.2 353.82,40.61 v1(353.82,41.73) 353.82,43.56 v2(351.66,45.72)
  TOP w0.104: UE1.H11 v2(322.12,34.35)
  IN2 w0.102: v2(329.79,48.25) 332.02,48.25 332.28,48 341.69,48 343.51,49.81 348.3,49.81 348.47,49.64 348.47,49.18 349.23,48.42 349.44,48.42 351.66,46.2 v2(351.66,45.72)
  IN3 w0.102: v2(322.12,34.35) 324.05,34.35 324.4,34.69 324.4,35.55 325.28,36.43 325.28,36.95 329.26,40.92 329.26,46.78 329.66,47.19 329.66,48.12 v2(329.79,48.25)
BEEP_R: length 7.1
  TOP w0.254: RA13.1 RA45.1 CA62.1 352.6,36.91 351.86,36.17 v1(350.66,36.17) 350.27,36.17 349.59,35.49 CA28.1
BGATE_ISL88738: length 45
  TOP w0.102: 21.85,6.57 v1(21.85,7.53)
  TOP w0.508: PC937.2 23.14,6.74 v2(23.54,7.14)
  IN2 w0.508: v2(6.55,31.72) 5.94,31.11 5.94,26.53 2.43,23.03 2.43,16.71 7.78,11.35 7.78,9.55 10.63,6.71 23.11,6.71 v2(23.54,7.14)
BIA_PWM: length 24
  BOTTOM w0.102: DV1.1 129.52,95.34 127.69,97.17 120.77,97.17 117.87,100.06 v1(116.56,100.06) 114.89,100.06 RV1.1 LV1.2
BIA_PWM_EC: length 249.2
  TOP w0.104: v2(308.16,28.42) 308.16,27.98 v1(308.36,27.79) 309.43,27.79 310.26,28.61 310.87,28.61 311.19,28.93 311.78,28.93 313.6,30.75 UE1.N1
  IN3 w0.102: v2(308.16,28.42) 308.16,30.25 307.46,30.95 307.46,33.41 306.62,34.25 306.62,35.39 307.01,35.78 307.01,38.65 307.69,39.33 307.69,46.05 307.93,46.29 307.93,47.04 311.25,50.35 v2(311.25,50.69)
  BOTTOM w0.102: DV1.2 140.7,90.77 145.27,90.77 145.94,90.09 157.26,90.09 164.8,82.55 173.34,82.55 173.59,82.3 175.08,82.3 179.8,77.57 198.64,77.57 206.89,69.32 206.89,66.41 206.13,65.65 205.85,65.65 205.62,65.41 205.62,64.35 213.43,56.54 221.29,56.54 236.12,41.71 238.25,41.71 242.57,37.39 248.29,37.39 250.16,35.52 280.63,35.52 284.34,39.23 284.34,45.03 291.15,51.84 297.5,51.84 298.14,52.49 301.62,52.49 303.68,50.43 308.52,50.43 308.77,50.69 v2(311.25,50.69)
BIA_PWM_PCH: length 132.6
  IN2 w0.102: v2(209.6,21.63) 209.73,21.77 209.73,23.86 208.57,25.02 208.57,26.15 208.29,26.43 207.68,26.43 207.24,26.86 205.59,26.86 205.4,27.05 200.34,27.05 200.3,27.09 196.95,27.09 196.26,26.41 194.95,26.41 194.33,27.03 191.66,27.03 189.81,28.88 185.71,28.88 185.24,29.35 182.93,29.35 173,39.29 173,57.93 171.24,59.68 v2(171.24,82.07)
  BOTTOM w0.089: UH1.AU48 210.07,20.74 210.07,21.16 v2(209.6,21.63)
  BOTTOM w0.102: DV1.3 139.63,90.54 145.18,90.54 145.85,89.86 156.92,89.86 v1(160.28,86.51) 164.72,82.07 v2(171.24,82.07)
BIOS_REC: length 11.3
  TOP w0.102: RH76.2 211.98,14.01 v1(211.98,15) 211.98,18.89 210.4,20.47 210.4,21.01 210.9,21.51 210.9,21.75 210.92,21.77 210.93,21.77 211.15,22 211.15,22.4 210.33,23.21 v2(210.14,23.21)
  BOTTOM w0.089: v2(210.14,23.21) 210.08,23.28 UH1.AR42
BL_PWR_MONITOR: length 4.3
  BOTTOM w0.102: RV625.2 150.42,96.49 QV19.2 151.35,95.91 151.74,96.29 v1(151.74,98.28)
BL_PWR_SRC_ON: length 7.5
  TOP w0.102: v1(126.65,113.38) RV4.1 126.34,114.7 125.38,114.7 125.12,114.44 QV1.3 125.12,113.75 RV5.1 CV14.1 CV13.1
BLUE: length 11.5
  TOP w0.107: v2(358.57,100.61) 358.82,100.35 LV18.2 358.9,99.8 CV131.1 v1(361.06,99.8) 362.38,99.8 363.02,99.16 363.59,99.16 JCRT1.3
  BOTTOM w0.107: DV6.2 356.38,100.1 357.64,100.1 358.14,100.61 v2(358.57,100.61)
BLUE_CRT: length 46.8
  TOP w0.107: v2(354.63,99.97) 355.72,98.88 RV118.1 CV128.1 358.74,98.88 LV18.1 ; v2(331.69,72.15) 331.69,72.08 330.88,71.27 330.64,71.27 330.4,71.03 UV6.21
  IN1 w0.099: v2(331.69,72.15) 331.69,72.41 332.25,72.98 332.25,80.56 351.89,100.2 354.4,100.2 v2(354.63,99.97)
BOARD_ID: length 6.3
  TOP w0.102: 326.97,36.17 327.13,36.01 327.39,36.01 328.04,35.36 RE79.2
  TOP w0.104: UE1.J13 323.78,33.95 324.51,34.69 324.9,34.69 325.73,35.59 CE40.1 325.73,36.01 325.88,36.17 326.97,36.17
BOOT1_ISL88738: length 2.5
  TOP w0.203: v2(13.05,33.86) 12.59,33.86 12.35,33.61 PU901.12
  BOTTOM w0.102: PR914.1 v1(13.91,35.08)
BOOT2_ISL88738:
  vias: v1(9.27,30.48)
BREATH_LED#: length 94.9
  TOP w0.102: v2(343.96,108.71) v1(343.29,108.71)
  TOP w0.104: v2(323.85,41.33) 323.76,41.33 322.85,40.42 322.85,40.22 322.66,40.02 322.54,40.02 322.2,39.68 322.2,39.22 UE1.C11
  IN3 w0.102: v2(343.96,108.71) 343.38,108.13 343.38,67.06 342.47,66.15 342.47,63.88 340.18,61.58 334.66,61.58 333.88,60.81 v2(328.8,60.81)
  BOTTOM w0.102: QZ7.4 349.74,109.29 349.17,108.71 v2(343.96,108.71) ; v2(323.85,41.33) 324,41.33 324.25,41.59 324.25,41.59 324.49,41.83 324.5,41.83 324.6,41.93 326.18,41.93 327.39,43.15 327.39,47.46 328.11,48.18 328.11,51.1 327.86,51.36 327.86,56.49 328.6,57.23 328.6,60.6 v2(328.8,60.81)
BREATH_LED#_Q: length 2.3
  BOTTOM w0.102: RZ32.1 v1(352.73,109.52)
  BOTTOM w0.203: RZ32.1 352.23,110.69 352.17,110.75 QZ7.3
BREATH_WHITE_LED_SNIFF#: length 13.7
  TOP w0.102: LED3.1 v1(351.05,124.59)
  TOP w0.203: v2(351.33,122.45) 351.06,122.72 LED3.1
  BOTTOM w0.203: v2(351.33,122.45) 352.73,121.06 RZ32.2
BST_3V: length 1.3
  BOTTOM w0.102: v1(87.45,3.53) 87.85,3.93 PR100.1
BST_+1VALWP_R: length 1.5
  BOTTOM w0.102: PR304.1 171.1,2.13 v1(171.81,1.42)
BT_RADIO_DIS#: length 40.5
  TOP w0.102: v2(306.85,47.02) 306.75,46.92 v1(306.75,46.18) 306.75,45.01 307.54,44.22 308.4,44.22 308.86,43.76 RE11.1 309.37,43.71 ; v2(303.6,29.12) 303.05,28.57 DZ2.1
  TOP w0.104: UE1.C2 314.11,39.16 313.65,39.16 313.39,39.41 313.39,39.63 312.83,40.2 312.83,40.32 309.44,43.71 309.37,43.71
  IN3 w0.102: v2(306.85,47.02) 306.44,46.61 301.98,46.61 301.71,46.34 301.71,42.74 301.37,42.39 301.37,34.31 300.66,33.6 300.66,32.49 303.6,29.54 v2(303.6,29.12)
BT_RADIO_DIS#_R: length 3.7
  TOP w0.102: v1(301.35,26.95) DZ2.2 300.95,25.74 300.63,25.43 v2(300.63,25.4)
  BOTTOM w0.102: JNGFF1.54 300.67,25.36 v2(300.63,25.4)
C10_PWR_GATE#: length 7.3
  BOTTOM w0.102: RZ542.1 140.24,85.47 UZ61.4 140.24,84.47 140.59,84.12 141.83,84.12 RH620.1 143.6,85.19 v1(144.28,85.88)
C10_PWR_GATE#_R: length 4.5
  BOTTOM w0.102: UZ35.1 144.98,85.26 144.71,85.52 144.51,85.52 144.14,85.15 144.14,84.45 v1(143.96,84.28) RH620.2 RH619.2
CAM_MIC_CBL_DET#: length 178.9
  IN2 w0.102: v2(177.01,85.32) 177.19,85.14 177.19,79.88 179.14,77.93 179.14,74.53 177.85,73.24 177.85,57.12 180.56,54.41 185.07,54.41 188.88,58.22 192.23,58.22 196.7,53.75 197.66,53.75 198.48,54.56 207.34,54.56 211.45,50.45 211.45,47.63 210.96,47.14 210.96,41.86 209.56,40.47 209.56,39.53 210.48,38.61 v2(210.66,38.61) 210.93,38.34 212.62,38.34 212.87,38.59 216.2,38.59 217.34,37.45 220.64,37.45 221.98,38.79 223.76,38.79 v2(223.99,38.56)
  BOTTOM w0.089: UH1.AW13 210.76,38.61 v2(210.66,38.61)
  BOTTOM w0.102: RH319.2 224.12,38.65 224.03,38.56 v2(223.99,38.56) ; JEDP1.14 117.15,107.2 117.29,107.34 117.64,107.34 127.69,117.38 142.9,117.38 162.19,98.09 162.19,96.26 v1(172.01,86.43) 173.07,85.38 176.56,85.38 176.63,85.32 v2(177.01,85.32)
CFG0: length 95
  TOP w0.102: JXDP1.9 34.67,40.46 34.34,40.79 v2(34.34,41.05) ; RC126.1 42.13,35.58 40.92,34.37 38.15,34.37 37.69,34.82 v2(37.69,36.7) ; v2(82.63,71.04) 82.07,70.48 80.92,70.48 80.22,69.79 v1(79.41,69.79) 77.39,69.79 77.1,69.49 75.73,69.49 RC321.1
  IN1 w0.099: v2(37.69,36.7) 37.41,36.42 34.79,36.42 34.34,36.88 v2(34.34,41.05) 33.7,41.68 33.7,42.19 32,43.89 32,47.13 33.81,48.95 37.53,48.95 39.81,51.22 55.95,51.22 55.95,51.22 56.23,51.22 71.41,66.4 72.3,66.4 75.95,70.05 80.38,70.05 81.78,71.45 82.23,71.45 v2(82.63,71.04)
  BOTTOM w0.076: UC1.BN25 82.31,70.72 v2(82.63,71.04)
CFG1: length 81
  TOP w0.102: JXDP1.11 35.17,40.85 34.46,41.55 33.57,41.55 v2(33.19,41.93) ; RC436.1 75.56,71.23 75.56,70.92 75.76,70.71 76.21,70.71 76.69,71.2 77.46,71.2 78.01,71.75 80.15,71.75 80.36,71.95 82.28,71.95 82.63,72.3 v2(82.63,72.62)
  IN1 w0.099: v2(82.63,72.62) 81.83,71.82 81.77,71.82 80.4,70.45 76.03,70.45 72.2,66.63 71.32,66.63 56.13,51.45 56.04,51.45 39.71,51.45 39.14,50.88 36.7,50.88 35.15,49.33 33.88,49.33 31.78,47.23 31.78,43.48 33.19,42.06 v2(33.19,41.93)
  BOTTOM w0.076: v2(82.63,72.62) 82.31,72.29 UC1.BN27
CFG2: length 78
  TOP w0.102: v2(81.98,71.04) v1(81.26,71.04) 80.85,71.04 79.93,70.13 77.29,70.13 77.07,69.91 75.08,69.91 RC181.1 ; v2(34.21,42.06) 34.39,42.24 35.18,42.24 36.17,41.25 JXDP1.15
  IN1 w0.099: v2(81.98,71.04) 80.76,69.83 76.04,69.83 72.39,66.18 71.5,66.18 56.32,50.99 55.85,50.99 55.85,51 39.9,51 37.6,48.69 33.88,48.69 32.23,47.04 32.23,44.04 v2(34.21,42.06)
  BOTTOM w0.076: v2(81.98,71.04) 82.31,71.37 UC1.BN26
CFG3: length 79.9
  TOP w0.102: v1(35.54,36.17) 36.24,36.87 RC121.2 36.61,37.34 36.67,37.41 JXDP1.17 36.67,40.54 36.5,40.71 36.5,41.43 35.3,42.62 32.86,42.62 32.69,42.44 32.69,41.81 v2(33.19,41.3)
  IN1 w0.099: v2(33.19,41.3) 31.55,42.94 31.55,47.32 33.94,49.71 34.97,49.71 36.37,51.1 39.05,51.1 39.62,51.67 56.04,51.67 71.22,66.85 72.11,66.85 75.94,70.68 80.04,70.68 v2(81.98,72.62)
  BOTTOM w0.076: UC1.BN28 82.31,72.94 v2(81.98,72.62)
CFG4: length 61.9
  TOP w0.102: v2(78.57,67.5) 78.57,67.11 v1(77.71,66.26) 76.46,66.26 75.7,65.49 75.7,64.74 RC322.1 ; v2(38.96,42.44) 39.01,42.39 39.01,41.05 39.17,40.89 JXDP1.27
  IN1 w0.099: v2(38.96,42.44) 39.05,42.44 39.47,42.86 39.47,43.46 43.91,47.9 55.8,47.9 67.54,59.64 67.55,59.64 68.73,59.64 76.17,67.08 78.14,67.08 v2(78.57,67.5)
  BOTTOM w0.076: v2(78.57,67.5) 79.2,66.87 80.1,66.87 80.23,67.01 80.71,67.01 UC1.BR20
CFG5: length 62.5
  TOP w0.102: JXDP1.29 v2(39.67,41.17) ; v2(82.63,66.32) v1(81.84,65.53) 81.23,64.92 78.97,64.92 78.34,64.29 77.77,64.29 RC323.1
  IN1 w0.099: v2(39.67,41.17) 39.85,41.35 41.95,41.35 46.85,46.25 56.39,46.25 68.2,58.06 68.2,58.06 68.39,58.06 69.46,58.06 75.4,64.01 78.76,64.01 79.22,64.46 80.13,64.46 81.99,66.32 v2(82.63,66.32)
  BOTTOM w0.076: v2(82.63,66.32) 82.96,66.64 UC1.BM20
CFG6: length 59.8
  TOP w0.102: v2(39.06,43.03) 39.37,42.72 39.37,42.11 40.51,40.97 40.51,40.34 40.67,40.18 JXDP1.33 ; v2(77.37,67.54) 76.61,66.78 76.51,66.78 v1(76.26,66.52) 75.24,65.5 RC324.1
  IN1 w0.099: v2(77.37,67.54) 76.3,67.54 68.63,59.87 67.45,59.87 55.74,48.16 43.84,48.16 39.06,43.38 v2(39.06,43.03)
  BOTTOM w0.076: UC1.BT20 80.21,66.57 78.41,66.57 78.02,66.95 77.92,66.95 77.7,67.17
  BOTTOM w0.127: v2(77.37,67.54) 77.37,67.5 77.7,67.17
CFG7: length 62.5
  TOP w0.102: v2(79.2,67.5) 78.73,67.97 77.14,67.97 v1(76.89,67.73) 75.92,66.75 75.34,66.75 75.24,66.65 RC325.1 ; JXDP1.35 41.17,40.31 41.35,40.49 41.35,41.35 40.36,42.34 v2(40.05,42.34)
  IN1 w0.099: v2(40.05,42.34) 39.77,42.62 39.77,43.45 43.99,47.67 55.88,47.67 67.63,59.42 67.64,59.42 68.84,59.42 75.94,66.52 78.22,66.52 v2(79.2,67.5)
  BOTTOM w0.076: UC1.BP20 81.36,67.01 81.13,67.01 80.93,67.21 80.1,67.21 79.98,67.08 79.62,67.08 v2(79.2,67.5)
CFG8: length 62.7
  TOP w0.102: v2(34.29,47.35) 34.74,46.89 34.74,46.28 34.67,46.2 JXDP1.10 ; v2(78.31,69.08) 77.88,68.64 77.31,68.64 76.95,69.01 v1(76.49,69.01) 76.21,69.01 RC437.1
  IN1 w0.099: v2(78.31,69.08) 77.91,69.48 76.01,69.48 72.48,65.95 71.6,65.95 56.42,50.77 55.76,50.77 55.76,50.77 40,50.77 37.51,48.28 35.23,48.28 v2(34.29,47.35)
  BOTTOM w0.076: v2(78.31,69.08) 78.7,69.47 80.61,69.47 UC1.BR23
CFG9: length 58
  TOP w0.102: v2(35.53,47.35) 35.28,47.35 v1(35.05,47.12) 35.05,46.3 35.17,46.18 JXDP1.12
  IN1 w0.099: v2(35.53,47.35) 36.19,48.01 37.67,48.01 40.21,50.54 55.66,50.54 55.66,50.54 56.52,50.54 71.49,65.51 v2(72.23,65.51)
  BOTTOM w0.076: 76.1,66.23 76.79,66.92 76.79,67.46 77.24,67.91 80.63,67.91 UC1.BR22
  BOTTOM w0.102: 76.1,66.23 75.58,65.71 RC438.1 75.58,65.05 RC439.1 72.69,65.05 v2(72.23,65.51)
CFG10: length 60.1
  TOP w0.102: v2(36.39,46.84) 36.39,46.35 36.17,46.13 JXDP1.16 ; v2(78.95,69.08) 78.95,68.67 v1(78.58,68.31) 76.42,68.31 RC440.1
  IN1 w0.099: v2(36.39,46.84) 36.98,47.42 37.77,47.42 39.49,49.15 55.77,49.15 67.17,60.55 67.17,60.55 70.2,63.58 71.35,63.58 76.22,68.45 78.32,68.45 v2(78.95,69.08)
  BOTTOM w0.076: UC1.BT23 79.96,68.68 79.34,68.68 v2(78.95,69.08)
CFG11: length 57.8
  TOP w0.102: v2(36.37,47.5) 36.57,47.5 36.8,47.27 v1(36.8,47.19) 36.8,46.25 36.67,46.12 JXDP1.18
  IN1 w0.099: v2(72.87,65.71) 72.87,65.43 71.27,63.83 70.13,63.83 56.62,50.32 40.31,50.32 37.69,47.7 36.57,47.7 v2(36.37,47.5)
  BOTTOM w0.076: UC1.BT22 80.16,68.1 76.88,68.1 76.63,67.84 76.63,67.08 76.1,66.56
  BOTTOM w0.102: RC441.1 72.06,66.51 v2(72.87,65.71) 75.26,65.71 76.1,66.56
CFG12: length 66.1
  TOP w0.102: JXDP1.28 39.17,43.58 39.59,43.15 39.59,42.21 v2(40.94,40.87) ; v2(83.28,66.32) 83.28,65.86 82.07,64.65 79.26,64.65 77.37,62.76 RC442.1
  IN1 w0.099: v2(40.94,40.87) 40.97,40.89 42.08,40.89 47.19,46 56.46,46 68.29,57.83 68.3,57.84 69.55,57.84 74.36,62.64 75.28,62.64 76.42,63.78 78.86,63.78 79.32,64.24 80.26,64.24 81,64.97 81.93,64.97 v2(83.28,66.32)
  BOTTOM w0.076: UC1.BM19 82.96,66 v2(83.28,66.32)
CFG13: length 55.2
  TOP w0.102: JXDP1.30 39.67,43.69 40.08,43.28 v2(40.18,43.28) ; v2(79.05,65.34) 79.05,65.32 78.25,64.52 RC443.1
  IN1 w0.099: v2(40.18,43.28) 40.18,43.27 40.8,42.65 42.07,42.65 46.4,46.99 56.16,46.99 67.92,58.74 67.92,58.74 68.67,58.74 69.13,58.74 75.09,64.69 78.4,64.69 v2(79.05,65.34)
  BOTTOM w0.076: UC1.BR19 81.01,65.88 80.6,65.47 80.06,65.47 79.85,65.68 79.39,65.68 v2(79.05,65.34)
CFG14: length 53
  TOP w0.102: JXDP1.34 40.67,43.35 v2(40.76,43.26)
  IN1 w0.099: v2(40.76,43.26) 41.14,42.88 41.97,42.88 46.31,47.21 56.07,47.21 67.82,58.96 67.83,58.97 68.77,58.97 69.04,58.97 74.99,64.92 77.99,64.92 v2(78.41,65.34)
  BOTTOM w0.076: v2(78.41,65.34) 78.41,65.41 78.96,65.96 79.91,65.96 80.23,65.63 80.53,65.63 80.65,65.76 80.65,66.02 80.88,66.25 81.34,66.25 UC1.BP19
CFG15: length 51
  TOP w0.102: JXDP1.36 41.17,43.51 41.35,43.33 v2(41.35,43.28)
  IN1 w0.099: v2(41.35,43.28) 41.45,43.38 41.45,44.27 44.62,47.44 55.98,47.44 67.73,59.19 67.73,59.19 68.86,59.19 68.86,59.19 68.94,59.19 75.09,65.34 v2(77.07,65.34)
  BOTTOM w0.076: UC1.BT19 80.09,66.19 77.73,66.19 77.07,65.53 v2(77.07,65.34)
CFG16: length 60.6
  TOP w0.102: v1(33.7,47.19) v2(33.7,46.63) 33.67,46.6 JXDP1.6
  IN1 w0.099: v2(33.7,46.63) 34.11,46.23 37.59,46.23 37.9,46.54 37.9,47.18 39.57,48.84 55.78,48.84 67.26,60.32 67.26,60.32 69.03,62.08 70.18,62.08 76.27,68.17 76.83,68.17 80.03,68.17 v2(81.33,69.47)
  BOTTOM w0.076: UC1.BP23 81.66,69.14 v2(81.33,69.47)
CFG17: length 62.9
  TOP w0.102: JXDP1.4 33.17,46.77 v2(33.11,46.83) 32.67,47.27 v1(32.3,47.27)
  IN1 w0.099: v2(33.11,46.83) 33.11,46.66 33.76,46 37.9,46 38.26,46.36 38.26,47.15 39.65,48.54 55.8,48.54 67.35,60.1 68.53,60.1 76.37,67.94 80.46,67.94 v2(81.98,69.47)
  BOTTOM w0.076: v2(81.98,69.47) 82.31,69.14 UC1.BN23
CFG18: length 59.7
  TOP w0.102: JXDP1.24 38.17,43.05 v2(37.66,42.54)
  IN1 w0.099: v2(82.63,67.89) 81.98,67.24 81.98,66.65 80.03,64.69 79.09,64.69 78.63,64.24 75.28,64.24 69.33,58.29 68.48,58.29 68.11,58.29 68.1,58.29 56.32,46.51 46.76,46.51 41.86,41.61 38.6,41.61 v2(37.66,42.54)
  BOTTOM w0.076: v2(82.63,67.89) 82.31,68.22 UC1.BN22
CFG19: length 58.2
  TOP w0.102: JXDP1.22 v2(37.67,43.33)
  IN1 w0.099: v2(37.67,43.33) 38.43,42.57 38.43,42.4 39,41.83 41.77,41.83 46.7,46.76 56.26,46.76 68.01,58.51 68.02,58.51 68.58,58.51 69.23,58.51 75.18,64.46 78.51,64.46 78.96,64.92 79.94,64.92 81.33,66.32 v2(81.33,67.89)
  BOTTOM w0.076: v2(81.33,67.89) 81.66,68.22 UC1.BP22
CHR_USB20_N1: length 2.2
  TOP w0.097: UI3.11 340,71.01 340.17,71.18 340.17,71.37 340.06,71.49 340.06,71.88 339.88,72.06 LI7.1
CHR_USB20_N1_R: length 24.4
  TOP w0.097: v2(339.91,74.9) 340.11,74.7 340.11,74.39 339.88,74.16 LI7.2 ; JUSB1.2 356.26,69.09 355.51,69.09 355.47,69.05 354.88,69.05 354.84,69.09 353.89,69.09 DI5.2 353.01,68.78 352.83,68.96 352.44,68.96 351.52,69.87 351.52,70.81 v2(351.33,71.01)
  IN1 w0.099: v2(339.91,74.9) 340.1,74.71 340.1,74.35 340.51,73.94 350.21,73.94 351.51,72.64 351.51,71.19 v2(351.33,71.01)
CHR_USB20_P1: length 2.2
  TOP w0.097: LI7.4 340.48,72.11 340.24,71.87 340.24,71.56 340.36,71.45 340.36,71.17 340.5,71.03 UI3.10
CHR_USB20_P1_R: length 24.4
  TOP w0.097: LI7.3 340.48,74.16 340.3,74.34 340.3,74.7 v2(340.5,74.9) ; JUSB1.3 356.22,69.27 v4(355.18,69.27) 353.89,69.27 DI5.3 353.01,69.3 352.86,69.15 352.52,69.15 351.71,69.95 351.71,70.81 v2(351.91,71.01)
  IN1 w0.099: v2(351.91,71.01) 351.72,71.19 351.72,72.73 350.3,74.15 340.6,74.15 340.31,74.43 340.31,74.71 v2(340.5,74.9)
CLK_CNV_PRX_DTX_N: length 105.2
  IN1 w0.099: v2(289.96,25.55) 290.17,25.35 290.17,25.14 290.53,24.78 290.53,24.38 290.44,24.28 288.78,24.28 288.38,23.88 282.85,23.88 282.44,24.28 281.51,24.28 281.06,24.73 271.98,24.73 271.86,24.85 270.34,24.85 268.06,27.14 255.9,27.14 255.45,26.69 243.49,26.69 241.89,28.29 238.94,28.29 237.4,29.83 234.78,29.83 230.5,34.1 230.5,36.04 228.31,38.23 227.77,38.23 225.41,40.59 225.41,41.73 225.06,42.08 224.53,42.08 221.78,44.83 219.5,44.83 219.08,45.24 215.9,45.24 215.06,44.41 215.06,43.47 214.96,43.38 213.46,43.38 213.24,43.15 213.24,42.71 213.59,42.35 v2(213.59,42.24)
  BOTTOM w0.089: v2(213.59,42.24) 213.71,42.17 UH1.BD4
  BOTTOM w0.097: JNGFF1.21 293.82,33.61 293.66,33.45 291.2,33.45 289.66,31.91 289.66,28.68 290.01,28.32 290.01,25.6 v2(289.96,25.55)
CLK_CNV_PRX_DTX_P: length 104.8
  IN1 w0.089: v2(213.86,42.78) 213.77,42.7
  IN1 w0.099: v2(290.55,25.55) 290.38,25.38 290.38,25.23 290.74,24.86 290.74,24.3 290.52,24.07 288.87,24.07 288.46,23.66 282.76,23.66 282.35,24.07 281.43,24.07 280.98,24.52 271.89,24.52 271.77,24.64 270.25,24.64 267.97,26.92 255.99,26.92 255.54,26.48 243.41,26.48 241.8,28.08 238.85,28.08 237.31,29.62 234.69,29.62 230.29,34.02 230.29,35.96 228.23,38.02 227.68,38.02 225.2,40.51 225.2,41.64 224.97,41.87 224.44,41.87 221.69,44.62 219.41,44.62 218.99,45.03 215.99,45.03 215.27,44.32 215.27,43.39 215.05,43.16 213.55,43.16 213.45,43.07 213.45,42.79 213.55,42.7 213.77,42.7
  BOTTOM w0.089: UH1.BE3 v2(213.86,42.78)
  BOTTOM w0.097: v2(290.55,25.55) 290.2,25.9 290.2,28.4 289.84,28.76 289.84,31.84 291.27,33.27 293.66,33.27 293.82,33.11 JNGFF1.23
CLK_CNV_PTX_DRX_N: length 98.1
  IN1 w0.089: v2(212.84,41.42) 213.03,41.24 213.52,41.24 213.67,41.09 213.91,41.09 214.65,40.35 217.7,40.35 218.08,39.97 220.61,39.97 221.52,39.06 221.68,39.06 221.7,39.07 221.72,39.07
  IN1 w0.099: v2(296.02,22.95) 296.02,22.45 295.92,22.35 295.05,22.35 294.26,21.56 289.83,21.56 289.68,21.41 271.78,21.41 270.79,22.4 269.32,22.4 267.06,24.66 264.41,24.66 264.05,24.3 261.49,24.3 261.42,24.23 242.19,24.23 240.79,25.64 240.18,25.64 239.98,25.84 237.92,25.84 236.39,27.37 233.72,27.37 225.4,35.69 224.96,35.69 224.65,36 223.91,36 222.76,37.14 222.76,38.64 222.33,39.07 221.72,39.07
  BOTTOM w0.089: v2(212.84,41.42) UH1.BC5
  BOTTOM w0.097: JNGFF1.71 295.64,21.11 295.7,21.04 295.7,20.88 295.79,20.8 296.13,20.8 296.22,20.89 296.22,22.82 296.1,22.95 v2(296.02,22.95)
CLK_CNV_PTX_DRX_P: length 98.2
  IN1 w0.089: 221.72,38.86 221.7,38.86 221.68,38.88 221.44,38.88 220.53,39.79 218.01,39.79 217.63,40.17 214.58,40.17 213.83,40.91 213.37,40.91 v2(213.33,40.87)
  IN1 w0.099: v2(296.65,22.95) 296.59,22.95 296.23,22.59 296.23,22.36 296.01,22.14 295.14,22.14 294.34,21.35 289.92,21.35 289.77,21.2 271.69,21.2 270.7,22.19 269.24,22.19 266.97,24.45 264.5,24.45 264.14,24.09 261.58,24.09 261.51,24.02 242.1,24.02 240.7,25.43 240.1,25.43 239.89,25.63 237.83,25.63 236.3,27.16 233.63,27.16 225.31,35.48 224.87,35.48 224.56,35.79 223.82,35.79 222.55,37.06 222.55,38.55 222.24,38.86 221.72,38.86
  BOTTOM w0.089: UH1.BB6 v2(213.33,40.87)
  BOTTOM w0.097: v2(296.65,22.95) 296.41,22.71 296.41,20.81 296.2,20.61 JNGFF1.73
CLK_DDC2_CRT: length 58.4
  TOP w0.107: UV6.15 328.33,68.24 328.6,67.97 329.36,67.97 v2(329.99,68.6)
  IN1 w0.099: v2(349.8,86.38) 343.5,86.38 343.5,86.39 342.13,86.39 340.8,85.05 339.93,85.05 334.12,79.24 334.12,78.9 334.12,72.68 332.31,70.88 330.64,70.88 329.77,70 329.77,69.5 329.99,69.27 v2(329.99,68.6)
  BOTTOM w0.107: v2(349.8,86.38) 349.8,84.98 351.62,83.16 358.71,83.16 359.46,83.92 RV120.1 360.31,84.95 v1(360.89,85.53) 361.49,86.13 361.49,91.46 JCRT1.15
CLK_PCIE_N0: length 183.1
  IN1 w0.099: v2(206.13,41.45) 206.32,41.31 207.12,41.31 208.09,42.28 208.09,44.9 210.07,46.88 216.51,46.88 216.81,47.18 216.81,47.95 218.34,49.48 221.12,49.48 230.31,40.3 230.31,39.71 237.53,32.49 238.59,32.49 240.08,30.99 243.65,30.99 245.05,29.59 269.36,29.59 271.64,27.31 272.87,27.31 272.99,27.19 287.18,27.19 287.4,26.97 300.58,26.97 305.38,31.77 305.38,34.13 302.71,36.81 302.71,45.31 302.33,45.69 302.33,51.52 303.87,53.07 306.42,53.07 309.52,56.17 312.66,56.17 315.04,53.78 319.83,53.78 322.1,56.06 328.23,56.06 329.54,57.37 331.81,57.37 332.22,56.96 335.3,56.96 335.72,56.54 337.16,56.54 337.69,56.01 338.51,56.01 v2(338.69,56.2)
  BOTTOM w0.094: v2(206.13,41.45) 206.4,41.45 UH1.AJ6
  BOTTOM w0.097: JNGFF2.53 337.65,55.45 338.13,55.93 338.42,55.93 v2(338.69,56.2)
CLK_PCIE_N1: length 107.1
  IN3 w0.089: 221.72,41.05 221.7,41.05 221.68,41.03 220.72,41.03 218.23,41.03 217.44,40.25 212.15,40.25 211.24,39.34 209.6,39.34 209.43,39.51 208.96,39.51 208.42,38.97 207.38,38.97 207.1,39.25 206.85,39.67 v2(206.85,39.67)
  IN3 w0.102: 221.72,41.05 222.39,41.05 226.63,36.81 226.9,36.81 230.57,33.13 230.57,32.78 235.22,28.13 237.03,28.13 239.83,25.33 256.73,25.33 257.1,24.97 262.28,24.97 262.53,25.22 270.78,25.22 271.97,26.41 279.44,26.41 280.89,27.86 291.03,27.86 293.03,29.86 297.23,29.86 297.46,29.63 297.46,29.49 v2(297.71,29.23)
  BOTTOM w0.094: UH1.AH9 206.81,39.7 v2(206.85,39.67)
  BOTTOM w0.097: v2(297.71,29.23) 297.51,29.04 297.51,27.33 296.94,26.77 295.77,26.77 295.61,26.61 JNGFF1.49
CLK_PCIE_N3: length 163.9
  IN3 w0.089: v2(205.21,41.16) 205.21,40.95 205.29,40.87 205.61,40.87 205.89,40.59 205.89,38.47 206.64,37.72 211.03,37.72 211.25,37.93 211.72,37.93 212.05,38.27 212.38,38.27 212.61,38.49 214.67,38.49 215.34,37.82 218.56,37.82 220.14,36.23 220.23,36.23 221.35,35.11 221.68,35.11 221.7,35.13 221.72,35.13
  IN3 w0.102: 221.72,35.13 224,35.13 224.65,34.49 228.06,34.49 229.87,32.68 229.87,32.49 234.93,27.43 236.74,27.43 239.54,24.63 256.44,24.63 256.8,24.27 262.93,24.27 263.18,24.52 271.07,24.52 272.23,25.67 279.7,25.67 281.16,27.14 292.52,27.14 293.4,28.02 299,28.02 304.11,22.91 306.52,22.91 306.69,22.74 309.8,22.74 310,22.55 315.36,22.55 317.16,20.74 332.71,20.74 332.95,20.98 339.34,20.98 340.64,19.69 341.17,19.69 341.71,19.15 341.71,18.7 v2(341.91,18.5)
  BOTTOM w0.094: v2(205.21,41.16) UH1.AE6
  BOTTOM w0.097: JNGFF3.53 347.55,10.26 347.43,10.39 347.43,11.31 345.37,13.36 345.37,13.42 344.96,13.83 344.9,13.83 v4(343.3,15.43) 341.71,17.02 341.71,18.3 v2(341.91,18.5)
CLK_PCIE_N4: length 189.6
  TOP w0.097: UL1.45 322.25,82.19 322.95,81.5 322.95,78.35 322.78,78.18 322.7,78.18 322.38,77.86 v2(322.38,77.78)
  IN1 w0.099: v2(204.14,48.69) 204.51,48.32 205.15,48.32 206.73,46.74 207.96,46.74 208.96,47.75 210.7,47.75 211.19,48.24 215.33,48.24 217.56,50.47 221.11,50.47 231,40.59 231,40.05 237.87,33.18 238.88,33.18 240.37,31.68 243.93,31.68 244.75,30.87 249.3,30.87 249.89,30.28 269.65,30.28 271.93,28 273.16,28 273.28,27.88 287.47,27.88 287.68,27.66 300.27,27.66 304.69,32.08 304.69,33.14 301.44,36.39 301.44,52.32 304.95,55.84 305.28,55.84 310.84,61.4 312.48,61.4 313.87,62.8 318.8,62.8 324.71,68.71 324.71,76.42 322.94,78.19 322.73,78.19 322.38,77.84 v2(322.38,77.78)
  BOTTOM w0.089: UH1.AC2 203.6,42.89 203.68,42.96 203.68,43.16 203.58,43.26 203.58,44.08 203.43,44.23 203.43,45.85 203.73,46.15 203.73,47.68 203.58,47.83 203.58,48.17 203.8,48.39 203.83,48.39 v2(204.14,48.69)
CLK_PCIE_N5: length 270.5
  TOP w0.097: UR1.6 15.2,67.34 15.08,67.46 12.68,67.46 12.37,67.76 11.88,67.76 11.06,68.57 11.06,69.27 12.72,70.93 12.72,71.53 12.64,71.6 12.37,71.6 v2(12.15,71.39)
  IN3 w0.102: v2(202.97,40.47) 202.68,40.55 202.55,40.48 202.31,40.24 201.81,40.24 201.09,39.52 201.09,36.79 200.57,36.27 200.18,36.27 199.05,35.14 197.16,35.14 195.95,36.35 193.82,36.35 193.4,35.93 188.56,35.93 182.39,42.09 181.51,42.09 179.16,44.44 177.06,44.44 174.34,47.16 174.34,57.89 143.74,88.49 138.16,88.49 131.31,95.35 128.41,95.35 124.04,99.72 120.8,99.72 118.62,101.9 118.62,102.71 116.97,104.36 116.97,105.42 114,108.39 102.93,108.39 100,111.32 94.73,111.32 93.11,109.7 77.61,109.7 72.03,104.12 65.12,104.12 61.88,100.87 52.35,100.87 51.98,100.5 49.32,100.5 48.62,101.2 42.89,101.2 40.12,98.43 40.12,87.27 30.93,78.09 18.55,78.09 14.2,73.74 14.2,72.62 13.18,71.59 12.36,71.59 v2(12.15,71.39)
  BOTTOM w0.089: v2(202.97,40.47) 202.97,40.67 203.21,40.91 203.21,41.57 203.15,41.63 203.15,42.56 202.89,42.83 UH1.AB2
CLK_PCIE_P0: length 182.8
  IN1 w0.099: v2(338.69,55.61) 338.51,55.8 337.6,55.8 337.07,56.33 335.63,56.33 335.21,56.75 332.13,56.75 331.72,57.15 329.62,57.15 328.32,55.85 322.19,55.85 319.92,53.57 314.95,53.57 312.57,55.95 309.61,55.95 306.51,52.86 303.96,52.86 302.54,51.44 302.54,45.78 302.92,45.4 302.92,36.9 305.6,34.22 305.6,31.69 300.67,26.76 287.31,26.76 287.09,26.98 272.9,26.98 272.78,27.1 271.56,27.1 269.27,29.38 244.96,29.38 243.56,30.78 240,30.78 238.5,32.28 237.44,32.28 230.09,39.62 230.09,40.21 221.04,49.27 218.43,49.27 217.02,47.86 217.02,47.09 216.6,46.67 210.15,46.67 208.3,44.81 208.3,42.19 207.21,41.1 206.4,41.1 v2(206.22,40.86)
  BOTTOM w0.094: UH1.AJ7 206.22,40.7 v2(206.22,40.86)
  BOTTOM w0.097: v2(338.69,55.61) 338.56,55.74 338.2,55.74 337.84,55.38 337.84,54.18 337.91,54.1 338.07,54.1 338.15,54.03 JNGFF2.55
CLK_PCIE_P1: length 106.5
  IN3 w0.089: v2(206.54,39.17) 206.59,39.22 206.88,39.22 207.3,38.79 208.5,38.79 209.03,39.33 209.36,39.33 209.53,39.16 211.31,39.16 212.22,40.07 217.52,40.07 218.31,40.86 220.65,40.86 221.68,40.86 221.7,40.83 221.72,40.83
  IN3 w0.102: 221.72,40.83 222.3,40.83 226.54,36.59 226.81,36.59 230.35,33.04 230.35,32.69 235.13,27.91 236.94,27.91 239.74,25.12 256.64,25.12 257,24.75 262.37,24.75 262.62,25 270.87,25 272.06,26.19 279.53,26.19 280.98,27.64 291.13,27.64 293.12,29.64 297.14,29.64 297.24,29.54 297.24,29.35 v2(297.12,29.23)
  BOTTOM w0.094: v2(206.54,39.17) 206.34,38.96 UH1.AH10
  BOTTOM w0.097: v2(297.12,29.23) 297.32,29.04 297.32,27.41 296.86,26.95 295.77,26.95 295.61,27.11 JNGFF1.47
CLK_PCIE_P3: length 163.6
  IN3 w0.089: 221.72,34.91 221.7,34.91 221.68,34.93 221.28,34.93 220.16,36.05 220.07,36.05 218.48,37.64 215.26,37.64 214.59,38.31 212.68,38.31 212.46,38.09 212.13,38.09 211.79,37.76 211.32,37.76 211.11,37.54 206.56,37.54 205.71,38.39 205.71,40.51 205.54,40.69 205.29,40.69 205.21,40.6 v2(205.21,40.4)
  IN3 w0.102: v2(341.32,18.5) 341.49,18.67 341.49,19.06 341.08,19.47 340.55,19.47 339.25,20.76 333.04,20.76 332.8,20.52 317.07,20.52 315.26,22.33 309.91,22.33 309.71,22.53 306.6,22.53 306.43,22.69 304.02,22.69 298.91,27.8 293.49,27.8 292.61,26.92 281.25,26.92 279.79,25.46 272.32,25.46 271.16,24.3 263.27,24.3 263.02,24.05 256.71,24.05 256.35,24.41 239.45,24.41 236.65,27.21 234.84,27.21 229.65,32.4 229.65,32.59 227.97,34.27 224.55,34.27 223.91,34.91 221.72,34.91
  BOTTOM w0.094: v2(205.21,40.4) UH1.AE7
  BOTTOM w0.097: v2(341.32,18.5) 341.52,18.3 341.52,16.95 342.94,15.53 342.94,15.48 343.35,15.06 343.41,15.06 v4(345.01,13.46) 347.24,11.23 347.24,10.49 347.05,10.3 JNGFF3.55
CLK_PCIE_P4: length 190
  TOP w0.097: v2(322.35,78.4) 322.37,78.37 322.71,78.37 322.77,78.43 322.77,81.42 322.07,82.12 322.07,82.65 321.85,82.87 UL1.44
  IN1 w0.099: v2(204.14,48.11) 205.06,48.11 206.64,46.53 208.05,46.53 209.05,47.54 210.78,47.54 211.28,48.03 215.42,48.03 217.65,50.26 221.02,50.26 230.79,40.5 230.79,39.96 237.78,32.97 238.79,32.97 240.28,31.47 243.85,31.47 244.66,30.66 249.22,30.66 249.8,30.07 269.56,30.07 271.84,27.79 273.07,27.79 273.19,27.67 287.38,27.67 287.59,27.45 300.36,27.45 304.9,32 304.9,33.23 301.65,36.48 301.65,52.23 305.04,55.63 305.36,55.63 310.93,61.19 312.57,61.19 313.96,62.59 318.89,62.59 324.92,68.62 324.92,76.5 323.03,78.4 v2(322.35,78.4)
  BOTTOM w0.089: v2(204.14,48.11) 204.04,48.21 203.87,48.21 203.75,48.09 203.75,47.9 203.91,47.75 203.91,46.08 203.61,45.78 203.61,44.3 203.76,44.15 203.76,43.33 203.86,43.23 203.86,42.65 203.55,42.34 UH1.AC3
CLK_PCIE_P5: length 270.1
  TOP w0.097: v2(12.18,71.99) 12.38,71.79 12.72,71.79 12.91,71.6 12.91,70.85 11.25,69.2 11.25,68.65 11.95,67.94 12.45,67.94 12.75,67.64 15.09,67.64 15.19,67.74 UR1.5
  IN3 w0.102: v2(12.18,71.99) 12.36,71.81 13.08,71.81 13.98,72.71 13.98,73.83 18.46,78.31 30.84,78.31 39.9,87.36 39.9,98.52 42.8,101.42 48.71,101.42 49.41,100.72 51.89,100.72 52.26,101.09 61.79,101.09 65.03,104.34 71.94,104.34 77.52,109.92 93.02,109.92 94.64,111.54 100.09,111.54 103.02,108.61 114.09,108.61 117.19,105.51 117.19,104.45 118.84,102.8 118.84,101.99 120.89,99.94 124.13,99.94 128.5,95.57 131.4,95.57 138.25,88.71 143.83,88.71 174.56,57.98 174.56,47.25 177.15,44.66 179.25,44.66 181.6,42.31 182.48,42.31 188.65,36.15 193.35,36.15 193.74,36.54 196.03,36.54 197.24,35.33 198.97,35.33 200.1,36.46 200.49,36.46 200.9,36.87 200.9,39.52 200.87,39.55 200.87,39.62 201.72,40.46 202.22,40.46 202.42,40.66 202.57,40.74 202.63,40.95 v2(202.54,41.11)
  BOTTOM w0.089: UH1.AB3 202.98,42.38 202.98,41.56 203.03,41.5 203.03,40.98 202.87,40.82 202.69,40.82 202.54,40.98 v2(202.54,41.11)
CLK_TP_SIO_I2C_DAT: length 224.9
  TOP w0.107: UE1.E10 v2(321.32,37.55)
  IN1 w0.099: v2(321.32,37.55) 321.7,37.93 323.38,37.93 323.99,37.32 323.99,34.92 323.68,34.61 323.68,27.71 323.27,27.3 323.27,26.05 323.84,25.48 323.84,23.75 322.3,22.22 321.85,22.22 319.99,20.36 319.99,19.56 v2(320.37,19.17)
  BOTTOM w0.107: v2(320.37,19.17) 320.17,18.97 320.17,14.66 v1(317.74,12.23) 316.14,10.63 316.14,8.29 315.04,7.19 314.89,7.19 313.33,5.64 312.98,5.64 312.82,5.64 309.35,2.18 293.03,2.18 291.57,3.63 288.43,3.63 286.09,1.29 278.56,1.29 275.49,4.37 275.49,5.5 273.63,7.36 271.54,7.36 268.77,4.58 267.68,4.58 264.34,1.25 192.32,1.25 191.2,2.36 191.2,6.11 188.62,8.69 188.62,12.73 187.77,13.59 183.92,13.59 183.35,14.15 178.1,14.15 177.69,13.74 177.69,12.46 176.94,11.71 174.91,11.71 174.33,12.29 171.74,12.29 171.12,11.67 160.79,11.67 156.64,7.52 156.26,7.52 155.04,6.3 CZ81.1 153.62,6.3 RZ346.2 RZ23.2
CLK_TP_SIO_R: length 14.7
  BOTTOM w0.107: RZ23.1 152.45,7.39 152.22,7.62 151.2,7.62 RZ19.2 150.52,7.49 149.55,7.49 CZ89.1 149.07,7.41 v1(148,7.41) 147.35,7.41 146.24,8.51 146.24,9.91 145.42,10.74 141.44,10.74 141.02,10.32 JKBTP1.7
CLKDET#: length 3.6
  BOTTOM w0.089: UH1.BF35 214.89,27.06 215.74,27.06 215.95,27.27 215.95,27.71 216.14,27.9 217.39,27.9 T258.1
CLKREQ_CNV: length 121.6
  TOP w0.102: v2(226.87,32.77) 227.38,32.77 v1(227.49,32.88)
  IN1 w0.099: v2(293.63,45.25) 292.67,45.25 287.87,40.45 287.87,32.91 288.79,31.98 297.1,31.98 297.28,32.16 v2(297.28,32.55)
  IN2 w0.102: v2(212.12,36.16) 212.28,36.16 212.64,35.8 214.92,35.8 215.41,35.31 217.39,35.31 217.98,34.72 220.33,34.72 221.32,33.73 222.95,33.73 224.47,32.2 226.3,32.2 v2(226.87,32.77) 230.07,35.97 234.01,35.97 234.95,35.03 236.51,35.03 237.19,35.71 241.22,35.71 243.41,33.51 251.15,33.51 251.57,33.09 267.44,33.09 269.5,31.03 282.09,31.03 282.9,31.85 296.58,31.85 v2(297.28,32.55)
  BOTTOM w0.089: UH1.BA17 212.21,36 212.12,36.1 v2(212.12,36.16)
  BOTTOM w0.102: QZ18.2 292.48,44.14 RZ4.1 292.48,44.93 292.79,45.25 v2(293.63,45.25) ; RH618.2 226.86,32.78 v2(226.87,32.77)
CLKREQ_CNV_R: length 20.1
  BOTTOM w0.102: JNGFF1.14 301.07,35.36 300.78,35.65 300.78,37.36 298.94,39.2 v1(298.94,41.67) 298.94,42.05 298.57,42.42 297.82,42.42 296.55,41.15 294.33,41.15 293.47,42.01 293.47,43.76 RZ376.2 293.72,44.39 293.19,44.92 293.09,44.92 RZ4.2 292.95,44.78 QZ18.3
CLKREQ_PCIE#0: length 138.2
  TOP w0.107: RH10.2 226.89,26.72 v2(229.13,26.72)
  IN2 w0.102: v2(229.13,26.72) 229.29,26.72 231.19,28.63 235.9,28.63 238.03,30.76 238.03,33.3 v2(238.48,33.74)
  IN3 w0.102: v2(238.48,33.74) 238.48,34.14 238.86,34.53 244.51,34.53 244.85,34.19 246.68,34.19 247.36,33.51 250.97,33.51 251.3,33.19 253.13,33.19 254.07,32.24 255.86,32.24 256.21,32.59 262.69,32.59 263.29,33.19 270.34,33.19 271.35,34.21 276.62,34.21 277.3,34.89 280,34.89 282.15,37.04 283.27,37.04 283.65,37.42 292.44,37.42 296.87,41.85 296.87,45.43 301.31,49.87 306.53,49.87 311.7,55.04 316.96,55.04 317.58,55.66 317.58,58.19 318.47,59.08 318.47,61.85 320.46,63.84 322.09,63.84 323,64.76 323.15,64.76 323.16,64.77 330.91,64.77 332.54,63.13 336.96,63.13 v2(337.03,63.07)
  BOTTOM w0.107: v2(337.03,63.07) 337.4,62.7 JNGFF2.52
CLKREQ_PCIE#0_R: length 13.5
  TOP w0.107: RH123.1 224.53,27.38 224.79,27.12 v2(224.79,26.91) 225.01,26.7 225.01,26.68 225.17,26.53 RH10.1
  BOTTOM w0.089: UH1.BF31 214.81,29.06 214.86,29.11 217.42,29.11 219.25,29.11 219.49,29.34 220.46,29.34 221.88,27.93 223.61,27.93
  BOTTOM w0.107: v2(224.79,26.91) 224.79,27.67 224.54,27.93 223.61,27.93
CLKREQ_PCIE#1: length 88.8
  TOP w0.089: 223.85,24.7 RH11.2
  TOP w0.107: 223.85,24.7 224.94,23.6 v2(224.94,23.25)
  IN3 w0.102: v2(296.27,25.6) 294.88,25.6 294.08,24.81 292.93,24.81 291.16,23.04 275.36,23.04 274.53,22.21 v2(274.08,22.21)
  BOTTOM w0.107: JNGFF1.53 296.27,25.61 v2(296.27,25.6) ; v2(224.94,23.25) 224.94,22.99 224.73,22.78 224.73,21.48 225.21,21.01 225.95,21.01 226.4,21.45 229.03,21.45 231.86,24.28 231.86,27.77 234.83,30.74 243.48,30.74 244.85,29.37 265.45,29.37 266.96,27.86 269.52,27.86 274.14,23.24 274.14,22.27 v2(274.08,22.21)
CLKREQ_PCIE#1_R: length 13.6
  TOP w0.107: RH124.1 223.41,25.2 RH11.1 224.21,26 v2(224.21,26.92)
  BOTTOM w0.089: UH1.BE31 214.42,28.9 214.49,28.82 214.84,28.82 214.9,28.88 219.48,28.88 v1(219.53,28.93) 219.58,28.98 220.57,28.98 222.02,27.53 223.03,27.53
  BOTTOM w0.102: 223.03,27.53 223.5,27.53
  BOTTOM w0.107: v2(224.21,26.92) 224.21,27.25 224.02,27.43 223.6,27.43 223.5,27.53
CLKREQ_PCIE#3: length 143
  TOP w0.107: RH13.2 226.77,27.42 227.35,28 227.35,28.56 v2(227.48,28.69)
  IN3 w0.102: v2(227.48,28.69) 227.48,28.51 227.3,28.33 227.3,27.43 229.75,24.98 230.63,24.98 231.51,24.1 232.49,24.1 233.24,23.35 233.88,23.35 237.26,19.96 241.27,19.96 241.78,19.46 246.56,19.46 246.73,19.29 251.27,19.29 251.65,19.67 252.63,19.67 252.77,19.81 254.44,19.81 254.64,19.61 269.62,19.61 269.83,19.39 270.78,19.39 271.48,18.69 277.84,18.69 278.3,19.15 286.82,19.15 287.36,18.61 292,18.61 293.04,19.65 294.84,19.65 295.77,20.59 300.83,20.59 302.32,19.1 314.58,19.1 314.86,18.82 317.3,18.82 318.76,17.37 323.97,17.37 324.89,18.29 339.73,18.29 339.91,18.47 v2(340.69,18.47)
  BOTTOM w0.107: v2(340.69,18.47) 340.69,16.73 345.36,12.06 345.36,8.94 347.33,6.97 347.33,3.82 347.8,3.34 JNGFF3.52
CLKREQ_PCIE#3_R: length 17.9
  TOP w0.107: RH126.1 224.58,28.02 225.18,27.42 RH13.1 225.79,27.72 225.67,27.85 v2(225.67,28.85)
  IN1 w0.099: v2(212.87,28.72) 212.92,28.67 213.07,28.67 213.23,28.83 217.74,28.83 219.42,27.14 221.26,27.14 221.44,27.32 222.7,27.32 223.31,27.93 224.87,27.93 225.67,28.73 v2(225.67,28.85)
  BOTTOM w0.089: UH1.BB30 212.98,28.83 v2(212.87,28.72)
CLKREQ_PCIE#4: length 166.1
  TOP w0.107: RH14.2 226.89,29.02 226.89,28.82 226.89,28.81 v2(226.89,28.71) ; RL4.1 324.9,81.89 v2(324.62,82.17) 324.11,82.17 323.45,82.83 UL1.48
  IN2 w0.102: v2(239.04,33.57) 239.04,34.05 238.91,34.18 238.17,34.18 237.55,33.55 237.55,30.96 235.7,29.11 227.28,29.11 v2(226.89,28.71)
  IN3 w0.102: v2(324.62,82.17) 327.01,79.78 327.77,79.78 332.15,75.4 332.15,68.83 334.59,66.4 336.85,66.4 337.62,65.63 337.62,62.96 337.31,62.65 332.34,62.65 330.71,64.29 326.02,64.29 326.01,64.28 323.2,64.28 322.29,63.36 320.78,63.36 318.95,61.54 318.95,58.88 318.09,58.02 318.09,55.49 317.16,54.56 311.9,54.56 306.06,48.72 300.84,48.72 297.35,45.23 297.35,41.65 292.61,36.91 283.82,36.91 283.47,36.56 282.35,36.56 280.2,34.4 277.5,34.4 276.82,33.72 271.55,33.72 270.49,32.66 267.43,32.66 266.41,31.64 254,31.64 253.05,32.59 251.21,32.59 250.77,33.03 247.16,33.03 246.48,33.71 244.65,33.71 244.31,34.04 239.51,34.04 v2(239.04,33.57)
CLKREQ_PCIE#4_R: length 17
  TOP w0.107: RH127.1 224.73,28.85 v2(225,28.85) 225.09,28.85 225.59,29.35 RH14.1
  IN1 w0.099: v2(225,28.85) 224.99,28.86 223.32,28.86 222.98,28.52 222.98,28.37 222.13,27.51 221.36,27.51 221.18,27.33 219.5,27.33 217.72,29.12 212.51,29.12 v2(212.24,28.84)
  BOTTOM w0.089: UH1.BA30 v2(212.24,28.84)
CLKREQ_PCIE#5: length 327.7
  TOP w0.107: v2(224.18,52.18) 224.1,52.11 224.1,50.9 v1(225.26,49.74) 227.65,47.35 227.65,39.49 228.23,38.91 228.84,38.91 229.61,38.14 229.61,36.09 229.14,35.62 227.14,35.62 RH15.2 ; v2(13.95,70.42) 13.95,70.36 15.38,68.94 UR1.2
  IN3 w0.102: v2(224.18,52.18) 224.18,52.77 222.5,54.45 218.41,54.45 217.55,55.3 198.13,55.3 197.57,55.86 196.26,55.86 141.38,110.74 141.38,112.35 136.28,117.45 130.37,117.45 126.28,121.54 120.21,121.54 120.12,121.63 103.17,121.63 102.28,122.52 85.05,122.52 84.23,123.34 66.28,123.34 64.51,121.58 64.51,116.5 57.27,109.26 40.34,109.26 30.5,119.1 24.02,119.1 21.92,116.99 20.49,116.99 19.86,116.36 19.86,114.39 20.11,114.13 20.11,108.67 19.99,108.55 19.99,107.36 19.67,107.05 19.67,104.23 19.91,103.99 19.91,100.53 20.49,99.95 20.49,85.17 21.43,84.23 21.43,82.28 19.15,80 17.72,80 11.18,73.46 11.18,71.06 11.82,70.42 v2(13.95,70.42)
CLKREQ_PCIE#5_R: length 21.5
  TOP w0.107: RH15.1 226.54,34.51 RH131.1 225.37,34.84 v2(225.31,34.9)
  IN1 w0.099: v2(225.31,34.9) 223.77,33.36 221.31,33.36 217.73,29.79 209.55,29.79 209,29.23 v2(208.55,29.23)
  BOTTOM w0.089: UH1.AN29 208.55,29.59 v2(208.55,29.23)
CLKREQ_PCIE#6_R: length 7.3
  BOTTOM w0.089: UH1.AE47 204.77,20.91 204.85,20.83 204.85,20.53 204.76,20.45 204.76,19.58 206.03,18.31 206.03,16.02 v1(205.72,15.71) 205.46,15.44 RH132.1
CLKREQ_PCIE#7_R: length 8.4
  BOTTOM w0.089: UH1.AC48 203.55,18.57 203.65,18.47 205.39,18.47 205.8,18.06 205.8,17.19 v1(205.63,17.02) 205.63,16.17 204.57,15.1 RH133.1
CLKRUN#: length 1.5
  TOP w0.102: T287.1 210.1,29.6 v2(210.52,29.18)
  BOTTOM w0.089: v2(210.52,29.18) 210.52,28.76 UH1.AV32
CMOUT: length 138.6
  TOP w0.254: v2(5.09,44.43) 4.49,43.83 v1(4.49,43.23) PR951.1
  IN1 w0.254: v2(70.53,104.75) 70.53,104.39 70.41,104.26 65.07,104.26 62.58,101.78 60.52,101.78 59.74,102.56 54.48,102.56 52.57,100.65 52.57,100.56 51.42,99.42 40.53,99.42 34.76,93.65 29.3,93.65 26.68,96.27 20.03,96.27 19.05,95.29 19.05,86.27 17.05,84.28 17.05,79.53 15.76,78.23 5.66,78.23 1.85,74.42 1.85,57.1 5.1,53.85 5.1,44.44 v2(5.09,44.43)
  BOTTOM w0.254: PQ1210.2 78.28,111.78 78.02,112.04 77.77,112.04 77.63,111.9 PQ1210.3 76.82,111.34 75.98,110.5 PQ1216.2 75.84,109.94 70.65,104.75 v2(70.53,104.75)
CNV_BRI_PRX_DTX: length 121.7
  TOP w0.102: v2(217.6,47.49) 217.67,47.55 v1(217.67,48.55) 217.67,49.31 RH614.2
  IN3 w0.102: v2(306.75,33.36) 307.23,32.88 307.23,30.95 306.19,29.91 306.19,27.72 305.77,27.29 304.28,27.29 302.51,29.06 302.51,29.99 298.31,34.19 285.26,34.19 283.43,32.36 281.89,32.36 280.68,31.15 273.13,31.15 271.35,29.38 268.64,29.38 268.39,29.13 251.77,29.13 251.32,29.59 244.8,29.59 243.74,30.65 239.85,30.65 239.4,31.1 237.79,31.1 236.02,32.87 236.02,32.95 228.32,40.65 226.99,40.65 223.04,44.6 219.84,44.6 217.6,46.84 v2(217.6,47.49)
  BOTTOM w0.089: v2(217.6,47.49) 217.6,46.9 217.4,46.69 214.6,46.69 214.05,46.14 213.09,46.14 211.98,45.03 211.98,44.93 211.96,44.91 211.96,43.27 211.86,43.17 UH1.AY2
  BOTTOM w0.102: RZ1381.1 306.62,33.49 v2(306.75,33.36)
CNV_BRI_PRX_DTX_R: length 3.8
  BOTTOM w0.102: v1(304.96,34.56) RZ1381.2 304.83,33.36 JNGFF1.22
CNV_BRI_PTX_DRX: length 11.9
  TOP w0.089: v2(215.24,47.53) RZ1384.1 214.36,48.22 RH603.1 214.35,49.23 v1(214.4,49.28) 214.41,49.29 RH604.1
  BOTTOM w0.089: v2(215.24,47.53) 214.68,46.98 213.66,46.98 211.01,44.33 211.01,43.09 210.98,43.06 210.98,42.72 211.06,42.64 211.06,42.2 UH1.AV4
CNV_BRI_PTX_DRX_R: length 111.6
  TOP w0.089: v2(215.82,47.52) 216.15,47.85 RZ1384.2
  IN3 w0.102: v2(215.82,47.52) 215.82,47.52 216.26,47.08 217.04,47.08 220,44.12 223.2,44.12 226.9,40.42 228.22,40.42 235.72,32.92 235.72,32.85 237.69,30.88 239.3,30.88 239.98,30.2 241.64,30.2 242.47,29.36 250.9,29.36 252.15,28.12 260.67,28.12 260.93,28.38 267.96,28.38 268.73,29.15 271.45,29.15 273.15,30.85 282.25,30.85 285.35,33.96 298.22,33.96 302.28,29.89 302.28,28.96 304.18,27.06 305.86,27.06 306.62,27.83 v2(306.62,28.79)
  BOTTOM w0.102: JNGFF1.36 303.46,29.86 304.53,28.79 v1(305.99,28.79) v2(306.62,28.79)
CNV_COEX1: length 183.3
  TOP w0.102: RH607.1 213.11,46.48 v1(213.11,45.29) 212.72,44.89 RH608.1 211.74,42.84 211.74,42.42 211.41,42.08 211.41,41.28 211.13,41 211.13,39.78 v2(211.04,39.7) ; v2(341.49,55.93) 341.95,56.4 RZ373.2
  IN3 w0.089: 212.24,43.14 211.04,41.95 v2(211.04,39.7) ; 214.22,43.14 214.4,42.96 218.22,42.96 218.99,42.19 219.58,42.19
  IN3 w0.102: 212.24,43.14 212.25,43.15 214.21,43.15 214.22,43.14 ; v2(341.49,55.93) 341.02,55.46 341.02,54.32 338.88,52.19 338.88,50.47 333.77,45.36 333.77,28.41 330.15,24.79 326.68,24.79 324.63,22.73 320.23,22.73 320.09,22.87 317.98,22.87 316.38,24.48 311.59,24.48 310.13,25.93 304.34,25.93 301.58,28.69 301.58,29.62 297.93,33.27 285.64,33.27 282.53,30.16 280.28,30.16 278.58,28.46 269.02,28.46 268.25,27.69 261.22,27.69 260.96,27.43 251.86,27.43 251.39,27.9 242.96,27.9 242.05,28.82 239.26,28.82 237.88,30.19 236.47,30.19 235.04,31.63 235.04,32.64 228.74,38.93 227.42,38.93 223.98,42.37 219.77,42.37 219.58,42.19
  BOTTOM w0.089: UH1.AU9 v2(211.04,39.7)
CNV_COEX2: length 172.2
  TOP w0.102: RZ372.2 340.8,56.91 v2(340.45,56.56)
  IN3 w0.102: v2(211.4,43.59) 211.61,43.38 215.48,43.38 215.68,43.18 223.49,43.18 227.51,39.16 228.84,39.16 235.26,32.73 235.26,31.72 236.57,30.42 237.98,30.42 239.35,29.04 242.14,29.04 243.03,28.16 251.46,28.16 251.96,27.66 260.86,27.66 261.12,27.92 268.15,27.92 268.92,28.69 271.64,28.69 273.34,30.39 282.44,30.39 285.54,33.5 298.03,33.5 301.81,29.72 301.81,28.79 304.44,26.16 310.23,26.16 311.68,24.7 316.48,24.7 318.08,23.1 320.19,23.1 320.33,22.96 324.53,22.96 326.59,25.02 330.06,25.02 332.1,27.06 332.1,37.47 333.54,38.91 333.54,45.45 338.65,50.56 338.65,52.28 340.79,54.42 340.79,56.25 340.47,56.56 v2(340.45,56.56)
  BOTTOM w0.089: v2(211.4,43.59) 211.39,43.59 211.2,43.4 UH1.AW2
CNV_COEX3: length 174.6
  TOP w0.102: RZ374.2 339.1,56.49 340.24,55.35 v2(341.47,55.35)
  IN3 w0.089: v2(211.84,41.34) 211.84,41.41 212.29,41.86 213.79,41.86 214.66,42.73 218.19,42.73 218.94,41.99 219.64,41.99 219.8,42.15 221.72,42.15
  IN3 w0.102: 221.72,42.15 223.88,42.15 227.37,38.66 228.69,38.66 234.81,32.54 234.81,31.53 236.38,29.96 237.79,29.96 239.16,28.59 241.95,28.59 242.87,27.67 251.3,27.67 251.77,27.2 261.13,27.2 261.34,27.41 268.28,27.41 269.11,28.23 278.68,28.23 280.38,29.93 282.63,29.93 285.73,33.04 297.84,33.04 301.35,29.53 301.35,28.6 304.25,25.7 310.04,25.7 311.49,24.25 316.29,24.25 317.89,22.65 320,22.65 320.14,22.5 324.72,22.5 326.78,24.56 330.25,24.56 334,28.31 334,45.26 339.11,50.38 339.11,52.09 341.25,54.23 341.25,55.12 v2(341.47,55.35)
  BOTTOM w0.089: v2(211.84,41.34) 211.43,41.34 UH1.AV6
CNV_DET#: length 130.4
  TOP w0.102: v1(291.78,7) 291.55,6.77 RZ7.1 290.71,6.01 RZ380.2 290.7,5.45 v2(290.9,5.24)
  IN1 w0.099: v2(339.92,15.34) 338.97,15.34 336.95,13.32 336.95,7.13 v2(336.48,6.66) ; v2(318.73,18.33) 318.13,18.92 318.13,22.39 318.87,23.13 319.83,23.13 320.4,23.7 320.4,25.22 320.82,25.64 320.82,29.17 v2(321.09,29.44)
  IN2 w0.102: v2(318.73,18.33) 318.73,18.12 320.68,16.17 335.35,16.17 336.14,15.38 339.89,15.38 v2(339.92,15.34) ; v2(321.09,29.44) 320.54,28.89 319.21,28.89 318.36,29.74 313.99,29.74 313.08,30.66 311.98,30.66 307.27,35.37 301.95,35.37 301.23,34.65 297.25,34.65 296.01,35.89 v2(296.01,36.49)
  IN3 w0.102: v2(290.9,5.24) 291.09,5.24 291.27,5.42 291.74,5.42 292.31,4.85 292.31,4.63 292.49,4.46 293.96,4.46 294.7,3.72 295.31,3.72 296.95,2.08 329.07,2.08 331.5,4.52 334.35,4.52 v2(336.48,6.66)
  BOTTOM w0.102: v2(321.09,29.44) 320.72,29.81 RE562.1 ; v2(296.01,36.49) 295.98,36.46 295.98,35.74 295.85,35.61 JNGFF1.13
CNV_DET#_EC: length 3.3
  TOP w0.089: UE1.L11 v2(321.32,31.95)
  BOTTOM w0.102: RE562.2 RE101.2 RE100.2 321.86,31.37 321.32,31.92 v2(321.32,31.95)
CNV_DET#_R: length 101.4
  IN2 w0.102: v2(236.38,35.84) 236.7,36.17 241.4,36.17 243.6,33.97 251.34,33.97 251.74,33.57 267.77,33.57 269.66,31.69 276.63,31.69 279.93,34.98 279.93,37.02 280.43,37.52 296.79,37.52 297.46,36.85 297.46,36.09 298.67,34.87 301.13,34.87 301.86,35.6 307.37,35.6 312.1,30.86 313.16,30.86 314.08,29.95 318.45,29.95 319.3,29.1 319.88,29.1 320.66,29.87 321.29,29.87 321.48,29.68 321.48,29.24 v2(321.87,28.86)
  BOTTOM w0.102: v2(321.87,28.86) 321.55,29.18 321.55,29.7 RE101.1 ; RH623.2 RH624.2 v1(235.54,35) v2(236.38,35.84)
CNV_EN#: length 26.3
  IN2 w0.102: v2(231.89,34.85) 231.81,34.85 228.49,31.53 227.45,31.53 227.01,31.97 224.35,31.97 222.82,33.5 220.64,33.5 220.52,33.62 219.68,33.62 218.92,34.38 218.06,34.38 217.74,34.06 212.23,34.06 211.77,34.52 v2(211.5,34.52)
  BOTTOM w0.089: UH1.AW21 v2(211.5,34.52)
  BOTTOM w0.102: v2(231.89,34.85) 232,34.85 v1(232.3,34.55) 232.74,34.11 RH623.1 RH622.2
CNV_PRX_DTX_N0: length 105.9
  IN1 w0.099: v2(214.41,44.65) 214.22,44.46 214.22,44.22 213.98,43.98 213.4,43.98 213.08,44.3 213.08,44.96 214.18,46.06 222.21,46.06 222.75,45.52 222.75,45.02 224.87,42.9 225.4,42.9 226.23,42.06 226.23,40.93 228.11,39.05 228.65,39.05 233.18,34.52 233.18,33.91 236.42,30.68 237.71,30.68 239.27,29.11 242.22,29.11 242.64,28.7 243.63,28.7 244.82,27.5 249.22,27.5 249.61,27.9 251.83,27.9 252.22,27.5 255.11,27.5 255.56,27.95 268.68,27.95 270.97,25.67 272.19,25.67 272.31,25.55 281.4,25.55 281.85,25.1 283,25.1 283.4,24.69 287.7,24.69 288.21,25.2 v2(288.21,25.56)
  BOTTOM w0.089: UH1.BB3 213.28,43.21 213.28,43.45 213.25,43.48 213.25,43.72 213.42,43.88 213.55,43.88 213.84,44.18 213.84,44.32 214.18,44.65 214.41,44.65 v2(214.41,44.65)
  BOTTOM w0.097: JNGFF1.15 293.79,35.11 293.64,34.95 292.62,34.95 292.58,34.99 292,34.99 291.96,34.95 291.58,34.95 288.87,32.24 288.87,27.03 288.21,26.37 v2(288.21,25.56)
CNV_PRX_DTX_N1: length 105.7
  IN1 w0.099: v2(220.77,46.67) 220.77,46.68 221.13,47.04 222.11,47.04 227.75,41.4 227.75,41.26 227.41,40.92 227.41,40.61 227.75,40.27 228.06,40.27 228.4,40.61 228.54,40.61 229.28,39.87 229.28,39.28 234.44,34.13 234.44,33.99 234.36,33.91 234.36,33.6 234.69,33.26 235.01,33.26 235.08,33.34 235.22,33.34 235.43,33.13 235.43,32.99 235.36,32.91 235.36,32.6 235.69,32.26 236.01,32.26 236.08,32.34 236.22,32.34 237.1,31.46 238.17,31.46 239.66,29.97 242.4,29.97 243.06,29.3 243.88,29.3 245.07,28.11 248.97,28.11 249.36,28.5 252.08,28.5 252.47,28.11 253.45,28.11 253.9,28.56 268.94,28.56 271.22,26.28 272.45,26.28 272.57,26.16 286.56,26.16 286.73,25.98 286.73,25.84 286.46,25.56 v2(286.44,25.56)
  BOTTOM w0.089: UH1.BA3 212.67,42.69 212.93,42.95 212.93,43.26 212.87,43.32 212.87,43.91 212.72,44.05 212.72,44.51 213.15,44.94 213.27,44.94 213.65,45.31 214.46,45.31 214.9,45.75 217.74,45.75 218.45,46.47 218.78,46.47
  BOTTOM w0.097: JNGFF1.9 293.79,36.61 293.76,36.58 292.08,36.58 287.66,32.15 287.66,28 286.64,26.98 286.64,25.76 v2(286.44,25.56) ; v2(220.77,46.67) 219.88,46.67 219.68,46.47 218.78,46.47
CNV_PRX_DTX_P0: length 105.6
  IN1 w0.099: v2(288.79,25.56) 288.78,25.56 288.42,25.2 288.42,25.11 287.79,24.48 283.32,24.48 282.91,24.89 281.76,24.89 281.32,25.34 272.23,25.34 272.11,25.46 270.88,25.46 268.6,27.74 255.65,27.74 255.2,27.29 252.13,27.29 251.74,27.69 249.7,27.69 249.31,27.29 244.74,27.29 243.54,28.49 242.55,28.49 242.14,28.9 239.19,28.9 237.62,30.47 236.33,30.47 232.97,33.83 232.97,34.43 228.57,38.84 228.02,38.84 226.02,40.85 226.02,41.98 225.31,42.68 224.78,42.68 222.54,44.93 222.54,45.43 222.12,45.85 214.27,45.85 213.29,44.87 213.29,44.39 213.49,44.19 213.89,44.19 214.01,44.31 214.01,44.64 213.91,44.73 213.74,44.73 v2(213.67,44.65)
  BOTTOM w0.089: UH1.BB4 213.21,42.9 213.11,43 213.11,43.36 213.06,43.4 213.06,43.8 213.33,44.06 213.48,44.06 213.67,44.25 v2(213.67,44.65)
  BOTTOM w0.097: v2(288.79,25.56) 288.78,25.56 288.4,25.95 288.4,26.3 289.05,26.95 289.05,32.16 291.65,34.77 v4(292.29,34.77) 293.64,34.77 293.79,34.61 JNGFF1.17
CNV_PRX_DTX_P1: length 105.6
  IN1 w0.099: v2(287.03,25.56) 286.94,25.65 286.94,26.07 286.64,26.37 272.65,26.37 272.53,26.49 271.31,26.49 269.02,28.77 253.81,28.77 253.36,28.32 252.56,28.32 252.17,28.71 249.27,28.71 248.88,28.32 245.16,28.32 243.97,29.52 243.15,29.52 242.49,30.18 239.75,30.18 238.25,31.67 237.19,31.67 236.31,32.55 236,32.55 235.92,32.47 235.78,32.47 235.57,32.68 235.57,32.82 235.65,32.9 235.65,33.21 235.31,33.55 235,33.55 234.92,33.47 234.78,33.47 234.57,33.68 234.57,33.82 234.65,33.9 234.65,34.21 229.49,39.37 229.49,39.96 228.63,40.82 228.31,40.82 227.97,40.48 227.83,40.48 227.62,40.69 227.62,40.83 227.96,41.17 227.96,41.49 222.2,47.25 v2(220.77,47.25)
  BOTTOM w0.089: UH1.BA2 212.68,43.18 212.68,43.83 212.53,43.97 212.53,44.59 213.07,45.13 213.18,45.13 213.56,45.5 214.4,45.5 214.82,45.93 217.66,45.93 218.39,46.65 218.78,46.65
  BOTTOM w0.097: 218.78,46.65 219.6,46.65 219.8,46.85 220.43,46.85 220.77,47.18 v2(220.77,47.25) ; JNGFF1.11 293.84,36.11 293.8,36.15 293.8,36.32 293.73,36.39 292.16,36.39 287.84,32.07 287.84,27.92 286.83,26.91 286.83,25.76 v2(287.03,25.56)
