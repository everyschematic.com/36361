# Allegro board LA-F711P R05-0112.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_B_D60: length 87.7
  IN1 w0.076: v2(115.1,59.36) 115.56,58.9 115.83,58.9 116.46,58.27 116.6,58.27 116.92,58.27 116.92,58.27 117.57,58.27 117.62,58.32 118.18,58.32
  IN1 w0.097: v2(174.23,19.25) 174.23,19.37 173.57,20.04 173.57,20.27 173.84,20.55 173.84,20.69 173.7,20.83 173.56,20.83 172.87,20.14 172.74,20.14 172.58,20.3 172.58,20.43 172.85,20.7 172.85,20.84 172.55,21.14 172.55,24.19 172.65,24.29 173.11,24.29 173.2,24.38 173.2,24.58 173.11,24.67 172.65,24.67 172.55,24.77 172.55,24.98 172.65,25.08 173.11,25.08 173.2,25.17 173.2,25.37 173.11,25.46 172.66,25.46 172.55,25.57 172.55,26.13 147.63,51.06 141.04,51.06 134.64,57.45 121.18,57.45 120.32,58.32 118.18,58.32
  BOTTOM w0.076: UC1.L10 v2(115.1,59.36)
  BOTTOM w0.107: v2(174.23,19.25) 173.78,19.25 172.22,20.82 JDIMM2.245
DDR_B_D61: length 87.6
  IN1 w0.076: v2(114.21,59.36) 113.84,59 113.84,58.3 113.64,58.09 113.64,56.71 114.46,55.88 114.46,55.44 114.76,55.14 115.19,55.14 115.52,54.81 115.52,53.85 116.23,53.14
  IN1 w0.097: 116.23,53.14 117.35,52.01 123.16,52.01 123.66,51.51 124.64,51.51 127.49,48.66 146.54,48.66 167.82,27.38 167.82,25.44 169.34,23.92 169.34,18.19 169.44,18.09 170.02,18.09 170.11,18 170.11,17.8 170.02,17.71 169.44,17.71 169.34,17.61 169.34,17.39 169.44,17.3 170.43,17.3 170.52,17.2 v2(170.52,16.89)
  BOTTOM w0.076: UC1.M10 v2(114.21,59.36)
  BOTTOM w0.107: v2(170.52,16.89) 168.97,15.34 JDIMM2.232
DDR_B_D62: length 83.8
  IN1 w0.076: v2(114.15,56.74) 114.35,56.53 115.06,56.53 115.41,56.19 115.41,55.57 115.79,55.19 115.79,54.03 116.46,53.36
  IN1 w0.097: v2(170.54,18.46) 169.75,18.46 169.66,18.55 169.66,18.8 169.76,18.9 169.95,18.9 170.05,19 170.05,19.2 169.95,19.3 169.76,19.3 169.66,19.4 169.66,19.59 169.76,19.69 170,19.69 170.1,19.79 170.1,19.99 170,20.09 169.76,20.09 169.66,20.19 169.66,24.05 168.12,25.59 168.12,27.5 146.66,48.96 127.62,48.96 124.77,51.81 123.78,51.81 123.26,52.33 117.49,52.33 116.46,53.36
  BOTTOM w0.076: v2(114.15,56.74) 113.8,57.09 UC1.M7
  BOTTOM w0.107: v2(170.54,18.46) 169.22,19.77 JDIMM2.233
DDR_B_D63: length 86
  IN1 w0.076: 118.46,57.47 116.47,57.47 115.79,58.15 v2(115.08,58.15)
  IN1 w0.097: v2(174.15,17.73) 174.15,17.57 173.86,17.27 173.44,17.27 173.34,17.37 173.34,17.76 173.44,17.86 173.53,17.86 173.63,17.96 173.63,18.16 173.53,18.26 173.44,18.26 173.34,18.36 173.34,19.11 172.25,20.2 172.25,26.01 147.5,50.76 140.91,50.76 134.51,57.15 120.35,57.15 120.04,57.47 118.46,57.47
  BOTTOM w0.076: UC1.L8 115.05,58.15 v2(115.08,58.15)
  BOTTOM w0.107: v2(174.15,17.73) 174.15,17.73 172.47,16.04 JDIMM2.246
DDR_B_DQS0: length 45.5
  IN3 w0.089: v2(106.42,48.44) 106.42,48.21 106.24,48.03 106.24,47.68 109.09,44.83 109.09,26.03 110.49,24.63 110.49,23.87 110.33,23.71 110.24,23.71 110.04,23.51 110.04,23.08 110.24,22.88 110.61,22.88 110.7,22.79 110.7,22.52 110.61,22.43 110.24,22.43 110.04,22.23 110.04,21.8 110.24,21.6 110.61,21.6 110.7,21.51 110.7,21.24 110.61,21.15 110.24,21.15 110.04,20.95 110.04,19.1 110.35,18.78 110.52,18.78 v2(110.77,18.52)
  BOTTOM w0.076: 106.81,50.95 106.81,50.97 106.82,50.98 106.82,52.51 106.51,52.82 106.51,54.19 UC1.AB3
  BOTTOM w0.089: JDIMM2.13 112.22,21.6 112,21.38 112,21.2 111.56,20.77 111.56,19.08 111.23,18.75 111.01,18.75 v2(110.77,18.52) ; v2(106.42,48.44) 107.08,49.1 107.08,50.14 106.81,50.41 106.81,50.95
DDR_B_DQS1: length 47.4
  IN3 w0.076: v2(110,48.65) 110.36,48.65 110.44,48.72 110.72,48.72 112.77,46.66 112.77,46.03 112.79,46.02 112.79,46
  IN3 w0.089: 112.79,46 112.79,35.75 115.44,33.1 115.44,20.26 115.53,20.17 115.98,20.17 116.19,19.96 116.19,19.55 115.98,19.34 115.53,19.34 115.44,19.25 115.44,17.83 115.62,17.64 116.2,17.64 v2(116.44,17.89)
  BOTTOM w0.076: 109.74,51.71 109.73,51.72 109.73,51.73 109.02,52.43 109.02,54.2 UC1.V3
  BOTTOM w0.089: 109.74,51.71 110.61,50.83 110.61,50.38 110.58,50.35 110.58,49.76 110.61,49.72 110.61,48.87 110.38,48.65 v2(110,48.65) ; JDIMM2.34 117.47,15.12 117.28,15.32 117.28,17.34 116.92,17.7 116.63,17.7 v2(116.44,17.89)
DDR_B_DQS2: length 82.1
  IN1 w0.076: v2(106.89,58.71) 106.51,58.33 106.51,57.06 106.64,56.94 106.64,51.38 107.41,50.61 107.43,50.61 107.44,50.6
  IN1 w0.089: 107.44,50.6 110.67,47.38 110.67,45.99 114.17,42.48 116.35,42.48 119.57,39.26 141.98,39.26 143.17,38.07 144.03,38.07 148.62,33.49 148.62,33.2 148.41,32.99 148.41,32.86 148.6,32.68 148.72,32.68 148.85,32.8 149.16,32.8 149.44,32.52 149.44,32.21 149.31,32.08 149.31,31.96 149.5,31.77 149.63,31.77 149.72,31.86 150.02,31.86 150.31,31.57 150.31,31.27 150.22,31.18 150.22,31.05 154.91,26.36 154.91,19.1 155.02,18.99 155.12,18.99 155.35,19.22 v2(155.35,19.5)
  BOTTOM w0.076: UC1.AA9 106.57,58.39 v2(106.89,58.71)
  BOTTOM w0.089: v2(155.35,19.5) 155.35,19.12 155.2,18.96 155.05,18.96 154.74,19.27 154.74,20.25 155.53,21.04 155.53,21.23 155.72,21.42 JDIMM2.179
DDR_B_DQS3: length 84.2
  IN1 w0.076: v2(109.6,58.71) 109.29,58.4 109.29,57.58 109.28,57.57 109.28,56.93 109.5,56.72 109.5,52.32 114.25,47.57 114.25,47.46 114.3,47.41 114.31,47.41 114.34,47.38 114.37,47.38 114.38,47.38
  IN1 w0.089: 114.38,47.38 115.71,46.05 119,46.05 122.21,42.83 144.26,42.83 159.44,27.65 159.44,25.89 160.02,25.31 160.02,18.05 160.33,17.74 160.81,17.74 161.01,17.95 v2(161.01,18.35)
  BOTTOM w0.076: UC1.V9 109.27,58.39 v2(109.6,58.71)
  BOTTOM w0.089: v2(161.01,18.35) 161.29,18.08 161.65,18.08 161.95,17.77 161.95,16.57 160.86,15.48 160.86,15.11 160.97,15 JDIMM2.200
DDR_B_DQS4: length 49
  IN3 w0.076: 115.57,47.7 115.56,47.7 115.54,47.72 115.54,47.73 113.63,49.64 113.38,49.64 113.18,49.44 v2(112.97,49.44)
  IN3 w0.089: v2(121.98,18.47) 122.21,18.7 122.63,18.7 122.84,18.91 122.84,21.05 122.59,21.3 121.92,21.3 121.83,21.39 121.83,21.66 121.92,21.74 122.63,21.74 122.84,21.95 122.84,30.65 117.12,36.37 117.12,46.78 116.2,47.7 115.57,47.7
  BOTTOM w0.076: 112.28,52.16 112.26,52.17 112.26,52.18 111.54,52.9 111.54,54.19 UC1.R3
  BOTTOM w0.089: v2(121.98,18.47) 122.27,18.77 122.42,18.77 122.7,19.05 122.7,20.68 122.53,20.85 122.53,21.11 122.72,21.3 JDIMM2.55 ; 112.28,52.16 113.53,50.9 113.53,49.88 113.09,49.44 v2(112.97,49.44)
DDR_B_DQS5: length 51
  IN3 w0.089: v2(116.38,51.65) 116.38,51.92 116.49,52.03 116.85,52.03 117.44,51.44 118.86,51.44 123.92,46.38 123.92,41.41 124.84,40.49 124.84,35.27 128.06,32.06 128.06,17.45 127.94,17.32 127.71,17.32 127.62,17.41 v2(127.62,17.89)
  BOTTOM w0.076: UC1.M3 113.96,54.29 113.96,54.11 114.05,54.03 114.05,52.99 115.59,51.46 115.9,51.46 116.09,51.65 v2(116.38,51.65)
  BOTTOM w0.089: JDIMM2.76 127.97,14.87 127.8,15.05 127.8,15.43 128.34,15.98 128.34,17.35 128.15,17.54 127.96,17.54 127.95,17.56 v2(127.62,17.89)
DDR_B_DQS6: length 85
  IN1 w0.076: 117.37,49.77 117.35,49.76 117.24,49.76 117.12,49.89 116.28,49.89 113,53.17 113,55.68 112.02,56.65 112.02,56.99 112.01,57.01 112.01,58.34 v2(112.38,58.71)
  IN1 w0.089: 117.37,49.77 121.55,49.77 124.99,46.33 145.73,46.33 165.61,26.46 165.61,23.18 166.59,22.21 166.59,21.81 166.28,21.5 165.67,21.5 165.58,21.42 165.58,21.15 165.67,21.06 165.93,21.06 166.14,20.86 166.14,20.43 165.93,20.22 165.67,20.22 165.58,20.14 165.58,19.4 165.88,19.1 166.41,19.1 166.58,19.27 v2(166.58,19.55)
  BOTTOM w0.076: UC1.P9 112.05,58.39 v2(112.38,58.71)
  BOTTOM w0.089: v2(166.58,19.55) 166.58,19.19 166.49,19.1 166.19,19.1 166.03,19.26 166.03,21.13 166.22,21.32 JDIMM2.221
DDR_B_DQS7: length 86.2
  IN1 w0.076: 116.79,55.46 116.77,55.46 116.75,55.47 116.47,55.47 115.94,56 115.94,56.24 115.28,56.89 114.85,56.89 114.52,57.22 114.52,58.06 114.42,58.17 114.3,58.17 v2(114.21,58.08)
  IN1 w0.089: v2(172.26,17.31) 172.26,17.52 172.08,17.71 171.55,17.71 171.25,18 171.25,22.88 170.9,23.23 170.9,24.43 170.6,24.73 170.38,24.73 170.15,24.95 170.15,25.33 170.69,25.87 170.69,26.15 147.08,49.76 127.95,49.76 125.1,52.61 124.11,52.61 123.56,53.16 119.73,53.16 117.44,55.46 116.79,55.46
  BOTTOM w0.076: UC1.L9 114.52,58.39 v2(114.21,58.08)
  BOTTOM w0.089: v2(172.26,17.31) 172.26,17.62 172.06,17.82 171.87,17.82 171.33,17.29 171.33,15.17 171.47,15.04 JDIMM2.242
DDR_B_DQS#0: length 45.5
  IN3 w0.089: v2(106.83,48.01) 106.78,48.06 106.55,48.06 106.44,47.95 106.44,47.76 109.29,44.91 109.29,26.11 110.69,24.71 110.69,23.79 110.41,23.52 110.32,23.52 110.23,23.43 110.23,23.16 110.32,23.07 110.69,23.07 110.89,22.87 110.89,22.44 110.69,22.24 110.32,22.24 110.23,22.15 110.23,21.88 110.32,21.79 110.69,21.79 110.89,21.59 110.89,21.16 110.69,20.96 110.32,20.96 110.23,20.87 110.23,19.18 110.44,18.97 110.59,18.97 110.77,19.16 v2(110.77,19.34)
  BOTTOM w0.076: UC1.AA3 106.68,54.19 106.68,52.89 106.98,52.58 106.98,50.98 106.99,50.97 106.99,50.95
  BOTTOM w0.089: 106.99,50.95 106.99,50.49 107.26,50.21 107.26,49.02 106.83,48.59 v2(106.83,48.01) ; JDIMM2.11 111.72,21.55 111.82,21.46 111.82,21.28 111.38,20.84 111.38,19.16 111.15,18.94 110.87,18.94 110.77,19.04 v2(110.77,19.34)
DDR_B_DQS#1: length 47.4
  IN3 w0.076: 112.59,46 112.59,46.02 112.61,46.03 112.61,46.59 110.65,48.55 110.5,48.55 110.43,48.48 110.43,48.22 v2(110.43,48.22)
  IN3 w0.089: v2(116.39,17.03) 115.97,17.45 115.54,17.45 115.24,17.75 115.24,19.33 115.45,19.53 115.9,19.53 116,19.63 116,19.88 115.9,19.98 115.45,19.98 115.24,20.18 115.24,33.02 112.59,35.67 112.59,46
  BOTTOM w0.076: UC1.U3 109.19,54.19 109.19,52.5 109.84,51.85 109.86,51.85 109.87,51.83
  BOTTOM w0.089: v2(110.43,48.22) 110.43,48.44 110.79,48.8 v4(110.79,50.05) 110.79,50.91 109.87,51.83 ; JDIMM2.32 116.97,15.21 117.09,15.33 117.09,17.27 116.84,17.52 116.69,17.52 116.39,17.21 v2(116.39,17.03)
DDR_B_DQS#2: length 82
  IN1 w0.076: v2(105.98,58.71) 106.35,58.34 106.35,57 106.47,56.87 106.47,51.31 107.29,50.5 107.29,50.48 107.3,50.46
  IN1 w0.089: v2(155.36,18.56) 155.16,18.77 154.97,18.77 154.72,19.02 154.72,26.28 150.02,30.97 150.02,31.26 150.11,31.35 150.11,31.49 149.94,31.66 149.8,31.66 149.71,31.57 149.42,31.57 149.12,31.88 149.12,32.17 149.25,32.29 149.25,32.44 149.07,32.61 148.93,32.61 148.8,32.48 148.52,32.48 148.21,32.78 148.21,33.07 148.42,33.28 148.42,33.4 143.95,37.87 143.09,37.87 141.9,39.06 119.49,39.06 116.27,42.29 114.09,42.29 110.47,45.91 110.47,47.3 107.3,50.46
  BOTTOM w0.076: UC1.AC9 105.65,58.39 v2(105.98,58.71)
  BOTTOM w0.089: v2(155.36,18.56) 155.14,18.78 154.98,18.78 154.56,19.2 154.56,20.33 155.35,21.12 155.35,21.3 155.22,21.43 JDIMM2.177
DDR_B_DQS#3: length 84.3
  IN1 w0.076: v2(108.7,58.77) 109.12,58.34 109.12,57.65 109.12,57.64 109.12,56.86 109.33,56.65 109.33,52.25 114.08,47.51 114.08,47.4 114.24,47.24
  IN1 w0.089: v2(161.03,17.37) 160.86,17.54 160.25,17.54 159.82,17.97 159.82,25.23 159.25,25.81 159.25,27.57 144.18,42.63 122.13,42.63 118.91,45.85 115.63,45.85 114.24,47.24
  BOTTOM w0.076: UC1.W9 108.32,58.39 v2(108.7,58.77)
  BOTTOM w0.089: v2(161.03,17.37) 161.03,17.74 161.19,17.9 161.58,17.9 161.77,17.7 161.77,16.64 160.68,15.55 160.68,15.15 160.47,14.94 JDIMM2.198
DDR_B_DQS#4: length 49
  IN3 w0.076: v2(113.42,48.99) 113.34,49.07 113.34,49.32 113.46,49.44 113.59,49.44 115.37,47.66 115.37,47.62 115.43,47.56
  IN3 w0.089: 115.43,47.56 115.49,47.51 116.11,47.51 116.92,46.7 116.92,36.29 122.64,30.57 122.64,22.03 122.55,21.94 121.84,21.94 121.64,21.74 121.64,21.31 121.84,21.1 122.51,21.1 122.64,20.97 122.64,18.99 122.55,18.9 122.22,18.9 121.96,19.15 121.96,19.46 v2(121.95,19.47)
  BOTTOM w0.076: UC1.P3 111.71,54.19 111.71,52.97 112.38,52.3 112.39,52.3 112.4,52.29
  BOTTOM w0.089: v2(113.42,48.99) 113.38,49.03 113.38,49.48 113.71,49.81 113.71,50.98 112.4,52.29 ; JDIMM2.53 122.22,21.29 122.35,21.15 122.35,20.77 122.52,20.6 122.52,19.12 122.35,18.95 122.12,18.95 121.95,19.12 v2(121.95,19.47)
DDR_B_DQS#5: length 51
  IN3 w0.089: v2(127.62,16.91) 127.84,17.13 128.02,17.13 128.26,17.37 128.26,32.14 125.04,35.35 125.04,40.57 124.12,41.49 124.12,46.46 118.94,51.64 117.52,51.64 116.93,52.22 116.41,52.22 116.26,52.08 v2(115.98,52.08)
  BOTTOM w0.076: UC1.L3 114.23,54.48 114.13,54.37 114.13,54.18 114.22,54.09 114.22,53.06 115.66,51.62 115.83,51.62 115.98,51.78 v2(115.98,52.08)
  BOTTOM w0.089: v2(127.62,16.91) 127.62,17.03 127.95,17.36 128.07,17.36 128.16,17.27 128.16,16.05 127.61,15.5 127.61,15.13 127.47,14.98 JDIMM2.74
DDR_B_DQS#6: length 85
  IN1 w0.076: 117.37,49.58 117.36,49.58 117.34,49.59 117.17,49.59 117.05,49.72 116.21,49.72 112.84,53.1 112.84,55.61 111.86,56.58 111.86,56.6 111.84,56.61 111.84,58.33 v2(111.47,58.71)
  IN1 w0.089: v2(166.55,18.64) 166.29,18.9 165.8,18.9 165.38,19.32 165.38,20.22 165.59,20.42 165.85,20.42 165.94,20.51 165.94,20.78 165.85,20.86 165.59,20.86 165.38,21.07 165.38,21.5 165.59,21.7 166.2,21.7 166.39,21.89 166.39,22.12 165.41,23.1 165.41,26.37 145.65,46.14 124.91,46.14 121.47,49.58 117.37,49.58
  BOTTOM w0.076: v2(111.47,58.71) 111.14,58.39 UC1.R9
  BOTTOM w0.089: JDIMM2.219 165.72,21.3 165.85,21.16 165.85,19.18 166.11,18.92 166.28,18.92 166.55,18.65 v2(166.55,18.64)
DDR_B_DQS#7: length 86.2
  IN1 w0.076: v2(114.2,58.68) 114.2,58.62 114.68,58.13 114.68,57.29 114.92,57.06 115.35,57.06 116.11,56.3 116.11,56.07 116.54,55.64 116.75,55.64 116.77,55.65 116.79,55.65
  IN1 w0.089: 116.79,55.65 117.52,55.65 119.82,53.36 123.64,53.36 124.19,52.81 125.18,52.81 128.03,49.96 147.16,49.96 170.89,26.23 170.89,25.79 170.35,25.25 170.35,25.04 170.46,24.92 170.68,24.92 171.09,24.51 171.09,23.31 171.45,22.96 171.45,18.08 171.63,17.9 171.97,17.9 v2(172.27,18.2)
  BOTTOM w0.076: UC1.M9 113.91,58.39 v2(114.2,58.68)
  BOTTOM w0.089: JDIMM2.240 170.97,15.03 171.15,15.2 171.15,17.36 171.79,18 172.07,18 v2(172.27,18.2)
DDR_B_MA0: length 80.4
  IN1 w0.076: 102.44,44.6 102.44,44.92 101.62,45.74 101.62,53.16 100.88,53.91 100.88,56.4 100.05,57.23 100.05,58.27 v2(100.49,58.71)
  IN1 w0.152: 102.44,44.6 102.44,40.76 112.24,30.97 137.94,30.97 144.76,24.16 144.76,19.35 144.98,19.13 145.31,19.13 145.4,19.03 145.4,18.14 145.61,17.93 v2(145.89,17.93)
  BOTTOM w0.076: UC1.AJ9 100.17,58.39 v2(100.49,58.71)
  BOTTOM w0.168: JDIMM2.144 144.97,17.49 145.41,17.93 v2(145.89,17.93)
DDR_B_MA1: length 78.9
  IN1 w0.076: 99.53,47.18 99.53,48.17 99.73,48.37 99.73,52.49 99.12,53.1 99.12,54.78 98.7,55.19 98.7,55.79 v2(99.03,56.12)
  IN1 w0.152: v2(141.18,20.44) 141.13,20.48 141.13,22.73 140.95,22.91 140.95,23.93 137.09,27.78 111.33,27.78 105.75,33.36 105.54,33.36 105.26,33.08 105.04,33.08 104.83,33.29 104.83,33.51 105.11,33.79 105.11,34.01 104.89,34.22 104.68,34.22 104.4,33.94 104.18,33.94 103.96,34.16 103.96,34.37 104.25,34.65 104.25,34.87 104.03,35.08 103.81,35.08 103.53,34.8 103.32,34.8 103.1,35.02 103.1,35.23 103.38,35.52 103.38,35.73 103.17,35.95 102.95,35.95 102.67,35.67 102.46,35.67 102.24,35.88 102.24,36.1 102.52,36.38 102.52,36.59 102.3,36.81 102.09,36.81 101.81,36.53 101.59,36.53 101.38,36.74 101.38,36.96 101.66,37.24 101.66,37.46 101.44,37.67 101.23,37.67 100.95,37.39 100.73,37.39 100.51,37.61 100.51,37.82 100.8,38.1 100.8,38.32 100.58,38.53 100.36,38.53 100.08,38.25 99.87,38.25 99.65,38.47 99.65,38.68 99.93,38.97 99.93,39.18 99.59,39.52 99.59,46.71 99.53,46.77 99.53,47.18
  BOTTOM w0.076: UC1.AK6 99.16,56.12 v2(99.03,56.12)
  BOTTOM w0.168: JDIMM2.133 142.22,21.48 v2(141.18,20.44)
DDR_B_MA2: length 81.2
  IN1 w0.076: v2(99.79,55.46) 99.41,55.08 99.41,53.26 99.89,52.77 99.89,50.23 99.89,50.23 99.89,49.9 99.89,49.9 99.89,47.28 100,47.18
  IN1 w0.152: v2(142.62,15.54) 142.91,15.54 143.06,15.39 143.06,15.14 142.83,14.91 142.11,14.91 141.94,15.08 141.94,15.53 141.75,15.72 141.75,16.59 141.91,16.74 143.09,16.74 143.24,16.89 143.24,17.2 143.09,17.35 141.91,17.35 141.75,17.5 141.75,17.82 141.91,17.97 142.3,17.97 142.46,18.13 142.46,18.43 142.3,18.58 141.91,18.58 141.75,18.74 141.75,22.93 141.45,23.24 141.45,24.08 137.28,28.24 111.52,28.24 100.05,39.71 100.05,47.13 100,47.18
  BOTTOM w0.076: v2(99.79,55.46) 99.47,55.78 UC1.AK5
  BOTTOM w0.168: JDIMM2.132 141.97,14.9 v2(142.62,15.54)
DDR_B_MA3: length 80.7
  IN1 w0.076: 99.03,45.49 98.65,45.87 98.65,52.17 98.8,52.32 98.8,54.48 98.24,55.04 v2(98.24,55.45)
  IN1 w0.152: v2(141.2,18.79) 140.65,19.33 140.65,22.51 140.45,22.71 140.45,23.78 136.9,27.33 111.14,27.33 110.15,28.32 109.94,28.32 109.65,28.03 109.43,28.03 109.22,28.24 109.22,28.46 109.5,28.75 109.5,28.96 109.29,29.18 109.07,29.18 108.78,28.89 108.57,28.89 108.35,29.11 108.35,29.32 108.64,29.61 108.64,29.83 108.43,30.04 108.21,30.04 107.92,29.75 107.71,29.75 107.49,29.97 107.49,30.19 107.78,30.47 107.78,30.69 107.56,30.9 107.35,30.9 107.06,30.62 106.84,30.62 106.63,30.83 106.63,31.05 106.92,31.34 106.92,31.55 106.7,31.77 106.48,31.77 106.2,31.48 105.98,31.48 105.77,31.7 105.77,31.91 106.05,32.2 106.05,32.41 105.8,32.66 105.53,32.66 105.29,32.42 104.86,32.42 99.13,38.15 99.13,45.39 99.03,45.49
  BOTTOM w0.076: v2(98.24,55.45) 98.57,55.78 UC1.AL5
  BOTTOM w0.168: JDIMM2.131 141.72,21.51 141.27,21.06 141.14,21.06 140.71,20.62 140.71,19.27 v2(141.2,18.79)
DDR_B_MA4: length 81
  IN1 w0.076: v2(98.24,56.1) 97.95,56.4 97.25,56.4 97,56.14 97,54.61 98.22,53.39 98.22,52.48 98.04,52.3 98.04,45.39 98.22,45.21 98.22,45.11
  IN1 w0.152: 98.22,45.11 98.22,37.4 109.21,26.41 136.07,26.41 138.46,24.02 138.46,23.41 139.66,22.21 139.66,14.95 139.81,14.79 141.26,14.79 141.49,15.02 141.49,15.34 141.32,15.51 v2(140.97,15.51)
  BOTTOM w0.076: UC1.AL6 98.57,56.43 v2(98.24,56.1)
  BOTTOM w0.168: v2(140.97,15.51) JDIMM2.128
DDR_B_MA5: length 79.3
  IN1 w0.076: 98.68,45.11 98.68,45.3 98.57,45.4 98.57,45.42 98.37,45.62 98.37,52.25 98.52,52.4 98.52,54.23 97.81,54.94 97.81,55.63 v2(97.4,56.04)
  IN1 w0.152: 98.68,45.11 98.68,37.59 109.4,26.87 136.26,26.87 138.97,24.16 138.97,23.54 140.16,22.36 140.16,16.2 140.28,16.08 140.53,16.08 140.71,16.26 140.71,17.07 140.81,17.17 v2(141.19,17.17)
  BOTTOM w0.076: v2(97.4,56.04) 97.79,56.43 UC1.AM6
  BOTTOM w0.168: v2(141.19,17.17) 140.47,16.45 JDIMM2.126
DDR_B_MA6: length 80.3
  IN1 w0.076: v2(97.78,56.9) 97.52,56.9 97.12,56.5 96.97,56.5 96.77,56.3 96.77,54.29 97.28,53.78 97.28,52.27 97.76,51.79 97.76,45.11
  IN1 w0.152: v2(138.64,18.79) 139.12,19.27 139.12,20.6 138.26,21.46 137.82,21.46 137.63,21.66 137.63,21.91 137.78,22.06 138.4,22.06 138.55,22.21 138.55,22.53 138.43,22.66 137.32,22.66 137.17,22.81 137.17,23.07 137.32,23.22 137.7,23.22 137.86,23.37 137.86,23.68 137.7,23.83 137.26,23.83 137.11,23.98 137.11,24.71 135.86,25.96 108.99,25.96 97.76,37.19 97.76,45.11
  BOTTOM w0.076: UC1.AN7 97.58,57.09 97.75,56.91 97.76,56.91 v2(97.78,56.9)
  BOTTOM w0.168: JDIMM2.127 140.72,21.24 140.05,20.57 140.05,20.2 v2(138.64,18.79)
DDR_B_MA7: length 80.9
  IN1 w0.076: 96.85,47.43 96.85,51.43 96.72,51.56 96.72,53.14 96.31,53.54 96.31,56.41 96.8,56.9 96.98,56.9 97.38,57.3 97.38,58.99 v2(97.75,59.36)
  IN1 w0.152: v2(139.07,17.34) 138.21,17.34 137.96,17.59 137.96,20.03 135.03,22.96 135.03,24.89 134.88,25.04 108.61,25.04 103.67,29.98 102.88,29.98 96.85,36.02 96.85,47.43
  BOTTOM w0.076: UC1.AN10 v2(97.75,59.36)
  BOTTOM w0.168: JDIMM2.122 139.47,15.01 139.7,15.24 139.7,16.71 v2(139.07,17.34)
DDR_B_MA8: length 79.9
  IN1 w0.076: v2(97.74,57.5) 97.74,57.38 97.06,56.7 96.89,56.7 96.57,56.38 96.57,53.95 96.97,53.54 96.97,51.94 97.3,51.61 97.3,47.43
  IN1 w0.152: v2(138.61,20.31) 138.33,20.31 136.17,22.47 136.17,23 136.65,23.48 136.65,24 136.5,24.15 135.74,24.15 135.49,24.4 135.49,25.35 135.34,25.5 108.8,25.5 103.51,30.79 103.3,30.79 103.14,30.63 102.92,30.63 102.7,30.84 102.7,31.06 102.86,31.22 102.86,31.43 102.65,31.65 102.43,31.65 102.27,31.49 102.06,31.49 101.84,31.71 101.84,31.92 102,32.08 102,32.3 101.79,32.51 101.57,32.51 101.41,32.35 101.2,32.35 100.98,32.57 100.98,32.78 101.14,32.94 101.14,33.16 100.86,33.44 100.64,33.44 100.51,33.31 100.29,33.31 100.07,33.53 100.07,33.74 100.21,33.88 100.21,34.09 99.99,34.31 99.78,34.31 99.64,34.17 99.43,34.17 99.21,34.39 99.21,34.6 99.35,34.74 99.35,34.95 99.13,35.17 98.91,35.17 98.78,35.03 98.56,35.03 98.35,35.25 98.35,35.47 98.48,35.6 98.48,35.82 98.27,36.03 98.05,36.03 97.92,35.9 97.7,35.9 97.49,36.11 97.49,36.33 97.62,36.46 97.62,36.68 97.3,37 97.3,47.43
  BOTTOM w0.076: v2(97.74,57.5) 97.51,57.74 UC1.AN8
  BOTTOM w0.168: v2(138.61,20.31) 139.2,20.31 140.22,21.33 JDIMM2.125
DDR_B_MA9: length 80.1
  IN1 w0.076: v2(95.91,59.31) 96.48,58.74 96.48,57.75 95.8,57.07 95.8,56.16 95.42,55.78 95.42,53.44 96.08,52.78 96.08,47.6 95.93,47.45 95.93,47.43
  IN1 w0.152: 95.93,47.43 95.93,35.58 107.39,24.13 113.63,24.13 114.16,23.6 133.1,23.6 136.88,19.81 136.88,18.51 v2(136.44,18.07)
  BOTTOM w0.076: UC1.AR11 95.53,59.69 v2(95.91,59.31)
  BOTTOM w0.168: v2(136.44,18.07) 138.1,19.73 138.1,20.42 138.43,20.75 138.48,20.75 139.22,21.49 JDIMM2.121
DDR_B_MA10: length 80.5
  IN1 w0.076: 103.82,44.6 103.82,44.72 102.23,46.3 102.23,53.41 101.49,54.16 101.49,54.16 101.45,54.19 101.45,56.78 101.41,56.83 v2(101.41,57.41)
  IN1 w0.152: 103.82,44.6 103.82,42.25 113.72,32.34 138.51,32.34 146.33,24.53 146.33,17.62 146.33,17.62 146.33,15.99 146.18,15.84 145.37,15.84 145.22,15.99 145.22,16.33 145.37,16.48 145.85,16.48 v2(145.93,16.41)
  BOTTOM w0.076: UC1.AH7 v2(101.41,57.41)
  BOTTOM w0.168: v2(145.93,16.41) 145.99,16.41 147.47,14.93 JDIMM2.146
DDR_B_MA11: length 84
  IN1 w0.076: 96.39,47.43 96.39,47.62 96.38,47.62 96.38,52.99 96.14,53.24 96.14,56.57 96.68,57.11 96.91,57.11 97.2,57.4 97.2,59.46 v2(97.75,60.01)
  IN1 w0.152: 96.39,47.43 96.39,35.83 102.91,29.3 103.13,29.3 103.29,29.46 103.5,29.46 103.72,29.25 103.72,29.03 103.56,28.87 103.56,28.66 103.78,28.44 103.99,28.44 104.15,28.6 104.37,28.6 104.58,28.38 104.58,28.17 104.42,28.01 104.42,27.79 104.64,27.58 104.85,27.58 105.01,27.74 105.23,27.74 105.44,27.52 105.44,27.31 105.29,27.15 105.29,26.93 105.5,26.72 105.72,26.72 105.88,26.87 106.09,26.87 106.31,26.66 106.31,26.44 106.15,26.28 106.15,26.07 106.36,25.85 106.58,25.85 106.74,26.01 106.95,26.01 107.17,25.8 107.17,25.58 107.01,25.42 107.01,25.21 107.63,24.58 133.7,24.58 134.41,23.88 134.41,22.93 137.46,19.89 137.46,17.43 138.35,16.54 138.35,16.41 138.96,15.8 v2(139.14,15.8)
  BOTTOM w0.076: UC1.AN11 v2(97.75,60.01)
  BOTTOM w0.168: v2(139.14,15.8) 138.97,15.63 JDIMM2.120
DDR_B_MA12: length 76.2
  IN1 w0.076: 95.47,47.43 95.47,47.62 95.74,47.88 95.75,47.88 95.75,52.76 95.22,53.29 95.22,55.88 95.55,56.21 95.55,57.14 96.28,57.86 96.28,58.35 v2(95.92,58.7)
  IN1 w0.152: 95.47,47.43 95.47,35.4 107.2,23.67 113.44,23.67 113.97,23.14 132.91,23.14 v2(136.45,19.6)
  BOTTOM w0.076: UC1.AR10 95.59,59.04 v2(95.92,58.7)
  BOTTOM w0.168: JDIMM2.119 138.72,21.45 138.4,21.13 137.99,21.13 v2(136.45,19.6)
DDR_B_MA13: length 83
  IN1 w0.076: 104.4,47.81 104.4,47.86 103.87,48.39 103.87,50.06 103.87,50.06 103.87,53.57 103.07,54.37 103.07,56.95 102.82,57.2 102.82,57.7 v2(103.21,58.1)
  IN1 w0.152: v2(149.78,16.34) 149.71,16.41 149.16,16.41 148.99,16.24 148.99,15.81 149.21,15.6 149.97,15.6 150.29,15.91 150.29,17.22 149.51,18 149.51,18.66 149.78,18.92 149.78,19.3 149.55,19.53 149.42,19.53 149.27,19.68 149.27,23.39 149.12,23.54 149.12,24.13 148.66,24.59 148.66,25.43 139.46,34.63 114.67,34.63 106.1,43.19 106.1,45.36 104.4,47.07 104.4,47.81
  BOTTOM w0.076: UC1.AF9 102.92,58.39 v2(103.21,58.1)
  BOTTOM w0.168: JDIMM2.158 150.47,16.15 150.28,16.34 v2(149.78,16.34)
DDR_B_MA14: length 77.5
  IN1 w0.076: 103.6,46.57 103.6,46.63 103.46,46.77 103.46,49.89 103.46,53.45 102.61,54.31 102.21,54.31 102,54.51 102,56.85 102.21,57.06 102.21,57.7 101.96,57.94 101.96,59.85 101.8,60.01 v2(101.41,60.01)
  IN1 w0.152: 103.6,46.57 105.19,44.98 105.19,42.82 114.29,33.72 139.08,33.72 147.75,25.05 147.75,24.18 148.15,23.77 148.15,23.19 148.28,23.06 148.28,22.75 148.13,22.6 147.9,22.6 147.75,22.45 147.75,22.14 147.9,21.99 148.21,21.99 148.36,21.84 148.36,21.53 148.21,21.38 147.98,21.38 147.83,21.23 147.83,20.92 147.98,20.77 v2(148.23,20.77)
  BOTTOM w0.076: UC1.AH11 v2(101.41,60.01)
  BOTTOM w0.168: v2(148.23,20.77) 148.72,21.26 JDIMM2.151
DDR_B_MA15: length 83.8
  IN1 w0.076: v2(102.37,58.08) 102.51,57.93 102.51,57.2 102.87,56.84 102.87,54.28 103.66,53.48 103.66,49.98 103.66,48.13 103.84,47.95 103.84,47.25
  IN1 w0.152: 103.84,47.25 103.84,46.97 105.64,45.17 105.64,43.01 114.48,34.17 139.27,34.17 148.21,25.24 148.21,24.38 148.65,23.94 148.65,23.36 148.81,23.19 148.81,18.77 149.06,18.53 149.06,17.79 149.33,17.52 149.33,17.3 149.13,17.1 148.91,17.1 148.54,17.47 148.54,18.34 148.2,18.67 v2(148.2,19.07)
  BOTTOM w0.076: v2(102.37,58.08) 102.71,57.74 UC1.AF8
  BOTTOM w0.168: JDIMM2.156 149.97,15.18 149.25,15.9 149.25,18.02 v2(148.2,19.07)
DDR_B_MA16: length 81.2
  IN1 w0.076: 103.27,46.25 103.26,46.26 103.26,52.97 101.82,54.4 101.82,56.96 101.97,57.1 101.97,57.65 101.89,57.72 101.77,57.84 101.77,59 v2(101.41,59.36)
  IN1 w0.152: 103.27,46.25 104.73,44.79 104.73,42.63 114.1,33.26 138.89,33.26 147.27,24.88 147.27,20.8 147.63,20.44 147.63,18.29 147.25,17.9 147.25,17.25 147.4,17.09 147.85,17.09 v2(148.09,17.33)
  BOTTOM w0.076: UC1.AH10 v2(101.41,59.36)
  BOTTOM w0.168: JDIMM2.152 148.97,15.57 148.65,15.89 148.65,16.77 v2(148.09,17.33)
DDR_B_ODT0: length 87.3
  IN1 w0.076: v2(103.25,57.43) 103.27,57.4 103.27,54.45 104.07,53.65 104.07,50.15 104.07,48.69 106.69,46.07
  IN1 w0.152: v2(149.96,20.7) 150.06,20.8 150.06,24.3 149.45,24.91 149.45,25.78 139.81,35.42 115.95,35.42 115.53,35.84 115.31,35.84 115.05,35.58 114.83,35.58 114.62,35.8 114.62,36.01 114.88,36.28 114.88,36.49 114.66,36.71 114.45,36.71 114.18,36.44 113.97,36.44 113.75,36.66 113.75,36.87 114.02,37.14 114.02,37.35 113.8,37.57 113.59,37.57 113.32,37.3 113.11,37.3 112.89,37.52 112.89,37.74 113.16,38 113.16,38.22 112.94,38.43 112.72,38.43 112.46,38.17 112.24,38.17 112.03,38.38 112.03,38.6 112.29,38.86 112.29,39.08 112.08,39.29 111.86,39.29 111.6,39.03 111.38,39.03 111.17,39.25 111.17,39.46 111.43,39.73 111.43,39.94 111.21,40.16 111,40.16 110.73,39.89 110.52,39.89 110.3,40.11 110.3,40.32 110.57,40.59 110.57,40.8 110.35,41.02 110.14,41.02 109.87,40.75 109.66,40.75 109.44,40.97 109.44,41.19 109.7,41.45 109.7,41.67 109.49,41.88 109.27,41.88 109.01,41.62 108.79,41.62 108.58,41.83 108.58,42.05 108.84,42.31 108.84,42.53 108.63,42.74 108.41,42.74 108.15,42.48 107.93,42.48 107.72,42.7 107.72,42.91 107.98,43.18 107.98,43.39 107.79,43.58 107.55,43.58 107.32,43.36 107.11,43.36 106.89,43.58 106.89,43.79 107.11,44.02 107.11,44.26 106.89,44.48 106.89,45.87 106.69,46.07
  BOTTOM w0.076: UC1.AF7 102.91,57.09 v2(103.25,57.43)
  BOTTOM w0.168: JDIMM2.155 149.72,21.6 148.68,20.55 148.68,19.04 148.86,18.85 149.24,18.85 149.36,18.97 149.36,20.4 149.67,20.7 v2(149.96,20.7)
DDR_B_ODT1: length 88.9
  IN1 w0.076: 107.34,46.71 107.21,46.85 106.84,46.85 105.25,48.44 104.97,48.44 104.48,48.93 104.48,50.31 104.48,53.82 103.68,54.62 103.68,56.87 103.92,57.11 103.92,57.11 v2(104.12,57.31)
  IN1 w0.152: v2(151.56,20.07) 151.25,20.07 151.11,19.93 151.11,18.58 150.97,18.43 150.68,18.43 150.57,18.55 150.57,20.41 150.72,20.56 151,20.56 151.15,20.71 151.15,21.02 151,21.17 150.67,21.17 150.52,21.32 150.52,21.8 150.67,21.95 151.71,21.95 151.82,22.06 151.82,22.45 151.71,22.56 150.67,22.56 150.52,22.72 150.52,23.11 150.67,23.27 151.67,23.27 151.82,23.42 151.82,25.43 150.98,26.27 150.77,26.27 150.67,26.17 150.46,26.17 150.24,26.39 150.24,26.6 150.34,26.7 150.34,26.91 150.12,27.13 149.91,27.13 149.77,27 149.56,27 149.34,27.21 149.34,27.43 149.47,27.56 149.47,27.78 140.81,36.44 117.65,36.44 117.41,36.69 117.19,36.69 116.94,36.44 116.72,36.44 116.51,36.65 116.51,36.87 116.76,37.12 116.76,37.33 116.59,37.5 116.38,37.5 115.9,37.02 115.64,37.02 115.44,37.22 115.44,37.44 115.94,37.94 115.94,38.15 115.73,38.36 115.5,38.36 115.01,37.87 114.79,37.87 114.6,38.07 114.6,38.28 115.09,38.78 115.09,39 114.42,39.67 112.99,39.67 107.8,44.86 107.8,46.25 107.34,46.71
  BOTTOM w0.076: UC1.AE8 v2(104.12,57.31)
  BOTTOM w0.168: JDIMM2.161 151.22,21.31 151.1,21.19 151.1,20.52 v2(151.56,20.07)
DDR_B_PAR: length 79.2
  IN1 w0.076: v2(100.49,57.41) 100.79,57.11 100.79,56.81 101.09,56.51 101.09,53.98 101.83,53.24 101.83,45.9 102.9,44.82 102.9,44.6
  IN1 w0.152: 102.9,44.6 102.9,40.95 108.95,34.9 109.17,34.9 109.37,35.11 109.59,35.11 109.81,34.89 109.81,34.68 109.6,34.47 109.6,34.26 109.82,34.04 110.03,34.04 110.24,34.25 110.45,34.25 110.67,34.03 110.67,33.82 110.46,33.61 110.46,33.39 110.67,33.19 110.88,33.19 111.12,33.42 111.33,33.42 111.55,33.2 111.55,32.99 111.31,32.76 111.31,32.54 111.53,32.32 111.75,32.32 111.98,32.56 112.19,32.56 112.41,32.34 112.41,32.13 112.18,31.89 112.18,31.68 112.43,31.43 138.13,31.43 145.22,24.35 145.22,20.08 v2(145.84,19.46)
  BOTTOM w0.076: UC1.AJ7 v2(100.49,57.41)
  BOTTOM w0.168: JDIMM2.143 144.72,20.57 v2(145.84,19.46)
DDR_DRAMRST#: length 90
  TOP w0.102: v2(135.36,12.85) v1(135.95,12.85) 135.95,13.91 CD61.1
  TOP w0.107: RD12.1 54.03,13.68 54.87,13.68 CD29.1 54.89,13.21 v2(55.32,12.78)
  IN3 w0.102: v2(135.36,12.85) 134.19,11.68 110.59,11.68 109.44,12.83 106.66,12.83 105.69,13.79 105.49,13.99 99.85,13.99 99.32,14.53 94.46,14.53 93.93,13.99 88.19,13.99 87.58,13.38 84.14,13.38 82.5,11.73 65.77,11.73 65.47,12.04 62.76,12.04 62.48,12.32 55.78,12.32 v2(55.32,12.78)
  BOTTOM w0.107: JDIMM1.108 54.97,13.13 v2(55.32,12.78) ; JDIMM2.108 135.97,13.27 135.56,12.85 v2(135.36,12.85)
DDR_RCOMP0: length 10.4
  TOP w0.381: v2(121.31,46.37) 121.55,46.13 RC5.2
  BOTTOM w0.254: UC1.G1 117.47,53.18 118.94,51.7
  BOTTOM w0.381: 118.94,51.7 119.79,50.85 120.69,50.85 122.17,49.38 v1(122.17,49.28) 122.17,48.07 121.45,47.34 121.45,46.51 v2(121.31,46.37)
DDR_RCOMP1: length 8.9
  TOP w0.381: v2(120.48,47.19) 120.75,47.46 RC6.2
  BOTTOM w0.254: UC1.H1 116.54,52.92 116.58,52.88 117.14,52.32 118.03,51.43 118.03,51.05
  BOTTOM w0.381: v2(120.48,47.19) 120.53,47.25 120.53,48.02 119.81,48.74 119.15,48.74 v1(118.72,49.17) 118.03,49.86 118.03,51.05
DDR_RCOMP2: length 11.7
  TOP w0.381: RC7.2 120.44,48.79 119.85,48.2 119.85,47.32 v2(119.9,47.27)
  BOTTOM w0.254: UC1.J2 115.96,53.55 115.96,53.02 116.34,52.64 116.8,52.18 116.8,52.13 117.57,51.37 117.57,51.05 116.89,50.37
  BOTTOM w0.381: 116.89,50.37 v1(116.89,49.22) 116.89,49.1 118.08,47.9 119.33,47.9 119.85,47.38 119.85,47.32 v2(119.9,47.27)
DDR_VTT_CTRL: length 13.7
  BOTTOM w0.102: UC1.BT13 78.79,61.2 v1(76.16,58.58) 75.65,58.06 70.46,58.06 69,59.52 UD1.2
DDR_XDP_WAN_SMBCLK: length 322.8
  TOP w0.107: v2(252.07,4.72) 251.8,4.46 251.8,4.3 251.91,4.19 257.42,4.19 259.52,2.09 265.92,2.09 268.59,4.77 270.59,4.77 270.77,4.58 LGA1.1 ; v2(217.6,4.62) 217.59,4.63 217.59,6.08 218.06,6.54 218.06,7.03 218.64,7.61 RH333.1 218.64,9.13 218.44,9.33 QH4.1 ; v2(44.75,42.19) 45.67,41.27 JXDP1.53
  IN3 w0.102: v2(44.75,42.19) 44.75,42.11 44.29,41.66 43.25,41.66 39.44,37.85 37.72,37.85 35.96,36.09 35.96,34.37 33.45,31.85 30.78,31.85 25.98,27.05 25.98,15.01 26.64,14.35 82.19,14.35 82.52,14.68 87.04,14.68 87.65,15.29 92.99,15.29 93.44,15.74 93.44,16.89 93.8,17.25 94.31,17.25 v2(94.61,17.55) 95.02,17.14 98.6,17.14 100.43,15.32 106.04,15.32 107.23,14.12 111.73,14.12 112.14,13.72 134.01,13.72 134.72,14.43 169.34,14.43 169.46,14.55 173.94,14.55 174.96,15.58 174.96,16.35 175.36,16.75 v2(175.92,16.75) 178.98,16.75 181.71,19.48 188.88,19.48 195.56,12.8 196.25,12.8 198.73,10.32 201.77,10.32 204.72,7.38 215.31,7.38 217.55,5.13 217.55,4.67 v2(217.6,4.62) 217.6,4.49 217.69,4.41 219.49,4.41 221.22,6.13 223.78,6.13 225.55,4.37 239.55,4.37 241.08,5.9 251.33,5.9 251.82,5.41 251.82,4.96 v2(252.07,4.72)
  BOTTOM w0.107: JDIMM2.253 174.22,21.51 174.91,20.82 174.91,17.77 v2(175.92,16.75) ; v2(94.61,17.55) 94.51,17.65 94.05,17.65 93.63,18.07 93.63,20.38 93.22,20.8 JDIMM1.253
DDR_XDP_WAN_SMBDAT: length 319.7
  TOP w0.107: v2(251.05,4.72) 251.32,4.46 251.32,4.1 251.71,3.71 257.22,3.71 259.32,1.61 266.12,1.61 267.6,3.08 LGA1.4 ; QH4.4 215.71,10.63 215.35,10.27 215.35,8.55 RH374.1 215.95,7.25 217.1,6.1 217.1,4.7 v2(217.02,4.62) ; JXDP1.51 45.17,40.6 44.12,41.66 v2(44.12,42.21)
  IN3 w0.102: v2(251.05,4.72) 251.34,5.01 251.34,5.21 251.13,5.42 241.28,5.42 239.75,3.89 225.35,3.89 223.58,5.65 221.42,5.65 219.7,3.92 217.49,3.92 217.02,4.39 v2(217.02,4.62) 217.07,4.67 217.07,4.93 215.11,6.89 204.52,6.89 201.57,9.84 198.53,9.84 196.05,12.32 195.36,12.32 188.68,19 181.91,19 179.18,16.27 176.06,16.27 v2(175.92,16.13) 175.77,16.27 175.56,16.27 175.45,16.15 175.45,15.38 174.14,14.07 169.67,14.07 169.54,13.94 134.92,13.94 134.21,13.23 111.94,13.23 111.53,13.64 107.03,13.64 105.84,14.83 100.23,14.83 98.4,16.66 94.74,16.66 v2(94.64,16.76) 94,16.76 93.93,16.69 93.93,15.54 93.19,14.81 87.85,14.81 87.24,14.19 82.72,14.19 82.39,13.87 26.44,13.87 25.5,14.81 25.5,27.25 30.58,32.33 33.25,32.33 35.48,34.57 35.48,36.29 37.52,38.33 39.24,38.33 43.13,42.21 v2(44.12,42.21)
  BOTTOM w0.107: JDIMM1.254 93.47,15.09 93.85,15.46 93.85,15.98 v2(94.64,16.76) ; v2(175.92,16.13) 174.8,16.13 174.64,15.97 174.64,15.18 174.47,15.01 JDIMM2.254
DEBUG_TX: length 5.1
  BOTTOM w0.102: JDEG1.9 v1(333.9,12.95) 333.9,12.31 332.6,11 RE30.2 RE74.2
DEW1: length 6.1
  BOTTOM w0.102: UN7.16 249.64,14.16 RN17.2 251.42,12.94 251.89,12.47 v1(251.89,11.8) 251.89,11.3 251.24,10.66 RN16.2
DEW2: length 5.5
  BOTTOM w0.102: UN7.6 247.64,19.27 247.32,19.6 RN15.2 247.87,20.83 247.87,22.2 247.52,22.55 RN14.2 v1(246.29,22.55)
DGPU_HOLD_RST#: length 1.1
  TOP w0.089: T37.1 212.84,35.21 v2(213.19,34.85)
  BOTTOM w0.089: UH1.BB20 212.98,34.64 v2(213.19,34.85)
DGPU_PWR_EN: length 1.1
  TOP w0.089: T38.1 208.38,35.59 v2(208.64,35.59)
  BOTTOM w0.089: UH1.AN18 208.47,35.42 v2(208.64,35.59)
DGPU_PWROK: length 37.2
  TOP w0.102: RE525.1 319.71,52.84 v1(319.71,54.14) v2(319.71,55.46)
  TOP w0.107: UE1.M4 v2(315.72,31.15)
  IN1 w0.099: v2(325.71,45.31) 325.71,44.15 324.71,43.15 323.54,43.15 322.01,41.62 321.8,41.62 321.28,41.1 321.28,40.89 320.68,40.28 319.64,40.28 318.83,39.48 318.83,38.98 318.53,38.68 318.53,36.62 316.94,35.03 316.94,32.63 316.64,32.33 316.36,32.33 316.14,32.11 316.14,31.64 315.72,31.22 v2(315.72,31.15)
  BOTTOM w0.107: v2(325.71,45.31) 325.83,45.43 325.83,49.7 324.36,51.18 322.09,51.18 320.53,52.74 320.53,54.63 v2(319.71,55.46)
DIFFOUT_2PH: length 9
  TOP w0.102: v1(60.07,71.16) 60.07,72.52 PR1738.1
  TOP w0.203: PU1700.35 58.13,75.35 PR1739.2 59.55,73.08 PR1738.1
DIFFOUT_4PH: length 5
  TOP w0.203: PU1700.4 58.53,86.75 58.81,87.03 v1(59.57,87.03) 59.67,87.13 59.67,87.67 PR1734.2 PC1715.2
DIMM1_SA0: length 7.4
  TOP w0.102: RD4.2 RD5.1 96.9,15.47 v2(97.05,15.62) 97.05,16.08 v1(96.85,16.28)
  BOTTOM w0.102: v2(97.05,15.62) 96.64,16.03 94.59,16.03 94.19,15.63 94.19,15.3 93.98,15.09 93.98,14.11 JDIMM1.256
DIMM1_SA1: length 6.7
  TOP w0.102: RD6.2 RD7.1 97.76,15.05 97.84,15.14 97.84,15.64 v2(97.97,15.76) 97.97,15.99 v1(98.2,16.22)
  BOTTOM w0.102: v2(97.97,15.76) 97.34,15.13 96.8,15.13 96.78,15.1 95.11,15.1 94.97,14.97 JDIMM1.260
DIMM1_SA2: length 3.9
  TOP w0.102: v2(71.72,12.81) 71.72,12.44 v1(71.85,12.31)
  TOP w0.104: v2(71.72,12.81) 72.09,13.18 RD9.1 RD8.2
  BOTTOM w0.127: JDIMM1.166 71.47,13.36 71.72,13.11 v2(71.72,12.81)
DIMM2_SA0: length 11.5
  TOP w0.102: RD20.2 177.82,16.15 178.05,16.38 178.05,16.99 v2(178.23,17.17) 178.41,16.99 178.41,16.31 178.69,16.03 RD21.1 178.98,16.03 v1(179.97,15.04)
  BOTTOM w0.102: JDIMM2.256 174.97,13.3 175.24,13.03 176.07,13.03 176.36,13.31 176.36,14.64 177.06,15.34 177.06,16 v2(178.23,17.17)
DIMM2_SA1: length 7.5
  TOP w0.102: RD23.1 178.8,17.08 178.8,17.94 v1(178.71,18.03) 178.46,18.03 v2(178.23,17.8) 177.59,17.17 RD22.2
  BOTTOM w0.102: JDIMM2.260 175.97,14.91 176.7,15.65 176.7,16.41 178.1,17.8 v2(178.23,17.8)
DIMM2_SA2: length 4.2
  TOP w0.102: v2(152.78,12.64) 152.91,12.64 v1(153.25,12.31)
  TOP w0.508: v2(152.78,12.64) 152.91,12.77 RD24.2 152.94,13.65 RD25.1
  BOTTOM w0.102: v2(152.78,12.64) 152.47,12.95 JDIMM2.166
DISP_ON: length 32.5
  BOTTOM w0.102: DV2.1 131.23,92.67 126.99,96.91 120.63,96.91 117.92,99.62 114.58,99.62 114.35,99.85 v1(113.83,99.85) 111.63,99.85 111.17,100.3 111.17,101.24 111.44,101.51 RV2.1 112.5,102.35 112.5,104.18 113.15,104.82 113.15,106.42 JEDP1.22
DMI_CRX_PTX_N0: length 93.4
  IN3 w0.102: v2(118.71,57.89) 118.71,58.55 119.07,58.91 120.13,58.91 121.45,60.24 134.02,60.24 158.09,36.16 182.9,36.16 186.29,32.76 186.29,32.36 v2(186.36,32.29)
  BOTTOM w0.089: 188,28.03 188.02,28.03 188.03,28.03 190.96,28.03 191.54,28.6 192.72,28.6 193.16,28.16 193.47,28.16 193.68,27.94 193.68,27.77 UH1.C33
  BOTTOM w0.094: UC1.E8 118.71,57.82 v2(118.71,57.89)
  BOTTOM w0.097: v2(186.36,32.29) 186.07,32.01 186.07,30.42 186.37,30.12 186.37,28.97 187.31,28.03 188,28.03
DMI_CRX_PTX_N1: length 90.8
  IN3 w0.102: v2(118.04,57.1) 118.23,56.91 118.48,56.91 118.69,57.12 120.48,57.12 121.33,57.97 123.59,57.97 124.19,58.56 133.92,58.56 158.65,33.84 181.24,33.84 183.89,31.18 186.81,31.18 187.04,30.95 187.04,30.77 v2(187.24,30.56)
  BOTTOM w0.076: UC1.F6 117.71,56.77 v2(118.04,57.1)
  BOTTOM w0.089: 188,28.99 188.02,28.99 188.03,28.98 193.17,28.98 193.33,28.82 193.58,28.82 193.6,28.83 193.66,28.83 193.82,28.67 193.82,28.47 UH1.C32
  BOTTOM w0.097: v2(187.24,30.56) 186.96,30.27 186.96,29.73 187.7,28.99 188,28.99
DMI_CRX_PTX_N2: length 90.1
  IN3 w0.102: v2(188.44,30.58) 188.44,29.99 188.21,29.76 186.15,29.76 185.63,30.29 182.17,30.29 179.94,32.51 158.78,32.51 133.57,57.72 124.54,57.72 123.83,57.01 122.76,57.01 121.87,56.12 120.58,56.12 120.13,55.66 118.97,55.66 v2(118.78,55.47)
  BOTTOM w0.089: v2(188.44,30.58) 188.44,30.08 189.06,29.45 189.19,29.45 189.2,29.46 193.56,29.46 193.75,29.26 193.75,29.17 UH1.C31
  BOTTOM w0.094: v2(118.78,55.47) 118.78,55.52 UC1.E5
DMI_CRX_PTX_N3: length 96.1
  IN3 w0.076: v2(116.7,58.71) 116.93,58.47 116.98,58.47 117.3,58.14 117.46,58.14 117.54,58.23 117.54,58.27 117.56,58.28
  IN3 w0.102: 117.56,58.28 119.69,60.41 120.32,60.41 121.4,61.49 131.46,61.49 132.39,62.42 134.54,62.42 138.31,58.65 138.31,56.82 158.35,36.79 184.33,36.79 187.55,33.57 187.55,33.12 187.33,32.89 187.12,32.89 v2(186.92,32.69)
  BOTTOM w0.089: UH1.C29 193.76,29.88 193.27,29.65 190.92,29.65 189.43,31.14 189.29,31.14
  BOTTOM w0.097: UC1.J9 116.61,58.71 v2(116.7,58.71) ; v2(186.92,32.69) 187.01,32.69 187.14,32.55 187.14,32.39 187.17,32.36 187.17,32.36 187.61,31.92 187.61,31.67 188.15,31.13 189.28,31.13 189.29,31.14
DMI_CRX_PTX_P0: length 93.4
  IN3 w0.102: v2(185.77,32.29) 185.78,32.29 186.07,32.59 186.07,32.67 182.8,35.94 158,35.94 133.93,60.02 121.54,60.02 120.22,58.7 119.17,58.7 118.93,58.46 118.93,58.34 118.97,58.29 119.4,58.29 119.5,58.19 119.5,58.03 v2(119.36,57.89)
  BOTTOM w0.089: 188,27.85 188.02,27.85 188.03,27.85 191.04,27.85 191.61,28.42 192.65,28.42 193.09,27.98 193.39,27.98 193.5,27.87 193.5,27.78 193.44,27.72 UH1.B33
  BOTTOM w0.094: v2(119.36,57.89) 119.36,57.82 UC1.D8
  BOTTOM w0.097: v2(185.77,32.29) 185.89,32.18 185.89,30.34 186.18,30.05 186.18,28.9 187.23,27.85 188,27.85
DMI_CRX_PTX_P1: length 90.8
  IN3 w0.102: v2(186.66,30.56) 186.82,30.72 186.82,30.86 186.72,30.96 183.8,30.96 181.15,33.62 158.56,33.62 133.83,58.34 124.28,58.34 123.68,57.75 121.42,57.75 120.57,56.9 118.78,56.9 118.57,56.69 118.08,56.69 118,56.62 v2(118,56.33)
  BOTTOM w0.076: v2(118,56.33) 118.38,56.71 UC1.E6
  BOTTOM w0.089: 188,28.8 188.02,28.8 188.03,28.8 193.1,28.8 193.26,28.64 193.58,28.64 193.63,28.59 193.63,28.47 193.56,28.4 UH1.B32
  BOTTOM w0.097: v2(186.66,30.56) 186.78,30.44 186.78,29.65 187.63,28.8 188,28.8
DMI_CRX_PTX_P2: length 90
  IN3 w0.102: v2(118.73,56.29) 118.73,56.14 119,55.88 120.04,55.88 120.49,56.33 121.77,56.33 122.67,57.23 123.74,57.23 124.45,57.94 133.66,57.94 158.87,32.73 180.03,32.73 182.26,30.5 185.72,30.5 186.24,29.98 188.12,29.98 188.22,30.08 188.22,30.23 187.86,30.58 v2(187.85,30.58)
  BOTTOM w0.089: 188,30.44 188.06,30.38 188.1,30.38 188.26,30.21 188.26,30 188.99,29.27 189.19,29.27 189.2,29.27 192.71,29.27 193.48,29.27 193.56,29.18 193.56,29.1 193.52,29.06 UH1.B31
  BOTTOM w0.094: UC1.D5 118.94,55.92 118.73,56.12 v2(118.73,56.29)
  BOTTOM w0.097: 188,30.44 v2(187.85,30.58)
DMI_CRX_PTX_P3: length 96.1
  IN3 w0.076: v2(116.76,57.89) 116.56,57.89 116.48,57.97 116.48,58.22 116.56,58.31 116.91,58.31 117.23,57.98 117.53,57.98 117.66,58.11 117.68,58.11
  IN3 w0.102: 117.68,58.11 117.7,58.11 119.78,60.19 120.41,60.19 121.49,61.27 131.55,61.27 132.48,62.2 134.45,62.2 138.1,58.56 138.1,56.73 158.25,36.57 184.24,36.57 187.33,33.48 187.33,33.21 187.24,33.11 187.08,33.11 v2(186.92,33.27)
  BOTTOM w0.076: v2(116.76,57.89) 116.44,57.89 UC1.J8
  BOTTOM w0.089: UH1.B29 193.18,29.83 190.99,29.83 189.51,31.32 189.37,31.32 189.36,31.32 189.23,31.32 189.23,31.32 189.21,31.32
  BOTTOM w0.097: 189.21,31.32 188.22,31.32 187.79,31.75 187.79,32 187.33,32.46 187.33,32.86 187.27,32.92 187.27,33.23 187.17,33.32 186.97,33.32 v2(186.92,33.27)
DMI_CTX_PRX_N0: length 98.2
  IN3 w0.089: v2(197.36,26.58) 197.24,26.32 197.28,26.2 197.28,25.97 197.09,25.78 196.65,25.78 196.26,26.17 196.26,26.63 197.03,27.4 197.33,27.4 197.78,27.85 197.78,30.7 197.43,31.05 193.26,31.05 193.24,31.03 193.15,31.03
  IN3 w0.102: v2(122.82,58.4) 122.77,58.4 122.63,58.54 122.63,58.87 122.73,58.97 134.09,58.97 157.81,35.25 181.6,35.25 185.25,31.61 187.61,31.61 188.19,31.03 193.15,31.03
  BOTTOM w0.094: v2(197.36,26.58) 197.36,26.59 UH1.K34
  BOTTOM w0.097: v2(122.82,58.4) 122.6,58.19 122.6,57.99 122.42,57.8 120.83,57.8 120.74,57.71 120.74,57.58 120.83,57.49 UC1.A8
DMI_CTX_PRX_N1: length 94.9
  IN3 w0.089: v2(196.16,27.44) 196.01,27.29 196.01,26.68 195.71,26.38 195.37,26.38 195.35,26.41 194.87,26.41 194.56,26.72 193.19,26.72 193.17,26.7 193.15,26.7
  IN3 w0.102: v2(125.96,53.68) 125.96,52.92 126.82,52.07 127.4,52.07 134.87,44.6 143.18,44.6 158.54,29.23 176.89,29.23 179.98,26.15 182.34,26.15 182.98,26.78 185.77,26.78 186.46,27.46 188.58,27.46 189.34,26.7 193.15,26.7
  BOTTOM w0.076: UC1.B6 120.33,56.65 120.26,56.57 120.1,56.57 120.02,56.65 120.02,56.83 120.23,57.03 121.22,57.03 121.37,57.18 121.43,57.18
  BOTTOM w0.094: UH1.G33 195.95,27.66 v2(196.16,27.44)
  BOTTOM w0.097: v2(125.96,53.68) 126.29,54.01 126.29,56.85 125.95,57.18 121.43,57.18
DMI_CTX_PRX_N2: length 92.2
  IN3 w0.089: 193.15,30.15 193.17,30.15 193.19,30.13 194.95,30.13 195.07,30.25 196.39,30.25 197.2,29.44 197.2,28.65 197,28.45 197,28.26 197.03,28.17 v2(197.4,27.98)
  IN3 w0.102: 193.15,30.15 192.26,30.15 191.46,29.36 185.89,29.36 185.48,29.77 182.11,29.77 179.77,32.11 157.75,32.11 143.79,46.07 135.93,46.07 125.81,56.19 125.02,56.19 124.92,56.29 124.92,56.4 v2(125.12,56.61)
  BOTTOM w0.076: 121.57,56.13 121.56,56.13 121.55,56.14 121.5,56.14 121.5,56.14 121.27,56.14 121.16,56.26 120.8,56.26 120.74,56.19 120.74,56.02 120.81,55.95 UC1.A5
  BOTTOM w0.094: v2(197.4,27.98) UH1.K32
  BOTTOM w0.097: v2(125.12,56.61) 124.9,56.38 124.9,56.18 124.7,55.98 123.71,55.98 123.55,56.13 121.57,56.13
DMI_CTX_PRX_N3: length 93.4
  IN3 w0.089: 193.15,27.56 193.17,27.56 193.19,27.54 193.38,27.54 193.7,27.86 193.7,29.05 194.01,29.37 195.4,29.37 v2(195.92,28.84)
  IN3 w0.102: v2(124.57,53.71) 124.68,53.82 124.68,54.2 124.92,54.45 126.67,54.45 135.67,45.45 143.53,45.45 158.89,30.08 177.24,30.08 179.68,27.64 185.3,27.64 185.97,28.31 188.93,28.31 189.67,27.56 193.15,27.56
  BOTTOM w0.076: UC1.B4 119.86,55.21 119.78,55.13 119.78,54.98 119.87,54.89 120.28,54.89 120.38,54.99 120.38,55.36 120.5,55.48 121.25,55.48 121.68,55.05 121.68,55.04 121.69,55.02 121.69,55.02
  BOTTOM w0.094: v2(195.92,28.84) UH1.G30
  BOTTOM w0.097: 121.69,55.02 122,54.72 122,54.41 122.59,53.81 123.75,53.81 124.13,54.18 124.75,54.18 124.84,54.09 124.84,53.97 124.58,53.71 v2(124.57,53.71)
DMI_CTX_PRX_P0: length 98.2
  IN3 w0.089: 193.15,31.25 193.17,31.25 193.19,31.22 197.51,31.22 197.96,30.78 197.96,27.77 197.41,27.22 197.11,27.22 196.44,26.56 196.44,26.25 196.73,25.96 197.02,25.96 197.11,26.05 197.11,26.17 197.07,26.26 v2(196.81,26.38)
  IN3 w0.102: v2(122.18,58.4) 122.41,58.63 122.41,58.96 122.64,59.19 134.18,59.19 157.9,35.47 181.69,35.47 185.34,31.83 187.7,31.83 188.28,31.25 193.15,31.25
  BOTTOM w0.076: 122.2,58.38 v2(122.18,58.4)
  BOTTOM w0.094: v2(196.81,26.38) 196.63,26.57 UH1.J35
  BOTTOM w0.097: UC1.B8 120.45,57.49 120.55,57.6 120.55,57.79 120.75,57.99 122.34,57.99 122.42,58.07 122.42,58.17 122.2,58.38
DMI_CTX_PRX_P1: length 94.9
  IN3 w0.089: v2(195.44,27.06) 195.44,27.29 195.54,27.39 195.67,27.39 195.83,27.23 195.83,26.76 195.64,26.56 195.44,26.56 195.42,26.58 194.94,26.58 194.63,26.9 193.19,26.9 193.17,26.92 193.15,26.92
  IN3 w0.102: 193.15,26.92 189.43,26.92 188.67,27.68 186.37,27.68 185.68,27 182.89,27 182.25,26.36 180.07,26.36 176.99,29.45 158.63,29.45 143.27,44.82 134.96,44.82 127.49,52.29 126.91,52.29 126.18,53.01 126.18,53.32 v2(126.55,53.68)
  BOTTOM w0.076: 121.43,57.37 121.33,57.37 121.15,57.2 120.16,57.2 119.84,56.88 119.84,56.86 UC1.C6
  BOTTOM w0.094: v2(195.44,27.06) 195.44,27.11 195.28,27.26 UH1.F34
  BOTTOM w0.097: 121.43,57.37 126.03,57.37 126.47,56.92 126.47,53.76 v2(126.55,53.68)
DMI_CTX_PRX_P2: length 92.4
  IN3 w0.089: v2(196.67,27.74) 196.86,28.12 196.82,28.24 196.82,28.52 197.02,28.73 197.02,29.36 196.31,30.07 195.14,30.07 195.02,29.95 193.19,29.95 193.17,29.93 193.15,29.93
  IN3 w0.102: 193.15,29.93 192.35,29.93 191.56,29.14 185.8,29.14 185.39,29.55 182.02,29.55 179.68,31.89 157.66,31.89 143.69,45.85 135.84,45.85 125.72,55.97 124.93,55.97 124.7,56.2 124.7,56.4 v2(124.49,56.61)
  BOTTOM w0.076: UC1.B5 120.5,55.92 120.57,55.99 120.57,56.26 120.73,56.42 121.23,56.42 121.34,56.31 121.56,56.31 121.57,56.32
  BOTTOM w0.094: v2(196.67,27.74) UH1.J32
  BOTTOM w0.097: 121.57,56.32 123.63,56.32 123.78,56.16 124.62,56.16 124.71,56.25 124.71,56.38 v2(124.49,56.61)
DMI_CTX_PRX_P3: length 93.3
  IN3 w0.089: v2(195.18,28.65) 195.27,28.56 195.41,28.56 195.56,28.71 195.56,28.95 195.32,29.19 194.08,29.19 193.87,28.98 193.87,27.79 193.45,27.36 193.19,27.36 193.17,27.34 193.15,27.34
  IN3 w0.102: v2(125.15,53.71) 124.89,53.96 124.89,54.11 125.01,54.23 126.58,54.23 135.58,45.23 143.44,45.23 158.8,29.86 177.15,29.86 179.59,27.42 185.39,27.42 186.06,28.09 188.83,28.09 189.58,27.34 193.15,27.34
  BOTTOM w0.076: UC1.D4 119.84,55.58 120.36,55.58 120.43,55.64 121.32,55.64 121.79,55.17 121.81,55.17 121.82,55.15
  BOTTOM w0.094: v2(195.18,28.65) UH1.F30
  BOTTOM w0.097: 121.82,55.15 122.18,54.79 122.18,54.48 122.67,53.99 123.68,53.99 124.05,54.37 124.82,54.37 125.03,54.16 125.03,53.83 v2(125.15,53.71)
DMIC0: length 267.7
  TOP w0.102: v2(338.88,29.87) 338.77,29.99 338.77,31.15 338.99,31.37 RA52.2 340.05,32.2 340.05,33.24 339.52,33.77 UA1.2
  IN1 w0.099: v2(301.9,32.83) 301.9,32.72 301.44,32.27 298.38,32.27 297.61,31.5 287.8,31.5 287.24,30.94 285.29,30.94 281.28,34.95 281.28,35.36 279.5,37.15 278.06,37.15 277.59,36.68 271.95,36.68 271.93,36.7 269.28,36.7 268.1,37.89 265.07,37.89 264.74,37.55 262.63,37.55 262.22,37.15 254.99,37.15 247.12,39.44 245.25,39.44 244.42,40.27 244.42,40.78 v2(244.64,41)
  IN3 w0.102: v2(244.64,41) 244.19,41.45 240.27,41.45 235.38,46.34 234.56,46.34 223.46,57.44 212.98,57.44 211.86,58.56 198.38,58.56 157.75,99.19 157.04,99.19 156.26,99.96 v2(156.26,100.8) ; v2(327.45,23.68) 327.54,23.6 332.08,23.6 334.59,26.11 334.59,27.53 337.03,29.97 338.78,29.97 v2(338.88,29.87)
  BOTTOM w0.102: v2(301.9,32.83) 302.38,32.83 302.82,32.4 304.26,32.4 304.66,32.79 306.82,32.79 307.61,32 307.61,30.62 308.61,29.62 313.82,29.62 314.3,29.14 317.08,29.14 317.72,28.5 321.06,28.5 321.09,28.48 322.01,28.48 323.24,27.25 323.24,26.59 324.68,25.15 326.02,25.15 327.31,23.85 327.31,23.82 v2(327.45,23.68) ; v2(156.26,100.8) 156.21,100.74 141.09,100.74 140.95,100.61 125.74,100.61 124.8,101.55 124.8,101.89 123.3,103.39 122.99,103.39 CA6.1 122.79,103.42 120.65,105.56 120.65,106.43 JEDP1.7
DMIC_CLK0: length 265.1
  TOP w0.107: RA14.1 340.18,29.99 340.66,29.51 CA54.1 340.3,29.06 v2(339.7,28.46)
  IN1 w0.099: v2(287.07,31.35) 287.07,31.63 283.66,35.04 282.62,35.04 281.12,36.54 281.12,37.27 280.24,38.14 278.2,38.14 277.36,37.31 269.53,37.31 268.35,38.49 264.82,38.49 264.49,38.16 262.37,38.16 261.97,37.76 255.08,37.76 247.2,40.05 245.61,40.05 245.19,40.47 v2(245.19,40.73)
  IN3 w0.102: v2(287.07,31.35) 287.34,31.08 288.29,31.08 288.82,30.54 291.69,30.54 291.71,30.52 297.77,30.52 298.68,29.61 298.68,29.2 304.04,23.84 309.56,23.84 310.25,23.16 315.63,23.16 317.43,21.35 332.32,21.35 338.63,27.66 338.9,27.66 v2(339.7,28.46) ; v2(156.68,100.22) 156.87,100.22 157.21,100.55 157.35,100.55 198.74,59.16 212.11,59.16 213.23,58.05 223.85,58.05 234.95,46.95 235.81,46.95 240.7,42.06 244.59,42.06 245.19,41.46 v2(245.19,40.73)
  BOTTOM w0.107: JEDP1.9 119.65,106.42 119.65,105.23 119.86,105.02 120.76,105.02 121.7,104.08 CA5.1 121.85,103.42 122.33,102.94 122.33,102.15 122.81,101.67 123.7,101.67 125.37,100 146.26,100 146.39,100.13 156.59,100.13 v2(156.68,100.22)
DMIC_CLK_CODEC: length 3.5
  TOP w0.102: UA1.3 339.92,33.82 340.26,33.48 340.26,31.45 RA14.2
DP2_AUXN_SBU2: length 4.1
  BOTTOM w0.076: UT5.L8 33.88,91.8 34.17,92.09 34.17,92.37 34.34,92.54
  BOTTOM w0.089: RT109.1 35.04,93.81 35.04,93.24 34.56,92.76 34.34,92.54
DP2_AUXP_SBU1: length 4.7
  BOTTOM w0.076: 34.42,92.37 34.34,92.29 34.34,92.02 34.05,91.73 34.05,90.88 34.12,90.81 34.12,90.43 UT5.K8
  BOTTOM w0.089: 35.26,93.37 35.26,93.21 34.42,92.37
  BOTTOM w0.102: 35.26,93.37 35.26,93.78 RT108.1
DP2_MIC_SBU1: length 53.7
  TOP w0.089: v2(13.29,111.95) 13.51,111.73 13.51,110.9 13.83,110.58 13.83,106.9 16.29,104.44 16.29,103.21 17.6,101.91 17.92,101.91 v2(18.22,101.61)
  IN1 w0.089: v2(31.99,98.64) 31.9,98.73 29.13,98.73 28.44,99.42 25.98,99.42 25.71,99.69 21.37,99.69 19.78,101.28 19,101.28 18.4,100.67 17.7,100.67 17.38,100.99 17.38,101.65 17.71,101.97 17.86,101.97 v2(18.22,101.61)
  IN3 w0.089: v2(12.17,115.56) 12.08,115.47 12.02,115.47 11.76,115.2 11.76,114.64 11.64,114.53 10.82,114.53 10.18,113.9 8.62,113.9 8.56,113.96 v2(8.56,114.45) ; v2(13.29,111.95) 13.48,112.14 13.48,114.21 14.49,115.22 14.49,115.62 14.3,115.81 v2(14.3,115.82)
  BOTTOM w0.089: RT132.2 20.28,104.47 20.05,104.24 20.05,102.64 19.01,101.61 v2(18.22,101.61) ; RT108.2 35.33,95.33 35.33,95.55 33.63,97.25 33.29,97.25 32.39,98.14 32.39,98.23 v2(31.99,98.64) ; v2(8.56,114.45) 8.43,114.45 8.26,114.63 JUSBC1.A8 ; v2(14.3,115.82) 14.5,115.62 14.5,115.21 14.44,115.15 14.29,115.15 14.14,115.31 DT39.6 DT39.5 12.46,115.31 12.3,115.47 12.26,115.47 12.17,115.56 v2(12.17,115.56)
DP2_MIC_SBU2: length 54.7
  TOP w0.089: v2(13.88,111.95) 13.7,111.77 13.7,110.98 14.02,110.66 14.02,106.98 16.48,104.52 16.48,103.29 17.67,102.09 18.12,102.09 v2(18.22,102.19)
  IN1 w0.089: v2(31.99,98.06) 31.52,98.52 29.04,98.52 28.36,99.21 25.89,99.21 25.62,99.48 21.28,99.48 19.69,101.07 19.09,101.07 18.48,100.46 17.61,100.46 17.17,100.9 17.17,101.73 17.62,102.18 18.21,102.18 v2(18.22,102.19)
  IN3 w0.089: v2(13.88,111.95) 13.69,112.14 13.69,114.13 14.7,115.14 14.7,115.62 v2(14.89,115.81) ; v2(6.9,112.8) 7.07,112.8 7.96,113.69 10.27,113.69 10.91,114.32 11.73,114.32 12.17,114.77 12.17,114.95 12.19,114.96 v2(12.19,114.97)
  BOTTOM w0.089: v2(6.9,112.8) 6.83,112.88 JUSBC1.B8 ; v2(18.22,102.19) 18.62,101.79 18.94,101.79 19.85,102.71 19.85,104.03 RT133.2 ; v2(14.89,115.81) 14.69,115.61 14.69,115.14 14.52,114.96 14.28,114.96 14.12,114.81 DT39.7 DT39.4 12.39,114.81 12.23,114.97 v2(12.19,114.97) ; RT109.2 34.77,95.05 35.13,95.4 35.13,95.49 33.55,97.06 33.21,97.06 32.22,98.06 v2(31.99,98.06)
