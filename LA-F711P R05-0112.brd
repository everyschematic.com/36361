# Allegro board LA-F711P R05-0112.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+VCC_SA: length 11.6
  BOTTOM w0.254: UC1.K31 115.16,75.25 v2(114.84,75.57) ; v2(114.84,75.57) 114.52,75.25 UC1.L31 ; v2(114.84,75.57) 114.51,75.9 UC1.L32 ; v2(114.84,76.22) 115.16,75.9 UC1.K32 ; UC1.M29 UC1.M30 UC1.M31 113.73,75.25 v2(114.05,75.57) 113.72,75.9 UC1.M32 ; v2(114.05,78.17) 113.73,77.85 UC1.M35 ; v2(114.05,78.17) 114.37,77.85 UC1.L35 ; v2(114.05,78.17) 113.72,78.5 UC1.M36 ; UC1.M33 113.73,76.55 v2(114.05,76.87) 113.72,77.2 UC1.M34 ; v2(114.07,79.5) 114.37,79.8 UC1.L38 ; UC1.L37 114.35,79.15 v2(114.05,78.85) 114.4,78.5 UC1.L36 ; UC1.K33 115.3,76.62 115.3,77.13 UC1.K34 115.2,77.2 v2(114.87,77.53) 115.19,77.85 UC1.K35 ; UC1.K30 UC1.K29 ; UC1.J30 v2(115.82,74.77)
  vias: v2(111.65,88.59) v2(111.65,87.96) v2(111.67,87.36) v2(112.31,88.8) v2(112.31,88.16) v2(112.31,87.53) v2(112.44,86.89) v2(112.44,86.13) v2(113.2,86.89) v2(113.2,86.13) v2(113.97,86.89) v2(113.97,86.13) v2(114.73,86.89) v2(114.73,86.13) v2(115.49,86.89) v2(116.12,89.18) v2(116.12,88.54) v2(116.12,87.91) v2(116.76,89.18) v2(116.76,88.54) v3(114.73,84.62)
+VCC_SFR_OC: length 48.6
  TOP w0.254: v2(84.91,60.83) 85.31,61.23 v2(85.85,61.23)
  IN3 w0.254: 115.03,60.99 115.57,60.45 115.57,60.22 115.58,60.21 115.58,60.08 115.83,59.83 116.31,59.83 116.68,59.46 v2(116.76,59.46)
  IN3 w0.61: v2(74.06,61.49) 74.44,61.49 75.15,62.21 77.93,62.21 78.79,63.07 81.89,63.07 83.31,61.65 85.25,61.65 85.64,61.25 85.83,61.25 v2(85.85,61.23) 85.87,61.25 85.87,61.26 85.89,61.24 85.89,61.21 86.1,61.42 99.58,61.42 99.67,61.33 102.73,61.33 103.07,60.99 115.03,60.99
  BOTTOM w0.076: v2(85.85,61.23) 85.85,61.23 85.61,60.99 UC1.BH13 ; UC1.BJ13 84.77,61.26 84.77,60.97 v2(84.91,60.83)
  BOTTOM w0.254: UC1.BH13 85.06,60.99 v2(84.91,60.83)
  BOTTOM w0.305: v2(116.76,59.46) 117.08,59.8 UC1.G11
  vias: v3(73.07,61.37)
+VCCK_12: length 16.7
  TOP w0.102: v1(330.59,73.34) 330.25,73.68 v2(330.25,73.81)
  TOP w0.203: UV6.4 324.03,71.03 323.77,70.76 323.31,70.76 CV103.1 ; UV6.25 328.73,73.43 328.85,73.56 329.07,73.56 329.61,74.1 CV104.1
  TOP w0.457: CV103.1 322.82,71.34 323.01,71.53 v2(323.64,71.53)
  TOP w0.508: v2(330.25,73.81) 330.5,74.07 CV105.1 CV104.1
  IN3 w0.508: v2(323.64,71.53) 323.64,71.91 324.91,73.18 329.54,73.18 330.17,73.81 v2(330.25,73.81)
+VCCRTCEXT: length 4.7
  BOTTOM w0.254: CH68.1 218.65,20.21 216.09,20.21 215.47,20.83 UH1.BG47 UH1.BF47
+VDD_DAC_33: length 2.7
  TOP w0.203: v1(330.63,70.63) UV6.20
  TOP w0.508: v1(330.63,70.63) 331.86,70.63 LV30.2
+VDDA_AVDD1: length 1.4
  TOP w0.203: 343.74,41.96 343.12,41.35 UA1.26
  vias: v1(346.34,44.31)
+VSS_PLL: length 3.9
  TOP w0.356: UE1.G1 313.22,35.55 311.67,37.1 CE18.2 311.06,37.1 310.98,37.17 CE17.2
GND: length 4031
  TOP w0.127: v3(38.49,7.4) 37.8,7.4 v2(37.79,7.39)
  TOP w0.203: v2(333.17,21.63) 333.21,21.59 UZ5.11 ; UZ4.11 v2(286.73,6.55) ; v2(330.02,72.8) 330.02,72.44 329.81,72.23 UV6.24 ; v2(194.95,6.96) 195.03,6.88 UZ3.11
  TOP w0.254: JXDP1.19 37.17,40.75 v2(37,40.92) ; UZ12.23 248.44,27.06 248.69,26.81 249.5,26.81 v2(249.96,27.27) ; v2(270.31,36.18) 270.5,35.99 UV9.31 ; v2(34.9,41.78) 35.02,41.78 35.67,41.14 JXDP1.13 ; UZ12.32 248.94,32 v2(248.71,31.77) ; JXDP1.14 35.67,46.52 v2(35.56,46.63) ; v2(279.02,41.59) 279.02,41.39 278.12,40.49 275.33,40.49 275,40.16 UV9.18 ; JXDP1.37 41.67,41.49 41.3,41.86 v2(41.3,42.24) ; JXDP1.7 34.17,40.45 v2(33.7,40.92) ; v2(245.66,31.77) 245.44,32 UZ12.9 ; v2(45.39,36.58) 44.67,37.29 JXDP1.49 ; UE1.E6 v2(317.32,36.75) ; v2(38.58,43.43) 38.67,43.52 JXDP1.26 ; 332.61,43.66 331.54,42.6 331.54,39.33 ; v2(337.73,69.08) 337.86,69.2 UI3.14 ; v2(94.08,60.7) 94.47,61.08 PC1099.2 ; UZ29.11 v2(357.93,48.05) ; UZ29.5 v2(360.48,50.9) ; v2(34.29,46.74) 34.29,46.62 34.17,46.51 JXDP1.8 ; JXDP1.25 v2(38.67,40.78) ; v2(245.66,28.73) 245.44,28.5 UZ12.16 ; v2(116.76,60.25) 116.76,60.39 PC852.2 ; JXDP1.20 37.17,46.29 37.26,46.38 v2(37.26,46.76) ; v2(357.22,47.97) 357.17,48.02 CZ154.2 ; v2(205.83,44.7) 205.98,44.7 206.36,45.08 206.36,45.73 RH313.2 ; 331.54,39.33 332.4,40.18 332.76,40.18 332.94,40 CA45.2 ; 331.54,39.33 CA46.2 ; v2(102.29,60.01) 102.35,60.01 102.82,60.47 PC1165.2 ; v2(41.96,43.43) 41.67,43.72 JXDP1.38 ; PQ1204.1 67.19,103.01 67.85,103.67 68.25,103.67 68.49,103.91 PQ1204.4 ; UE1.A6 317.72,40.87 317.67,40.92 v2(317.67,41.05) ; JXDP1.32 40.17,46.01 40.41,46.25 v2(40.41,46.38) ; v2(85.35,62.46) 85.39,62.43 86.01,62.43 86.41,62.03 PC1096.2 PC1088.2 ; JXDP1.59 47.17,40.56 46.94,40.79 v2(46.78,40.79) ; v2(172.82,10.49) 172.82,10.55 172.45,10.92 PR316.2 ; UZ29.20 v2(363.41,48.55) ; v2(330.25,45.78) 330.25,46.2 330.25,46.21 UZ8.5 ; RC178.2 133.85,76.91 v2(134.01,76.76) ; UV9.24 272,40.49 272.38,40.87 272.57,40.87 v2(272.69,40.99) ; v2(32.67,46.44) JXDP1.2 ; UZ2.11 v2(312.21,70.51)
  TOP w0.279: JXDP1.31 40.17,40.62 v2(40.08,40.72) ; JXDP1.50 v2(44.67,46.53)
  TOP w0.305: v2(264.9,9.3) 264.8,9.2 UZ23.5 ; JAPS1.8 176.32,43.26 v2(176.38,43.21) ; v2(177.42,43.08) 177.32,43.17 JAPS1.10 ; v2(271.08,0.44) 271.08,0.82 271.58,1.32 LGA1.5 ; v2(178.57,42.43) 179.32,43.18 JAPS1.14 ; CD28.2 94.85,19.04 v2(95.02,19.2) ; v2(274.16,0.44) 274.16,1.03 273.26,1.93 273.26,3.28 272.95,3.58 LGA1.8 ; LGA1.7 272.63,1.57 273.38,0.81 v2(273.38,0.44) ; LGA1.6 272.08,1.27 272.36,0.99 v2(272.36,0.44) ; JAPS1.12 178.32,43.37 v2(178.57,43.12) ; CR19.1 v2(5.38,82.19) ; CL7.2 314.62,87.24 v2(314.5,87.12) ; CL3.2 v2(331.27,87.21) ; CZ2.2 v2(123.62,102.26)
  TOP w0.356: CC192.1 114.69,72.76 v2(114.36,73.09) ; v2(323.74,40.73) 323.74,40.71 323.39,40.35 UE1.A13 ; UE1.C4 v2(316.52,38.35) ; UE1.H4 v2(316.52,34.35)
  TOP w0.381: v2(205.21,27.74) 205.78,27.74 CH62.2 ; RT140.2 18.77,118.77 v2(19.34,118.77) ; CI19.2 339.5,64.81 v2(339.4,64.72) ; CE23.2 318.86,43.45 CE14.2 ; CC329.2 222.85,38.26 222.4,37.81 222.15,37.81 v2(222.14,37.8) 222.07,37.73 CC310.2 221.01,37.73 220.52,38.23 CC327.2 ; v2(89.47,69.24) 89.8,69.24 PC1019.2 ; CL15.2 312.84,91.1 v2(312.64,90.91) ; PU1.3 v2(76.18,117.44) ; v2(21.26,111.42) 21.08,111.42 20.56,110.9 CT122.2 ; CV62.2 268.64,35.38 268.42,35.17 v2(268.42,34.86) ; 331.52,44.14 331.9,44.53 CZ120.2 ; PC9.2 72.22,117.59 v2(71.73,118.08) ; RE95.1 318.11,27.31 v2(318.11,26.77) ; UZ6.3 312.5,22.17 v2(312.84,21.83) ; CC307.2 40.41,35.51 40.69,35.79 v2(40.69,35.84) 40.79,35.84 40.99,36.04 CC28.2 ; v2(87.17,64.81) 87.52,64.81 PC1008.2 ; v2(10.69,113.37) 10.75,113.44 DT40.3 ; v2(263.37,11.76) 263.44,11.68 CZ129.2 ; RH617.1 218.78,36.83 v2(218.57,37.05) ; CA49.2 338.41,42.6 v2(338.68,42.86) ; v2(319.48,45.62) 319.48,46.37 319.45,46.41 RE93.2 319.45,47.61 QE12.3 ; RH379.2 207.57,25.37 207.67,25.37 v2(207.86,25.18) ; PC1015.2 89.8,68.03 v2(89.46,68.03) ; RD25.2 153.85,14.84 153.02,15.67 v2(153.02,15.71) ; v2(135.85,8.15) 135.89,8.11 CZ92.2 CZ91.2 ; PQ1214.4 61.91,101.97 61.94,101.97 v2(62.35,102.39) ; PC1166.2 PC1165.2 ; v2(274.53,1.59) 274.53,1.88 274.3,2.11 CN2.2 ; CT119.2 17.31,113.69 16.93,114.07 16.93,114.08 v2(16.94,114.08) ; CN3.2 272.29,7.28 v2(271.95,6.95) ; CA66.2 336.11,48.56 336.51,48.96 UE5.3 ; v2(310.5,9.25) 310.5,9.51 310.88,9.89 CE22.2 ; PC1012.2 89.8,70.45 v2(89.46,70.45) ; UL2.3 v2(317.11,91.81) ; RH424.2 212.4,20.28 211.8,20.87 v2(211.8,21.65) ; v2(9.7,110.06) CT99.2 CT100.2 ; v2(202.96,27.69) 202.52,27.69 CH64.2 ; CE21.2 315.86,27.55 v2(315.77,27.46) ; v2(222.74,36.05) 222.89,35.9 RH372.2 ; CZ90.2 139.44,8.02 v2(139.11,8.34) ; RH268.2 221.8,29.65 v2(221.83,29.62) ; PC1704.2 v2(64.63,84.02) ; v2(327.28,35.53) 327.22,35.58 CE40.2 ; PC1005.2 87.52,63.59 v2(87.17,63.59) ; RT138.2 24.23,110.59 v2(23.9,110.26) ; PQ1201.4 57.89,107.56 PR1222.2 ; v2(187.91,47.57) 187.63,47.29 RH626.2 ; CT618.2 26.36,111.45 25.99,111.82 25.42,111.82 25.05,111.45 CT615.2 ; CD60.2 173.69,23.97 v2(173.99,23.66) ; CT118.2 18.87,116.38 CT117.2 18.21,116.67 18.08,116.8 18.02,116.8 v2(17.89,116.93) ; RH325.1 209.26,25.06 v2(208.98,25.34) ; PQ1.4 67.48,110.74 67.86,110.36 67.86,110.15 v2(68.23,109.79) 68.58,109.44 PQ1.1 ; v2(344.01,48.7) 344.1,48.7 344.61,49.21 UE4.3 ; RE342.2 309.79,34.86 310.57,34.86 v2(310.59,34.85) 310.61,34.82 310.63,34.82 310.66,34.78 CE13.2 ; PU903.3 12.34,46 12.65,45.69 12.65,45.14 v2(13.15,44.63) ; CR1.2 18.81,72.9 CR2.2 19.03,72.1 19.28,71.85 v2(19.28,71.66) ; DI1.3 v2(16.99,91.39)
  TOP w0.406: v2(63.04,100.28) 63.09,100.28 63.44,100.62 PQ1214.1
  TOP w0.457: PC1180.2 109.33,68.98 v2(109.77,68.98) ; v2(91.81,70.45) 91.51,70.45 PC1013.2 ; v2(104.93,63.27) 104.92,63.26 104.47,63.26 PC1045.2 ; v2(114.46,47.87) 114.75,47.58 114.75,47.08 CC171.2 ; v2(91.81,63.94) 91.81,63.52 PC1002.2 ; PC1010.2 87.83,70.79 87.49,70.45 v2(87.11,70.45) ; v2(107.39,70.32) 107.84,70.32 PC1114.2 ; PC1181.2 109.32,67.76 v2(109.77,67.76) ; RC171.1 77.96,48.04 79.42,49.5 79.54,49.5 79.58,49.54 79.88,49.54 v2(79.9,49.56) ; v2(105.01,67.89) 104.59,67.89 PC1054.2 ; v2(89.52,63.59) 89.12,63.59 PC1009.2 ; PC1174.2 102.24,66.68 v2(102.67,66.68) ; PC1042.2 102.24,69.1 v2(102.66,69.1) ; v2(105.01,70.32) 104.59,70.32 PC1115.2 ; PC1177.2 109.33,66.55 v2(109.78,66.55) ; v2(94.19,69.27) 94.57,69.27 94.91,69.61 PC1001.2 ; v2(112.1,68.45) 112.55,68.45 PC1046.2 ; PC1051.2 107.72,62.75 v2(107.27,62.75) ; v2(110.84,47.78) 110.59,47.52 110,47.52 CC172.2 109.39,48.13 109.39,48.92 v2(109.58,49.11) ; v2(105.15,49.22) 105.15,48.38 CC82.2 105.36,48.29 106.04,48.97 v2(106.14,48.97) ; PC1017.2 91.51,69.24 v2(91.82,69.24) ; v2(91.81,68.03) 91.51,68.03 PC1007.2 ; PC949.1 15.62,46.92 15.29,46.58 v2(14.63,46.58) ; v2(87.12,69.24) 87.5,69.24 87.84,69.58 PC1011.2 ; v2(112.11,66.03) 112.56,66.03 PC1179.2 ; PC1014.2 94.55,70.48 v2(94.17,70.48) ; v2(87.11,68.03) 87.45,68.03 PC1018.2 ; v2(110.28,71.39) 109.83,71.39 PC1112.2 ; v2(111.78,71.77) 111.78,71.33 PC1173.2 ; CD60.2 173.49,24.42 CD59.2 ; v2(109.64,63.27) 109.19,63.27 PC1043.2 ; v2(94.1,47.5) 93.62,47.5 CC168.2 ; CZ83.2 141.06,7.69 141.52,8.14 v2(141.52,8.36) ; PC1111.2 104.59,69.1 v2(105.01,69.1) ; v2(107.39,67.89) 107.84,67.89 PC1056.2 ; v2(115.87,46.45) 115.32,45.89 CC81.2 ; PC1175.2 104.59,66.68 v2(105.02,66.68) ; PC1116.2 112.55,69.66 v2(112.1,69.66) ; PC1006.2 94.55,68.06 v2(94.17,68.06) ; PC1003.2 89.12,64.81 v2(89.52,64.81) ; v2(107.41,67.2) 107.83,67.2 PC1178.2 ; v2(113.89,48.44) 113.89,48.21 113.54,47.86 CC84.2 ; v2(102.66,67.89) 102.24,67.89 PC1052.2 ; v2(112.1,67.25) 112.55,67.25 PC1176.2 ; PC1048.2 109.33,70.18 v2(109.78,70.18) ; PC1041.2 107.84,69.1 v2(107.39,69.1) ; PC1113.2 102.24,70.32 v2(102.66,70.32) ; v2(111.98,62.75) 112.43,62.75 PC1044.2
  TOP w0.508: JAPS1.20 182.92,40.98 v2(182.22,41.69) ; CD38.2 134.67,20.89 v2(134.12,20.33) ; CZ61.2 300.87,10.23 301.42,9.68 v2(301.57,9.68) ; RC219.1 54.91,51.92 54.53,52.3 v2(54.53,53.62) ; v2(89.61,19.74) 89.37,19.74 88.95,20.17 CD2.2 ; RV82.2 272.97,29.72 272.74,29.49 v2(272.74,29.22) ; CD57.2 v2(152.05,12.74) ; v2(337.73,69.08) 337.69,69.03 337.01,69.03 RI14.1 ; v2(200.76,21.65) 200.4,21.29 CH66.2 ; RC179.2 123.39,84.89 v2(123.35,84.93) ; CZ197.2 330.55,51.03 331.61,51.03 v2(331.65,51.07) ; CL13.2 328.94,88.03 v2(329.19,87.78) 329.49,88.09 YL1.2 ; PC1204.2 58.15,99.78 59.27,99.78 v2(59.53,100.05) 59.61,100.13 PR1210.2 ; CD47.2 147.37,21.71 147.37,20.22 147.72,19.88 v2(148.19,19.88) ; PC937.1 24.3,6.71 v2(24.3,7.26) ; v2(217.39,44.28) 217.13,44.03 217.13,43.58 ; CD6.2 60.23,15.37 v2(60.5,15.65) ; PC955.2 14,39.19 13.64,39.55 12.83,39.55 PC931.1 12.11,38.84 PC933.2 10.88,39.5 v2(10.68,39.5) ; CC325.2 77.96,85.48 77.82,85.62 v2(77.78,85.62) ; CD37.2 141.88,21.01 141.88,20.28 v2(141.28,19.67) ; v2(304.11,36.91) 303.96,37.06 CE60.2 ; CD13.2 66.7,21.63 66.98,21.36 66.98,20.47 66.71,20.21 v2(66.25,20.21) ; v2(164.32,9.32) 164.62,9.32 165.61,10.31 PC314.2 165.79,10.34 PR302.2 ; RL13.2 v2(327.46,91.13) ; v2(290.39,4.87) 290.62,4.64 290.62,3.88 290.26,3.52 289.8,3.52 289.61,3.33 288.78,3.33 288.34,2.88 RZ38.1 ; RT377.2 30.57,91.46 v2(30.27,91.17) ; PC415.2 PR403.2 155.72,58 v2(156.64,57.07) ; CH47.2 198.66,33.69 v2(198.02,34.32) ; CH47.2 198.25,33.22 v2(198.25,32.91) ; CH47.2 199.49,33.62 CH34.2 ; v2(55.51,9.69) 55.86,9.34 PC204.2 ; CV101.2 332.02,69.11 v2(332.66,69.75) ; v2(327.69,38.04) 327.76,38.11 JTAG1.2 326.73,38.77 RE65.2 CE30.2 ; RC443.2 76.21,65.35 v2(76.67,65.82) ; CD34.2 171.23,21.43 v2(170.59,20.79) ; PR1760.2 50.44,81.16 50.44,80.26 PR1761.2 PR1762.2 50.63,78.18 v2(50.64,78.17) ; v2(210.78,11.4) 210.46,11.4 209.72,10.67 RH621.1 ; CE8.2 321.18,28.83 v2(321.2,28.86) ; DI5.1 350.63,69.18 350.39,68.94 v2(349.83,68.94) ; CZ100.2 129.64,94.06 v2(130.22,94.64) ; RV117.2 356.66,102.72 v2(356.66,103.28) ; CC33.2 51.99,45.69 51.79,45.49 v2(51.28,45.49) ; RV84.2 RV50.2 v2(282.58,38.7) ; v2(311.51,47.8) 312.25,48.54 CE10.2 ; UE3.3 341.41,49.21 v2(340.8,48.6) 340.8,47.76 339.28,46.24 CA69.2 ; v2(186.71,48.09) 186.86,47.94 CH341.2 ; CD7.2 70.39,19.88 v2(69.73,19.22) ; v2(329.1,76.61) 329.61,76.1 CV104.2 ; v2(135.11,15.38) 135.66,14.83 CD61.2 ; v2(159.32,20.26) 159.71,20.26 160.05,20.6 CD42.2 ; 178.13,15.14 CD54.2 ; 178.13,15.14 178.76,15.14 v2(178.79,15.16) ; 178.13,15.14 v2(178.15,15.16) ; CD9.2 46.77,21.43 46.08,20.74 46.08,19.04 v2(45.77,18.73) ; PC938.2 v2(6.4,40.11) ; RH377.1 207.29,21.54 v2(207.38,21.62) ; CV131.2 v2(360.8,98.88) ; CV126.2 v2(357.68,105.82) ; PC1049.2 v2(103.7,86.13) ; PC1047.2 78.71,86.11 v2(78.3,86.51) ; v2(220.73,45.23) 220.73,45 220.72,45 220.72,44.21 CH323.2 CH37.2 ; CD3.2 31.8,14.31 31.8,15.92 31.29,16.42 v2(31.05,16.42) ; RD16.2 68.13,10.8 v2(67.79,10.46) ; CD26.2 70.13,15.58 v2(70.38,15.82) ; PC1108.2 104.15,64.55 104.42,64.29 PC1085.2 104.42,63.82 104.22,63.62 PC1045.2 ; v2(148.11,16.47) 147.66,16.47 RD31.2 ; v2(314.26,86.35) 314.36,86.45 RL12.2 ; v2(347.18,23.8) 347.12,23.74 DA6.1 ; v2(320.95,71.02) 321.27,71.34 CV103.2 ; v2(54.51,16.17) 54.89,15.79 CD29.2 ; CD46.2 144.7,15.19 v2(144.37,15.52) ; CT87.2 32.69,92.13 v2(32.69,92.48) ; RV123.1 v2(327.14,66.13) ; CD55.2 174.59,13.87 172.26,16.2 v2(172.26,16.43) ; PR953.2 15.56,44.15 15.44,44.03 v2(14.78,44.03) ; CD16.2 79,21.78 79.63,21.16 79.63,20.27 79.13,19.78 v2(78.83,19.78) ; v2(69.51,104.75) 69.23,104.75 68.83,104.35 PQ1204.4 ; v2(309.98,46.27) 309.55,45.83 RE55.2 RE58.2 ; CA67.2 339.72,27.2 CA54.2 340.66,27.84 v2(341.04,27.46) ; CV127.2 357.68,103.02 v2(357.42,103.28) ; CH45.2 197.21,46.3 v2(197.21,45.88) ; RD18.2 67.34,15.17 v2(67.89,15.72) ; PC206.2 49.24,3.63 49.91,4.3 v2(49.91,4.4) ; CD44.2 156.19,12.91 156.31,12.79 v2(156.31,12.57) ; RZ40.1 v2(318.53,70.07) ; 5.89,41.63 5.25,42.27 v2(5.25,42.32) ; v2(55.99,19.14) 55.81,19.14 55.38,19.58 55.38,21.63 CD10.2 ; v2(56.49,15.66) 56.33,15.5 56.33,14.99 CD14.2 ; CC301.2 140.15,60.81 v2(140.56,61.21) ; v2(19.57,72.97) 19.53,72.93 CR1.2 CR27.2 ; RH308.2 216.25,18.24 CH41.1 214.63,18.63 215.15,19.15 215.38,19.15 v2(215.66,19.43) 215.1,19.98 RH83.2 215.11,20.02 215.38,20.29 CH266.2 ; PC842.2 v2(118.31,92.02) ; v2(296.46,6.88) 296.46,6.2 PC2.1 ; v2(76.2,61.55) RC442.2 RC323.2 ; RC5.1 122.81,45.69 122.47,45.36 v2(122.39,45.36) ; CD27.2 93.65,18.77 93.98,18.44 v2(94.48,18.44) ; CC306.2 45.62,49.32 v2(45.13,49.81) 44.73,49.41 CC32.2 ; PR212.2 v2(42.17,12.12) ; SW3.3 v2(348.13,121.97) SW3.1 ; v2(309.4,28.37) 309.36,28.41 309.36,28.83 RE20.2 309.03,29.16 RE550.2 ; v2(203.99,44.95) 203.5,44.95 RH435.1 ; CE62.2 310.69,40.28 310.94,40.03 v2(310.94,39.65) ; RZ360.2 362.66,52.3 v2(362.72,52.36) ; v2(71.56,64.7) 71.56,64 72.35,63.21 CC209.1 CC210.1 CC322.2 74.83,63.21 74.86,63.24 75.26,63.24 v2(75.53,63.5) ; PD1.1 3.29,12.35 v2(3.29,12.03) ; CV106.2 v2(328.34,76.61) ; v2(58.02,19.45) 58.22,19.45 58.83,20.06 58.83,21.3 CD5.2 ; v2(63.57,15.42) 63.53,15.37 CD12.2 ; CA22.2 333.63,37.77 333.31,37.45 333.31,37.45 333.2,37.34 v2(333.2,36.72) 333.37,36.88 CA23.2 ; v2(200.31,38.23) 199.65,38.88 RH110.2 ; CL18.2 v2(315.39,113.56) ; v2(4.36,82.45) CR20.1 v2(3.48,81.56) ; CA68.2 345.23,29.16 v2(345.43,28.96) ; v2(202.05,41.44) 201.75,41.74 CH29.2 ; CC29.2 41.05,49.61 v2(41.18,49.74) ; v2(95.58,120.8) 96,121.22 QV4.3 ; v2(242.7,33.64) 242.63,33.57 242.63,33.41 242.62,33.4 CZ59.2 242.62,32.13 CZ60.2 ; CC186.1 129.03,71.6 v2(129.08,71.65) ; CV631.2 268.31,32.84 266.91,32.84 v2(266.75,32.69) ; v2(283.38,34.57) 283.06,34.25 RV76.2 RV80.2 ; v2(339.48,29.78) 339.47,29.79 339.47,30.21 RA52.1 ; CD56.2 174.77,14.86 v2(174.19,15.44) ; v2(73.49,16.52) 74.45,15.56 CD15.2 ; v2(31.47,39.22) 31.89,38.8 31.89,36.32 32.25,35.96 RC122.2 ; v2(281.82,31.67) CV61.2 CV75.2 ; v2(341.7,27.23) 341.7,27.99 CA33.2 ; QE2.4 304.48,46.14 v2(304.39,46.05) ; v2(111.24,15.96) 111.92,15.28 CD35.2 ; v2(307.03,51.56) 307.88,50.71 CE61.2 ; CC187.2 126.95,69.52 v2(126.54,69.11) ; PR1720.1 67.28,83.24 PC1710.1 68.26,85.09 68.26,86.04 v2(68.47,86.26) ; CD11.2 41.43,14.9 v2(41.86,15.33) ; v2(8.32,24.54) 8.6,24.26 9.68,24.26 11.1,22.85 PC940.2 ; CV129.2 v2(360.65,104.09) ; CE52.2 337.7,51.75 338.17,52.22 339.87,52.22 340.27,51.83 v2(340.27,51.54) ; CZ56.2 242.54,25.63 242.43,25.74 v2(242.41,25.74) ; RD21.2 RD23.2 179.88,17.14 179.34,17.68 v2(179.24,17.68) ; v2(201.37,33.72) 201.09,33.72 200.75,33.38 CH38.2 ; PC841.2 116.3,73.95 116.64,73.61 v2(116.78,73.61) ; RZ62.2 v2(252.73,28.73) ; v2(196.63,41.5) 196.41,41.71 CH32.2 CH46.2 ; v2(220.16,47.34) 220.16,47.33 220.16,47.09 RH606.2 219.59,46.41 218.99,45.82 RH611.1 ; RC437.2 74.43,68.15 RC321.2 74.43,69.5 74.09,69.85 RC181.2 74,69.99 73.5,69.49 ; CE53.2 v2(341.24,51.65) ; v2(36.66,19.73) 36.02,20.36 36.02,21.22 CD1.2 ; PQ1201.4 58.48,106.59 v2(58.72,106.83) ; v2(319.9,44.41) 319.73,44.41 319.19,43.87 CE14.2 ; CC308.2 73.24,70 73.24,69.75 73.5,69.49 ; CR27.2 CR28.2 ; CR27.2 19.12,73.88 19.37,73.63 v2(19.6,73.63) ; PQ1201.1 56.05,104.69 55.7,104.33 v2(55.7,103.43) ; RH1.1 210.47,48.81 v2(210.33,48.94) ; RC325.2 RC324.2 RC322.2 ; RC325.2 74.41,66.39 RC440.2 ; RC325.2 73.5,66.31 v2(73.37,66.19) ; v2(339.4,64.72) 338.96,64.72 338.72,64.96 CI31.2 ; RE702.2 307.25,23 307.68,23.44 v2(308.09,23.44) 308.15,23.49 CE59.2 ; v2(28.75,110.51) 28.62,110.51 28.56,110.45 RT136.2 ; v2(228.25,30.67) 227.94,30.98 CC319.2 ; v2(175.92,18.44) 175.42,18.94 CD50.2 CD51.2 176.33,19.39 CD52.2 177.45,19.35 v2(178.23,18.57) ; v2(125.4,49.62) 125.23,49.62 124.41,48.79 RC7.1 RC6.1 ; CD25.2 71.02,14.82 v2(71.88,15.67) ; 332.61,43.66 332.61,43.66 333.12,44.17 333.12,44.89 CA65.2 333.01,44.78 CZ120.2 ; v2(119.83,129.52) PC126.2 ; v2(41.93,67.72) PC2001.2 PC2002.2 ; CD36.2 167.57,16.73 167.98,16.32 v2(168.33,16.32) ; v2(33.07,85.24) 32.84,85.47 RT101.2 ; CD48.2 140.82,14.57 140.23,15.16 140.23,15.65 140.85,16.27 v2(141.23,16.27) ; CD8.2 66.09,15.45 v2(66.11,15.47) ; QE2.1 302.81,45.41 302.21,45.41 v2(302.12,45.33) 302.12,45.55 301.94,45.73 QZ4.3 ; CV15.2 122.84,110.19 123.14,109.88 123.14,108.88 v2(122.99,108.73) ; CL4.2 v2(332.35,86.2) ; CD41.2 127.79,20.97 126.45,19.62 v2(126.05,19.62) ; CE29.2 314.7,43.59 315.14,44.02 v2(315.15,44.02) ; CC328.2 202.86,28.72 202.86,29.01 v2(202.91,29.06) ; v2(282.27,41.05) 281.82,40.6 RV74.2 ; v2(74.44,73.25) 74.12,72.93 RC436.2 ; CZ106.2 145.6,76.23 v2(146.1,76.73) ; v2(53.26,49.55) 53.26,49.43 53.01,49.17 53.01,49.12 CC269.2 ; v2(57.58,102.06) 57.58,102.22 58.1,102.74 PU1200.3 ; CD43.2 122.46,15.89 v2(122.18,16.16) ; CH22.2 CH21.2 214.04,36.98 v2(213.72,37.3) ; v2(205.24,38.24) 205.57,37.91 CH36.2 ; v2(73.36,120.88) 73.47,120.98 73.47,121.05 PQ6.3 74.85,121.53 PR30.2 ; CV105.2 v2(330.5,76.48) ; v2(72.94,104.06) 72.58,103.7 PC1807.2 ; v2(62.12,111.1) 62.63,110.6 PQ7.3 64.06,111.38 PR24.2 ; CE12.2 312.94,46.95 v2(312.85,46.86) ; CE28.2 311.88,43.55 v2(311.92,43.59) ; RH603.2 213.44,48.44 v2(213.93,48.93) ; v2(211.8,41.92) 212.72,42.84 RH608.2 ; v2(150.02,12.69) 150.27,12.94 RD29.2 CD58.2 ; PD2.1 v2(3.54,9.74) ; CA24.2 333.48,35.99 333.2,35.71 v2(333.2,35.09) 333.22,35.1 CA19.2 ; v2(220.06,45.28) 219.55,45.28 219.19,44.93 RH610.1 ; v2(301.61,5.96) 301.61,7.03 RZ10.1 ; QZ16.1 277.4,2.08 v2(276.96,1.64) ; v2(341.9,58.9) 341.47,59.33 341.47,59.8 CZ20.2 ; CV102.2 331.85,67.92 v2(331.14,67.21) ; 331.52,44.14 CZ121.2 v2(329.99,44.14) ; 73.5,69.49 v2(73.5,69.16) ; CD33.2 118.04,19.7 v2(118.09,19.7) ; v2(275.9,1.68) 275.9,2.12 CN1.2 275.46,2.5 275.14,2.18 v2(275.14,1.68) ; CL14.2 v2(328.4,91.49) ; CR15.2 v2(20.75,74.07) ; UZ19.5 v2(146.22,74.83) ; RL9.2 327.56,82.08 v2(328.01,81.64) ; CD39.2 138.44,16.22 138.78,16.56 v2(139.09,16.56) ; CZ32.2 296.13,19.99 v2(295.94,20.18) ; RA37.2 v2(360.22,21.67) ; v2(119.06,86.19) 118.89,86.36 PC808.2 ; CE63.2 v2(306.88,55.48) ; v2(3.7,40.36) 3.73,40.36 4.16,39.93 4.16,39.8 4.36,39.6 ; v2(120.49,127.23) 120.16,126.9 RV21.2 ; v2(333.09,48.74) 334.3,48.74 334.48,48.56 CA66.2 ; v2(12.35,3.33) PC1.2 ; RD5.2 v2(95.98,15.57) ; CV130.2 360.17,101.68 v2(360.73,101.12) ; v2(100.67,64.92) PC1053.2 ; RH334.1 232.96,9.94 233.12,9.79 v2(233.12,9.24) ; PR509.2 PC510.2 151.55,125.62 v2(151.18,125.25) ; PR207.1 44.65,3.63 v2(44.24,4.04) ; CD23.2 CD24.2 95,13.65 95.49,13.17 v2(95.49,12.93) ; RZ7.2 293.81,6.01 v2(294.18,6.37) ; CE36.2 322.3,12.24 322.67,11.87 v2(322.67,11.86) ; v2(218,15.77) 218,16.17 CH33.2 ; CT614.2 22.67,109 v2(22.58,109.1) ; v2(29.62,85.2) 29.62,84.6 29.28,84.27 CT74.2 ; RD9.2 73,13.29 v2(72.54,12.83) ; v2(24.43,66.9) CR21.2 22.87,66.9 CR22.2 ; v2(172.39,39.6) 171.6,39.6 170.72,40.47 JAPS1.19 ; CV14.2 126.27,110.99 v2(125.73,110.45) ; CV7.2 334.34,70.76 v2(333.68,70.76) 333.35,70.43 CV100.2 ; PC1016.2 67.42,64.63 64,61.21 PC849.2 59.45,61.21 v2(58.16,59.91) ; RV116.2 v2(356.79,105.82) ; v2(130.16,67.91) 129.9,67.65 CC333.1 ; v2(50.73,84.52) 50.57,84.36 PC1732.2 ; CD18.2 v2(97.71,21.36) ; RV118.2 v2(356.79,100.61) ; v2(151.61,20.9) 151.56,20.95 CD45.2 ; QV7.3 129.64,97.13 129.91,97.41 v2(130.2,97.41) 130.23,97.37 CV1638.2 ; v2(121.61,84.51) 121.09,85.03 CC323.2 ; QV2.3 127.26,109.83 v2(127.4,109.98) ; DA7.1 v2(346.73,19.74) ; PC837.2 118.6,85.32 v2(119.06,84.86) 118.65,84.45 PC836.2 ; PQ3.3 73.91,125.3 v2(74.34,124.87) 74.34,123.6 74.04,123.29 PR8.1 ; v2(316.39,55.45) 316.94,54.9 CE65.2 ; v2(269.38,7.35) 269.22,7.5 QN6.3 ; RV77.2 267.6,37.49 266.79,37.49 266.78,37.48 v2(266.29,37.48) ; v2(357.55,100.61) 357.81,100.35 CV128.2 ; RA36.2 v2(366.98,39.49) ; RD7.2 v2(98.68,15.72) ; v2(88.6,60.74) 88.62,60.75 PC1026.2 ; PR948.2 4.31,32.08 ; CL30.2 314.23,87.97 v2(313.99,87.73) ; v2(145.84,70.7) CZ105.2 ; 124.37,101.98 CV1635.2 ; RC75.2 v2(219.55,15.75) ; CD19.2 v2(97.58,22.25) ; CD22.2 90.58,15.71 90.97,16.1 v2(90.97,16.08) ; v2(23.9,111.42) 23.93,111.45 CT615.2 ; v2(206.15,53.04) 206.02,52.91 RH74.2 ; RC136.2 v2(48.56,49.68) ; v2(42.85,12.09) 42.85,11.94 43.05,11.73 PC222.2 ; CC316.2 223.12,21.12 224.47,21.12 224.47,21.13 v2(224.48,21.13) ; CC191.1 130.34,74.36 130.34,74.59 130.63,74.89 v2(130.63,74.95) 130.88,75.21 CC194.1 CC193.1 131.29,74.19 v2(131.02,73.93) 130.55,73.46 CC195.1 ; PC3.2 296.02,7.71 295.7,7.39 v2(295.7,6.76) ; v2(359.11,52.43) 359.88,52.43 CZ155.2 ; CZ130.2 v2(264.21,11.79) ; CE32.2 206.02,65.66 v2(206.02,65.24) ; RN5.2 v2(262.34,3.88) ; RV102.2 v2(325.67,76.61) ; RL3.2 v2(331.65,84.8) ; PD4.1 v2(62.72,126.2) ; CH65.2 218.66,15.84 v2(218.7,15.79) ; v2(132.9,15.66) 132.76,15.53 CD40.2 ; CD4.2 85.2,14.77 85.2,15.81 85.13,15.88 85.13,15.94 84.77,16.29 84.71,16.29 v2(84.57,16.44) ; YL1.4 v2(331.33,90.08) ; CT617.2 20.8,109.55 v2(21.26,109.1) ; PC1702.1 v2(67.37,77.9) ; PR1262.2 v2(59.66,103.73) ; CZ27.2 v2(302.05,39.78)
  GND1 w0.203: SW1.5 206.48,4.21 ; SW1.5 204.71,3.45 ; SW1.5 205.72,4.46 ; SW1.5 206.72,3.45 ; SW1.5 205.72,2.45 ; SW1.5 204.95,2.69 ; SW1.5 204.95,4.21 ; SW1.5 206.48,2.69 ; 131.1,106.27 H35.1 ; H35.1 129.58,109.87 ; H35.1 129.58,106.83 ; H35.1 131.1,110.43 ; H35.1 129.02,108.35 ; H35.1 132.62,106.83 ; H35.1 133.18,108.35 ; H35.1 132.62,109.87 ; H1.1 73.33,78.09 ; H1.1 73.97,79.8 ; H1.1 69.29,79.8 ; H1.1 69.93,81.5 ; H1.1 73.33,81.5 ; H1.1 69.93,78.09 ; H1.1 71.63,82.14 ; H1.1 71.63,77.46 ; 184.12,5.93 H17.1 ; H17.1 183.37,3.95 ; H17.1 186.1,1.22 ; H17.1 188.08,5.93 ; H17.1 186.1,6.68 ; H17.1 188.83,3.95 ; H17.1 184.12,1.97 ; H17.1 188.08,1.97 ; 98.77,137.98 JHDMI1.22 ; JHDMI1.22 98.77,134.82 ; JHDMI1.22 100.93,137.98 ; JHDMI1.22 100.93,136.4 ; JHDMI1.22 100.93,134.82 ; JHDMI1.22 99.85,137.98 ; JHDMI1.22 98.77,136.4 ; JHDMI1.22 99.85,134.82 ; 14.42,88.34 JUSB2.4 ; JUSB2.4 15.88,87.71 ; JUSB2.4 15.05,86.88 ; JUSB2.4 15.05,88.54 ; JUSB2.4 15.69,87.07 ; JUSB2.4 15.69,88.34 ; JUSB1.11 361.36,77.93 ; JUSB1.11 357.8,76.17 ; JUSB1.11 361.36,77.05 ; JUSB1.11 359.58,77.93 ; JUSB1.11 357.8,77.93 ; JUSB1.11 357.8,77.05 ; 77.37,136.81 JUSB3.12 ; JUSB3.12 77.37,135.48 ; JUSB3.12 77.37,134.15 ; JUSB3.12 78.25,136.81 ; JUSB3.12 78.25,134.15 ; 112.6,129.74 JHDMI1.17 ; JHDMI1.17 112.14,130.78 ; JHDMI1.17 112.14,129.86 ; JHDMI1.17 112.6,130.9 ; JHDMI1.17 113.06,130.78 ; JHDMI1.17 113.06,129.86 ; 363.27,87.18 JCRT1.16 ; JCRT1.16 366.53,87.18 ; JCRT1.16 364.9,87.18 ; JCRT1.16 363.27,88.62 ; JCRT1.16 366.53,88.62 ; JCRT1.16 363.27,87.9 ; JCRT1.16 364.9,88.62 ; JCRT1.16 366.53,87.9 ; 93.95,126.9 JUSB3.10 ; JUSB3.10 94.83,126.9 ; JUSB3.10 94.83,130.46 ; JUSB3.10 94.83,128.68 ; JUSB3.10 93.07,126.9 ; JUSB3.10 93.95,130.46 ; 115.47,131.17 JHDMI1.21 ; JHDMI1.21 116.35,131.17 ; JHDMI1.21 116.35,127.67 ; JHDMI1.21 115.47,127.67 ; JHDMI1.21 117.23,129.42 ; JHDMI1.21 115.47,129.42 ; JHDMI1.21 117.23,127.67 ; H16.1 143.8,137.7 ; H16.1 140.4,134.3 ; H16.1 140.4,137.7 ; H16.1 142.1,133.66 ; H16.1 143.8,134.3 ; H16.1 142.1,138.34 ; H16.1 144.44,136 ; H16.1 139.76,136 ; 362.56,18.6 H23.1 ; H23.1 365.6,15.56 ; H23.1 363.4,16.4 ; H23.1 367.8,16.4 ; H23.1 365.6,21.64 ; H23.1 368.64,18.6 ; H23.1 363.4,20.8 ; H23.1 367.8,20.8 ; H14.1 112.73,2.9 ; H14.1 109.9,4.1 ; H14.1 111.1,1.27 ; H14.1 111.1,4.53 ; H14.1 109.9,1.7 ; H14.1 112.3,4.1 ; H14.1 112.3,1.7 ; H14.1 109.47,2.9 ; 4.49,99.94 JUSB2.13 ; JUSB2.13 5.82,99.94 ; JUSB2.13 7.15,99.94 ; JUSB2.13 4.49,99.06 ; JUSB2.13 7.15,99.06 ; JHDMI1.5 106.6,130.9 ; JHDMI1.5 106.14,130.78 ; JHDMI1.5 107.06,129.86 ; JHDMI1.5 106.14,129.86 ; JHDMI1.5 106.6,129.74 ; JHDMI1.5 107.06,130.78 ; SW1.4 212.78,4.21 ; SW1.4 212.02,4.46 ; SW1.4 212.78,2.69 ; SW1.4 211.25,2.69 ; SW1.4 213.02,3.45 ; SW1.4 211.25,4.21 ; SW1.4 211.01,3.45 ; SW1.4 212.02,2.45 ; H7.1 329.73,27.87 ; H7.1 328.24,27.33 ; H7.1 329.73,30.85 ; H7.1 330.27,29.36 ; H7.1 326.75,30.85 ; H7.1 326.21,29.36 ; H7.1 328.24,31.39 ; H7.1 326.75,27.87 ; 364.28,100.87 JCRT1.7 ; JCRT1.7 364.28,101.9 ; JCRT1.7 364.14,101.38 ; 5.03,121.53 H9.1 ; H9.1 8.03,122.8 ; H9.1 7.57,121.53 ; H9.1 6.3,121.07 ; H9.1 7.57,124.07 ; H9.1 6.3,124.53 ; H9.1 4.57,122.8 ; H9.1 5.03,124.07 ; JHDMI1.8 108.56,128.36 ; JHDMI1.8 107.64,128.36 ; JHDMI1.8 108.56,129.28 ; JHDMI1.8 108.1,129.4 ; JHDMI1.8 107.64,129.28 ; JHDMI1.8 108.1,128.23 ; 302.97,122.9 H21.1 ; H21.1 304.6,124.53 ; H21.1 303.4,121.7 ; H21.1 305.8,121.7 ; H21.1 304.6,121.27 ; H21.1 306.23,122.9 ; H21.1 303.4,124.1 ; H21.1 305.8,124.1 ; 364.8,92.71 JCRT1.5 ; JCRT1.5 364.28,93.89 ; JCRT1.5 365.32,92.85 ; JCRT1.5 364.14,93.37 ; JCRT1.5 364.28,92.85 ; H13.1 71.6,133 ; H13.1 71.6,135.4 ; H13.1 69.2,133 ; H13.1 70.4,132.57 ; H13.1 69.2,135.4 ; H13.1 70.4,135.83 ; H13.1 68.77,134.2 ; H13.1 72.03,134.2 ; H2.1 131.01,83 ; H2.1 126.97,81.3 ; H2.1 131.01,79.6 ; H2.1 129.31,83.64 ; H2.1 127.61,79.6 ; H2.1 129.31,78.96 ; H2.1 127.61,83 ; H2.1 131.65,81.3 ; JUSB1.13 367.71,61.35 ; JUSB1.13 367.71,60.47 ; JUSB1.13 366.38,60.47 ; JUSB1.13 365.05,61.35 ; JUSB1.13 365.05,60.47 ; JUSBC1.6 3.58,120.43 ; JUSBC1.6 0.52,120.43 ; JUSBC1.6 1.7,118.77 ; JUSBC1.6 3.58,119.6 ; JUSBC1.6 1.7,120.43 ; JUSBC1.6 3.58,118.77 ; JUSBC1.6 0.52,118.77 ; JUSBC1.6 0.52,119.6 ; JCRT1.6 365.32,104.19 ; JCRT1.6 364.8,104.34 ; JCRT1.6 364.14,103.67 ; JCRT1.6 364.28,104.19 ; JCRT1.6 364.28,103.16 ; JUSB2.10 14.4,99.94 ; JUSB2.10 10.84,99.06 ; JUSB2.10 14.4,98.18 ; JUSB2.10 10.84,99.94 ; JUSB2.10 12.62,99.94 ; JUSB2.10 14.4,99.06 ; 6.4,108.65 JUSBC1.3 ; JUSBC1.3 7.12,110.66 ; JUSBC1.3 7.12,108.65 ; JUSBC1.3 6.4,110.66 ; JUSBC1.3 5.68,108.65 ; 0.52,108.73 JUSBC1.5 ; JUSBC1.5 3.58,107.9 ; JUSBC1.5 1.7,108.73 ; JUSBC1.5 0.52,107.9 ; JUSBC1.5 0.52,107.07 ; JUSBC1.5 3.58,108.73 ; JUSBC1.5 1.7,107.07 ; JUSBC1.5 3.58,107.07 ; JUSB1.10 361.36,60.47 ; JUSB1.10 361.36,61.35 ; JUSB1.10 357.8,61.35 ; JUSB1.10 359.58,60.47 ; JUSB1.10 357.8,62.23 ; JUSB1.10 357.8,60.47 ; 364.28,99.61 JCRT1.8 ; JCRT1.8 364.28,98.58 ; JCRT1.8 364.14,99.09 ; JUSB2.7 14.38,91.21 ; JUSB2.7 14.19,90.57 ; JUSB2.7 13.55,92.04 ; JUSB2.7 14.19,91.84 ; JUSB2.7 13.55,90.38 ; 365.05,77.93 JUSB1.12 ; JUSB1.12 367.71,77.93 ; JUSB1.12 365.05,77.05 ; JUSB1.12 367.71,77.05 ; JUSB1.12 366.38,77.93 ; 5.82,82.48 JUSB2.12 ; JUSB2.12 7.15,83.36 ; JUSB2.12 4.49,83.36 ; JUSB2.12 7.15,82.48 ; JUSB2.12 4.49,82.48 ; JHDMI1.2 105.1,129.4 ; JHDMI1.2 104.64,129.28 ; JHDMI1.2 105.1,128.23 ; JHDMI1.2 104.64,128.36 ; JHDMI1.2 105.56,128.36 ; JHDMI1.2 105.56,129.28 ; JHDMI1.2 104.52,128.82 ; H4.1 135.39,53.68 ; H4.1 133.05,56.02 ; H4.1 131.35,55.38 ; H4.1 134.75,51.98 ; H4.1 130.71,53.68 ; H4.1 134.75,55.38 ; H4.1 131.35,51.98 ; H4.1 133.05,51.34 ; JCRT1.17 364.9,108.72 ; JCRT1.17 363.27,107.28 ; JCRT1.17 364.9,107.28 ; JCRT1.17 363.27,108.72 ; JCRT1.17 366.53,108 ; JCRT1.17 363.27,108 ; JCRT1.17 366.53,107.28 ; JCRT1.17 366.53,108.72 ; 109.6,129.74 JHDMI1.11 ; JHDMI1.11 110.06,130.78 ; JHDMI1.11 109.14,130.78 ; JHDMI1.11 109.14,129.86 ; JHDMI1.11 109.6,130.9 ; JHDMI1.11 110.06,129.86 ; 70.11,50.16 H3.1 ; H3.1 67.77,52.5 ; H3.1 68.41,50.79 ; H3.1 68.41,54.2 ; H3.1 72.45,52.5 ; H3.1 71.81,54.2 ; H3.1 71.81,50.79 ; H3.1 70.11,54.84 ; 4.4,20.8 H11.1 ; H11.1 8.8,20.8 ; H11.1 4.4,16.4 ; H11.1 6.6,21.64 ; H11.1 9.64,18.6 ; H11.1 6.6,15.56 ; H11.1 8.8,16.4 ; H11.1 3.56,18.6 ; JUSBC1.4 7.12,116.84 ; JUSBC1.4 7.12,118.85 ; JUSBC1.4 6.4,118.85 ; JUSBC1.4 6.4,116.84 ; JUSBC1.4 5.68,118.85 ; JHDMI1.23 119.43,134.82 ; JHDMI1.23 118.35,137.98 ; JHDMI1.23 117.27,134.82 ; JHDMI1.23 119.43,137.98 ; JHDMI1.23 119.43,136.4 ; JHDMI1.23 118.35,134.82 ; JHDMI1.23 117.27,137.98 ; JHDMI1.23 117.27,136.4 ; 5.03,103.43 H10.1 ; H10.1 6.3,106.43 ; H10.1 6.3,102.97 ; H10.1 4.57,104.7 ; H10.1 8.03,104.7 ; H10.1 7.57,105.97 ; H10.1 7.57,103.43 ; H10.1 5.03,105.97 ; 77.37,128.68 JUSB3.11 ; JUSB3.11 79.13,126.9 ; JUSB3.11 78.25,126.9 ; JUSB3.11 78.25,130.46 ; JUSB3.11 77.37,130.46 ; JUSB3.11 77.37,126.9 ; 93.95,134.15 JUSB3.13 ; JUSB3.13 94.83,134.15 ; JUSB3.13 93.95,136.81 ; JUSB3.13 94.83,135.48 ; JUSB3.13 94.83,136.81 ; H22.1 357.59,93.2 ; H22.1 351.61,93.2 ; H22.1 354.6,96.18 ; H22.1 356.76,95.36 ; H22.1 354.6,90.21 ; H22.1 352.44,95.36 ; H22.1 352.44,91.04 ; H22.1 356.76,91.04 ; JUSBC1.2 8.33,117.3 ; JUSBC1.2 5.67,118.85 ; JUSBC1.2 8.33,118.85 ; JUSBC1.2 8.33,118.07 ; JUSBC1.2 7,118.85 ; 364.14,94.51 JCRT1.10 ; JCRT1.10 364.28,95.03 ; JCRT1.10 364.28,94 ; JHDMI1.20 102.73,127.67 ; JHDMI1.20 101.85,127.67 ; JHDMI1.20 100.97,127.67 ; JHDMI1.20 101.85,131.17 ; JHDMI1.20 102.73,129.42 ; JHDMI1.20 100.97,129.42 ; JHDMI1.20 102.73,131.17 ; 358.65,68.37 JUSB1.7 ; JUSB1.7 357.82,69.2 ; JUSB1.7 358.02,68.57 ; JUSB1.7 358.65,70.03 ; JUSB1.7 358.02,69.84 ; 85.47,127.12 JUSB3.7 ; JUSB3.7 86.1,126.92 ; JUSB3.7 86.74,127.12 ; JUSB3.7 86.93,127.75 ; JUSB3.7 85.27,127.75 ; 319.56,134.65 JLOM1.14 ; JLOM1.14 321.39,132.9 ; JLOM1.14 320.48,134.65 ; JLOM1.14 319.56,132.9 ; JLOM1.14 321.39,134.65 ; JLOM1.14 320.48,131.15 ; JLOM1.14 319.56,131.15 ; 7,108.66 JUSBC1.1 ; JUSBC1.1 8.33,110.21 ; JUSBC1.1 8.33,108.66 ; JUSBC1.1 8.33,109.43 ; JUSBC1.1 5.67,108.66 ; 333.9,96.63 H8.1 ; H8.1 331.87,98.66 ; H8.1 335.39,100.15 ; H8.1 335.39,97.17 ; H8.1 332.41,97.17 ; H8.1 333.9,100.69 ; H8.1 332.41,100.15 ; H8.1 335.93,98.66 ; JUSB2.11 14.4,84.24 ; JUSB2.11 12.62,82.48 ; JUSB2.11 10.84,82.48 ; JUSB2.11 14.4,82.48 ; JUSB2.11 14.4,83.36 ; JUSB2.11 10.84,83.36 ; 96.7,106.27 H34.1 ; H34.1 98.22,106.83 ; H34.1 94.62,108.35 ; H34.1 95.18,109.87 ; H34.1 95.18,106.83 ; H34.1 98.22,109.87 ; H34.1 96.7,110.43 ; H34.1 98.78,108.35 ; 81.97,125.61 JUSB3.4 ; JUSB3.4 83.24,126.88 ; JUSB3.4 83.43,126.25 ; JUSB3.4 82.6,125.42 ; JUSB3.4 83.24,125.61 ; JUSB3.4 81.77,126.25 ; 356.52,72.06 JUSB1.4 ; JUSB1.4 356.32,72.7 ; JUSB1.4 357.15,71.87 ; JUSB1.4 357.15,73.53 ; JUSB1.4 357.79,72.06 ; JUSB1.4 356.52,73.33
  VCC w0.203: JUSB1.11 359.58,77.93 ; JUSB1.11 361.36,77.93 ; JUSB1.11 357.8,76.17 ; JUSB1.11 357.8,77.93 ; JUSB1.11 357.8,77.05 ; JUSB2.11 14.4,84.24 ; JUSB2.11 12.62,82.48 ; JUSB2.11 14.4,82.48 ; JUSB2.11 10.84,82.48 ; JUSB2.11 14.4,83.36 ; 77.37,134.15 JUSB3.12 ; JUSB3.12 77.37,135.48 ; JUSB3.12 77.81,134.15 ; H16.1 143.8,134.3 ; H16.1 142.1,138.34 ; H16.1 142.1,133.66 ; H16.1 143.8,137.7 ; H16.1 144.44,136 ; H16.1 140.4,137.7 ; H16.1 140.4,134.3 ; H16.1 139.76,136 ; H8.1 335.93,98.66 ; H8.1 331.87,98.66 ; H8.1 333.9,100.69 ; H8.1 335.39,97.17 ; H8.1 333.9,96.63 ; H8.1 332.41,100.15 ; H8.1 335.39,100.15 ; H8.1 332.41,97.17 ; JUSB2.4 15.69,87.07 ; JUSB2.4 15.05,88.54 ; JUSB2.4 14.42,88.34 ; JUSB2.4 15.88,87.71 ; JUSB2.4 15.05,86.88 ; JUSB2.4 15.69,88.34 ; 357.8,61.35 JUSB1.10 ; JUSB1.10 357.8,62.23 ; JUSB1.10 357.8,60.47 ; JUSB1.10 359.58,60.47 ; JUSB1.10 361.36,60.47 ; 106.6,129.74 JHDMI1.5 ; JHDMI1.5 106.14,129.86 ; JHDMI1.5 107.06,129.86 ; H10.1 6.3,106.43 ; H10.1 5.03,103.43 ; H10.1 7.57,105.97 ; H10.1 4.57,104.7 ; H10.1 7.57,103.43 ; H10.1 6.3,102.97 ; H10.1 5.03,105.97 ; H10.1 8.03,104.7 ; 4.49,99.94 JUSB2.13 ; JUSB2.13 7.15,99.94 ; JUSB2.13 5.82,99.94 ; 5.82,82.48 JUSB2.12 ; JUSB2.12 4.49,82.48 ; JUSB2.12 7.15,82.48 ; 81.77,126.25 JUSB3.4 ; JUSB3.4 83.24,125.61 ; JUSB3.4 82.6,125.42 ; JUSB3.4 81.97,125.61 ; JUSB3.4 83.43,126.25 ; JUSB3.4 83.24,126.88 ; 364.28,100.87 JCRT1.7 ; JCRT1.7 364.28,101.9 ; JCRT1.7 364.14,101.38 ; 364.28,95.03 JCRT1.10 ; JCRT1.10 364.14,94.51 ; JCRT1.10 364.28,94 ; 364.28,93.89 JCRT1.5 ; JCRT1.5 364.14,93.37 ; JCRT1.5 364.28,92.85 ; 4.4,20.8 H11.1 ; H11.1 9.64,18.6 ; H11.1 6.6,15.56 ; H11.1 4.4,16.4 ; H11.1 6.6,21.64 ; H11.1 3.56,18.6 ; H11.1 8.8,20.8 ; H11.1 8.8,16.4 ; 364.28,104.19 JCRT1.6 ; JCRT1.6 364.28,103.16 ; JCRT1.6 364.14,103.67 ; 77.37,128.68 JUSB3.11 ; JUSB3.11 77.37,126.9 ; JUSB3.11 77.37,130.46 ; JUSB3.11 78.25,126.9 ; JUSB3.11 79.13,126.9 ; 98.77,136.4 JHDMI1.22 ; JHDMI1.22 98.77,134.82 ; JHDMI1.22 99.85,134.82 ; H9.1 7.57,121.53 ; H9.1 6.3,124.53 ; H9.1 8.03,122.8 ; H9.1 4.57,122.8 ; H9.1 5.03,121.53 ; H9.1 6.3,121.07 ; H9.1 7.57,124.07 ; H9.1 5.03,124.07 ; 69.2,133 H13.1 ; H13.1 71.6,135.4 ; H13.1 72.03,134.2 ; H13.1 70.4,132.57 ; H13.1 68.77,134.2 ; H13.1 71.6,133 ; H13.1 70.4,135.83 ; H13.1 69.2,135.4 ; 364.28,98.58 JCRT1.8 ; JCRT1.8 364.14,99.09 ; JCRT1.8 364.28,99.61 ; JUSB1.13 367.71,60.47 ; JUSB1.13 365.05,60.47 ; JUSB1.13 366.38,60.47 ; JUSBC1.6 2.64,120.43 ; JUSBC1.6 3.58,120.02 ; JUSBC1.6 3.58,120.43 ; JUSBC1.4 7.12,116.84 ; JUSBC1.4 6.71,118.85 ; JUSBC1.4 7.12,118.85 ; JUSB3.10 94.83,126.9 ; JUSB3.10 94.83,130.46 ; JUSB3.10 94.83,128.68 ; JUSB3.10 93.95,126.9 ; JUSB3.10 93.07,126.9 ; 352.44,91.04 H22.1 ; H22.1 357.59,93.2 ; H22.1 356.76,91.04 ; H22.1 356.76,95.36 ; H22.1 354.6,90.21 ; H22.1 351.61,93.2 ; H22.1 352.44,95.36 ; H22.1 354.6,96.18 ; JHDMI1.11 110.06,129.86 ; JHDMI1.11 109.14,129.86 ; JHDMI1.11 109.6,129.74 ; 357.15,71.87 JUSB1.4 ; JUSB1.4 356.32,72.7 ; JUSB1.4 356.52,72.06 ; JUSB1.4 356.52,73.33 ; JUSB1.4 357.15,73.53 ; JUSB1.4 357.79,72.06 ; 104.64,129.28 JHDMI1.2 ; JHDMI1.2 105.56,128.36 ; JHDMI1.2 104.52,128.82 ; JHDMI1.2 105.1,128.23 ; JHDMI1.2 104.64,128.36 ; JHDMI1.2 105.56,129.28 ; JHDMI1.2 105.1,129.4 ; 10.84,99.94 JUSB2.10 ; JUSB2.10 14.4,99.06 ; JUSB2.10 14.4,99.94 ; JUSB2.10 12.62,99.94 ; JUSB2.10 14.4,98.18 ; JUSB3.7 86.74,127.12 ; JUSB3.7 86.1,126.92 ; JUSB3.7 85.47,127.12 ; 302.97,122.9 H21.1 ; H21.1 303.4,124.1 ; H21.1 305.8,121.7 ; H21.1 304.6,124.53 ; H21.1 304.6,121.27 ; H21.1 306.23,122.9 ; H21.1 305.8,124.1 ; H21.1 303.4,121.7 ; 363.27,108 JCRT1.17 ; JCRT1.17 363.27,107.28 ; JCRT1.17 363.27,108.72 ; JCRT1.17 364.9,108.72 ; 107.64,129.28 JHDMI1.8 ; JHDMI1.8 108.1,128.23 ; JHDMI1.8 108.56,129.28 ; JHDMI1.8 108.1,129.4 ; JHDMI1.8 108.56,128.36 ; JHDMI1.8 107.64,128.36 ; JUSBC1.5 3.58,107.07 ; JUSBC1.5 2.64,107.07 ; JUSBC1.5 3.58,107.49 ; 363.27,87.18 JCRT1.16 ; JCRT1.16 364.9,87.18 ; JCRT1.16 363.27,87.9 ; JCRT1.16 363.27,88.62 ; JHDMI1.21 117.23,129.42 ; JHDMI1.21 115.47,129.42 ; JHDMI1.21 117.23,127.67 ; JHDMI1.21 116.35,127.67 ; JHDMI1.21 115.47,127.67 ; 118.35,134.82 JHDMI1.23 ; JHDMI1.23 119.43,136.4 ; JHDMI1.23 119.43,134.82 ; JUSBC1.3 7.12,110.66 ; JUSBC1.3 6.81,110.66 ; JUSBC1.3 7.12,108.65 ; JUSB3.13 94.83,134.15 ; JUSB3.13 94.83,135.48 ; JUSB3.13 94.83,136.15 ; JUSB1.12 366.38,77.93 ; JUSB1.12 365.05,77.93 ; JUSB1.12 367.05,77.93 ; JUSBC1.1 8.33,110.21 ; JUSBC1.1 7,108.66 ; JUSBC1.1 8.33,109.43 ; JUSBC1.1 8.33,108.66 ; JUSBC1.2 8.33,118.85 ; JUSBC1.2 8.33,117.3 ; JUSBC1.2 8.33,118.07 ; JUSBC1.2 7,118.85 ; JHDMI1.20 102.73,127.67 ; JHDMI1.20 100.97,127.67 ; JHDMI1.20 100.97,129.42 ; JHDMI1.20 102.73,129.42 ; JHDMI1.20 101.85,127.67 ; 112.6,129.74 JHDMI1.17 ; JHDMI1.17 113.06,129.86 ; JHDMI1.17 112.14,129.86 ; 358.02,68.57 JUSB1.7 ; JUSB1.7 358.02,69.84 ; JUSB1.7 357.82,69.2 ; JUSB2.7 14.19,90.57 ; JUSB2.7 14.19,91.84 ; JUSB2.7 14.38,91.21
  GND2 w0.203: H35.1 132.62,109.87 ; H35.1 129.58,109.87 ; H35.1 131.1,106.27 ; H35.1 133.18,108.35 ; H35.1 131.1,110.43 ; H35.1 129.02,108.35 ; H35.1 132.62,106.83 ; H35.1 129.58,106.83 ; 115.47,131.17 JHDMI1.21 ; JHDMI1.21 117.23,129.42 ; JHDMI1.21 115.47,129.42 ; JHDMI1.21 117.23,127.67 ; JHDMI1.21 115.47,127.67 ; JHDMI1.21 116.35,131.17 ; JHDMI1.21 116.35,127.67 ; 93.95,134.15 JUSB3.13 ; JUSB3.13 93.95,136.81 ; JUSB3.13 94.83,134.15 ; JUSB3.13 94.83,135.48 ; JUSB3.13 94.83,136.81 ; H10.1 6.3,106.43 ; H10.1 7.57,105.97 ; H10.1 5.03,103.43 ; H10.1 8.03,104.7 ; H10.1 5.03,105.97 ; H10.1 6.3,102.97 ; H10.1 7.57,103.43 ; H10.1 4.57,104.7 ; 10.84,99.06 JUSB2.10 ; JUSB2.10 14.4,99.06 ; JUSB2.10 14.4,99.94 ; JUSB2.10 14.4,98.18 ; JUSB2.10 12.62,99.94 ; JUSB2.10 10.84,99.94 ; JHDMI1.5 106.6,130.9 ; JHDMI1.5 106.14,129.86 ; JHDMI1.5 107.06,129.86 ; JHDMI1.5 107.06,130.78 ; JHDMI1.5 106.6,129.74 ; JHDMI1.5 106.14,130.78 ; JUSB3.4 83.24,126.88 ; JUSB3.4 83.43,126.25 ; JUSB3.4 81.97,125.61 ; JUSB3.4 82.6,125.42 ; JUSB3.4 81.77,126.25 ; JUSB3.4 83.24,125.61 ; 77.37,134.15 JUSB3.12 ; JUSB3.12 78.25,136.81 ; JUSB3.12 77.37,136.81 ; JUSB3.12 77.37,135.48 ; JUSB3.12 78.25,134.15 ; H1.1 73.33,81.5 ; H1.1 69.29,79.8 ; H1.1 69.93,81.5 ; H1.1 71.63,77.46 ; H1.1 73.33,78.09 ; H1.1 73.97,79.8 ; H1.1 69.93,78.09 ; H1.1 71.63,82.14 ; H3.1 71.81,54.2 ; H3.1 68.41,50.79 ; H3.1 70.11,54.84 ; H3.1 67.77,52.5 ; H3.1 68.41,54.2 ; H3.1 71.81,50.79 ; H3.1 72.45,52.5 ; H3.1 70.11,50.16 ; JUSBC1.3 6.4,110.66 ; JUSBC1.3 7.12,110.66 ; JUSBC1.3 6.4,108.65 ; JUSBC1.3 5.68,108.65 ; JUSBC1.3 7.12,108.65 ; JUSB2.7 14.19,91.84 ; JUSB2.7 13.55,90.38 ; JUSB2.7 14.19,90.57 ; JUSB2.7 13.55,92.04 ; JUSB2.7 14.38,91.21 ; JUSB1.11 359.58,77.93 ; JUSB1.11 361.36,77.05 ; JUSB1.11 357.8,76.17 ; JUSB1.11 357.8,77.05 ; JUSB1.11 357.8,77.93 ; JUSB1.11 361.36,77.93 ; 78.25,126.9 JUSB3.11 ; JUSB3.11 78.25,130.46 ; JUSB3.11 77.37,128.68 ; JUSB3.11 77.37,126.9 ; JUSB3.11 79.13,126.9 ; JUSB3.11 77.37,130.46 ; 364.14,103.67 JCRT1.6 ; JCRT1.6 364.28,103.16 ; JCRT1.6 365.32,104.19 ; JCRT1.6 364.28,104.19 ; JCRT1.6 364.8,104.34 ; 99.85,134.82 JHDMI1.22 ; JHDMI1.22 98.77,137.98 ; JHDMI1.22 100.93,134.82 ; JHDMI1.22 100.93,136.4 ; JHDMI1.22 100.93,137.98 ; JHDMI1.22 98.77,136.4 ; JHDMI1.22 98.77,134.82 ; JHDMI1.22 99.85,137.98 ; JHDMI1.2 105.56,129.28 ; JHDMI1.2 105.1,128.23 ; JHDMI1.2 104.52,128.82 ; JHDMI1.2 105.1,129.4 ; JHDMI1.2 104.64,129.28 ; JHDMI1.2 104.64,128.36 ; JHDMI1.2 105.56,128.36 ; 126.97,81.3 H2.1 ; H2.1 131.01,79.6 ; H2.1 131.01,83 ; H2.1 129.31,83.64 ; H2.1 127.61,79.6 ; H2.1 127.61,83 ; H2.1 129.31,78.96 ; H2.1 131.65,81.3 ; JUSB3.10 93.95,130.46 ; JUSB3.10 94.83,128.68 ; JUSB3.10 94.83,130.46 ; JUSB3.10 93.95,126.9 ; JUSB3.10 93.07,126.9 ; JUSB3.10 94.83,126.9 ; 109.47,2.9 H14.1 ; H14.1 111.1,1.27 ; H14.1 109.9,1.7 ; H14.1 112.73,2.9 ; H14.1 109.9,4.1 ; H14.1 111.1,4.53 ; H14.1 112.3,1.7 ; H14.1 112.3,4.1 ; 364.28,95.03 JCRT1.10 ; JCRT1.10 364.28,94 ; JCRT1.10 364.14,94.51 ; SW1.5 206.48,4.21 ; SW1.5 205.72,2.45 ; SW1.5 205.72,4.46 ; SW1.5 204.95,4.21 ; SW1.5 206.72,3.45 ; SW1.5 204.95,2.69 ; SW1.5 204.71,3.45 ; SW1.5 206.48,2.69 ; 362.56,18.6 H23.1 ; H23.1 363.4,16.4 ; H23.1 367.8,16.4 ; H23.1 368.64,18.6 ; H23.1 365.6,15.56 ; H23.1 365.6,21.64 ; H23.1 367.8,20.8 ; H23.1 363.4,20.8 ; JHDMI1.23 119.43,136.4 ; JHDMI1.23 117.27,134.82 ; JHDMI1.23 118.35,134.82 ; JHDMI1.23 119.43,137.98 ; JHDMI1.23 117.27,137.98 ; JHDMI1.23 119.43,134.82 ; JHDMI1.23 118.35,137.98 ; JHDMI1.23 117.27,136.4 ; JHDMI1.17 113.06,130.78 ; JHDMI1.17 112.14,130.78 ; JHDMI1.17 112.6,130.9 ; JHDMI1.17 112.6,129.74 ; JHDMI1.17 112.14,129.86 ; JHDMI1.17 113.06,129.86 ; JCRT1.16 364.9,88.62 ; JCRT1.16 366.53,87.9 ; JCRT1.16 363.27,88.62 ; JCRT1.16 363.27,87.9 ; JCRT1.16 366.53,87.18 ; JCRT1.16 364.9,87.18 ; JCRT1.16 366.53,88.62 ; JCRT1.16 363.27,87.18 ; H17.1 186.1,6.68 ; H17.1 184.12,5.93 ; H17.1 184.12,1.97 ; H17.1 188.08,5.93 ; H17.1 188.83,3.95 ; H17.1 186.1,1.22 ; H17.1 188.08,1.97 ; H17.1 183.37,3.95 ; JCRT1.17 366.53,107.28 ; JCRT1.17 363.27,107.28 ; JCRT1.17 366.53,108.72 ; JCRT1.17 364.9,108.72 ; JCRT1.17 364.9,107.28 ; JCRT1.17 366.53,108 ; JCRT1.17 363.27,108 ; JCRT1.17 363.27,108.72 ; 365.05,60.47 JUSB1.13 ; JUSB1.13 367.71,61.35 ; JUSB1.13 366.38,60.47 ; JUSB1.13 367.71,60.47 ; JUSB1.13 365.05,61.35 ; JUSB2.4 15.69,87.07 ; JUSB2.4 15.69,88.34 ; JUSB2.4 15.05,88.54 ; JUSB2.4 15.88,87.71 ; JUSB2.4 15.05,86.88 ; JUSB2.4 14.42,88.34 ; SW1.4 212.02,4.46 ; SW1.4 212.78,2.69 ; SW1.4 212.78,4.21 ; SW1.4 211.01,3.45 ; SW1.4 211.25,2.69 ; SW1.4 212.02,2.45 ; SW1.4 213.02,3.45 ; SW1.4 211.25,4.21 ; JLOM1.14 321.39,132.9 ; JLOM1.14 321.39,134.65 ; JLOM1.14 320.48,131.15 ; JLOM1.14 319.56,132.9 ; JLOM1.14 319.56,134.65 ; JLOM1.14 320.48,134.65 ; JLOM1.14 319.56,131.15 ; 69.2,133 H13.1 ; H13.1 71.6,133 ; H13.1 70.4,132.57 ; H13.1 68.77,134.2 ; H13.1 69.2,135.4 ; H13.1 71.6,135.4 ; H13.1 70.4,135.83 ; H13.1 72.03,134.2 ; JUSBC1.2 7,118.85 ; JUSBC1.2 5.67,118.85 ; JUSBC1.2 8.33,118.07 ; JUSBC1.2 8.33,118.85 ; JUSBC1.2 8.33,117.3 ; 94.62,108.35 H34.1 ; H34.1 95.18,109.87 ; H34.1 96.7,110.43 ; H34.1 98.22,109.87 ; H34.1 95.18,106.83 ; H34.1 96.7,106.27 ; H34.1 98.22,106.83 ; H34.1 98.78,108.35 ; 4.49,82.48 JUSB2.12 ; JUSB2.12 7.15,82.48 ; JUSB2.12 5.82,82.48 ; JUSB2.12 7.15,83.36 ; JUSB2.12 4.49,83.36 ; 357.8,62.23 JUSB1.10 ; JUSB1.10 361.36,60.47 ; JUSB1.10 357.8,61.35 ; JUSB1.10 361.36,61.35 ; JUSB1.10 359.58,60.47 ; JUSB1.10 357.8,60.47 ; H11.1 8.8,20.8 ; H11.1 6.6,21.64 ; H11.1 8.8,16.4 ; H11.1 3.56,18.6 ; H11.1 4.4,20.8 ; H11.1 9.64,18.6 ; H11.1 6.6,15.56 ; H11.1 4.4,16.4 ; JHDMI1.11 109.6,130.9 ; JHDMI1.11 109.14,130.78 ; JHDMI1.11 109.6,129.74 ; JHDMI1.11 110.06,129.86 ; JHDMI1.11 110.06,130.78 ; JHDMI1.11 109.14,129.86 ; H7.1 328.24,31.39 ; H7.1 326.75,27.87 ; H7.1 329.73,27.87 ; H7.1 326.21,29.36 ; H7.1 328.24,27.33 ; H7.1 329.73,30.85 ; H7.1 330.27,29.36 ; H7.1 326.75,30.85 ; 0.52,107.07 JUSBC1.5 ; JUSBC1.5 1.7,107.07 ; JUSBC1.5 1.7,108.73 ; JUSBC1.5 3.58,107.9 ; JUSBC1.5 0.52,107.9 ; JUSBC1.5 3.58,107.07 ; JUSBC1.5 0.52,108.73 ; JUSBC1.5 3.58,108.73 ; 131.35,51.98 H4.1 ; H4.1 133.05,56.02 ; H4.1 135.39,53.68 ; H4.1 130.71,53.68 ; H4.1 134.75,55.38 ; H4.1 134.75,51.98 ; H4.1 133.05,51.34 ; H4.1 131.35,55.38 ; 100.97,127.67 JHDMI1.20 ; JHDMI1.20 102.73,127.67 ; JHDMI1.20 100.97,129.42 ; JHDMI1.20 101.85,127.67 ; JHDMI1.20 102.73,131.17 ; JHDMI1.20 102.73,129.42 ; JHDMI1.20 101.85,131.17 ; 0.52,118.77 JUSBC1.6 ; JUSBC1.6 1.7,118.77 ; JUSBC1.6 3.58,118.77 ; JUSBC1.6 0.52,120.43 ; JUSBC1.6 1.7,120.43 ; JUSBC1.6 3.58,119.6 ; JUSBC1.6 0.52,119.6 ; JUSBC1.6 3.58,120.43 ; 108.1,128.23 JHDMI1.8 ; JHDMI1.8 108.56,128.36 ; JHDMI1.8 108.1,129.4 ; JHDMI1.8 108.56,129.28 ; JHDMI1.8 107.64,128.36 ; JHDMI1.8 107.64,129.28 ; H22.1 356.76,95.36 ; H22.1 356.76,91.04 ; H22.1 352.44,91.04 ; H22.1 352.44,95.36 ; H22.1 357.59,93.2 ; H22.1 354.6,90.21 ; H22.1 354.6,96.18 ; H22.1 351.61,93.2 ; JUSB1.4 357.79,72.06 ; JUSB1.4 356.32,72.7 ; JUSB1.4 356.52,73.33 ; JUSB1.4 357.15,73.53 ; JUSB1.4 357.15,71.87 ; JUSB1.4 356.52,72.06 ; 4.49,99.06 JUSB2.13 ; JUSB2.13 5.82,99.94 ; JUSB2.13 7.15,99.94 ; JUSB2.13 4.49,99.94 ; JUSB2.13 7.15,99.06 ; 364.14,93.37 JCRT1.5 ; JCRT1.5 364.28,92.85 ; JCRT1.5 365.32,92.85 ; JCRT1.5 364.28,93.89 ; JCRT1.5 364.8,92.71 ; 364.28,101.9 JCRT1.7 ; JCRT1.7 364.28,100.87 ; JCRT1.7 364.14,101.38 ; 365.05,77.93 JUSB1.12 ; JUSB1.12 366.38,77.93 ; JUSB1.12 367.71,77.05 ; JUSB1.12 367.71,77.93 ; JUSB1.12 365.05,77.05 ; 333.9,96.63 H8.1 ; H8.1 331.87,98.66 ; H8.1 332.41,97.17 ; H8.1 335.39,100.15 ; H8.1 333.9,100.69 ; H8.1 335.93,98.66 ; H8.1 332.41,100.15 ; H8.1 335.39,97.17 ; JUSB3.7 86.74,127.12 ; JUSB3.7 85.27,127.75 ; JUSB3.7 86.1,126.92 ; JUSB3.7 86.93,127.75 ; JUSB3.7 85.47,127.12 ; 358.02,68.57 JUSB1.7 ; JUSB1.7 358.65,70.03 ; JUSB1.7 357.82,69.2 ; JUSB1.7 358.65,68.37 ; JUSB1.7 358.02,69.84 ; 364.14,99.09 JCRT1.8 ; JCRT1.8 364.28,98.58 ; JCRT1.8 364.28,99.61 ; 139.76,136 H16.1 ; H16.1 140.4,134.3 ; H16.1 142.1,138.34 ; H16.1 143.8,134.3 ; H16.1 140.4,137.7 ; H16.1 144.44,136 ; H16.1 142.1,133.66 ; H16.1 143.8,137.7 ; JUSB2.11 14.4,84.24 ; JUSB2.11 10.84,83.36 ; JUSB2.11 12.62,82.48 ; JUSB2.11 14.4,82.48 ; JUSB2.11 14.4,83.36 ; JUSB2.11 10.84,82.48 ; 6.3,121.07 H9.1 ; H9.1 7.57,124.07 ; H9.1 5.03,121.53 ; H9.1 6.3,124.53 ; H9.1 5.03,124.07 ; H9.1 7.57,121.53 ; H9.1 4.57,122.8 ; H9.1 8.03,122.8 ; JUSBC1.4 7.12,118.85 ; JUSBC1.4 7.12,116.84 ; JUSBC1.4 6.4,118.85 ; JUSBC1.4 6.4,116.84 ; JUSBC1.4 5.68,118.85 ; H21.1 305.8,121.7 ; H21.1 304.6,121.27 ; H21.1 305.8,124.1 ; H21.1 304.6,124.53 ; H21.1 306.23,122.9 ; H21.1 302.97,122.9 ; H21.1 303.4,121.7 ; H21.1 303.4,124.1 ; 7,108.66 JUSBC1.1 ; JUSBC1.1 5.67,108.66 ; JUSBC1.1 8.33,108.66 ; JUSBC1.1 8.33,110.21 ; JUSBC1.1 8.33,109.43
  BOTTOM w0.076: PR1736.2 99.04,83.82 99.15,83.82 ; v2(84.92,77.52) 84.59,77.2 UC1.BJ34 ; UT5.L1 30.38,91.06 v2(30.27,91.17) ; 82.71,58.59 82.64,58.52 81.52,58.52 81.2,58.84 UC1.BR9 ; 99.93,83.03 RC141.2
  BOTTOM w0.089: v2(188.98,37.37) 189.24,37.12 190,37.12 190.19,37.31 v2(191.16,37.31) ; UH1.V4 201.13,41.67 201.13,41.46 200.92,41.24 200.92,40.42 201.39,39.95 201.39,39.38 v2(201.55,39.22) 201.68,39.22 201.88,39.41 UH1.Y9 ; v2(197.21,45.88) 197.21,45.69 197.47,45.44 198.48,45.44 198.6,45.33 199.31,45.33 199.92,44.72 199.92,43.53 200.11,43.34 200.13,43.34 200.23,43.23 200.23,43.23 200.25,43.21 200.25,42.95 ; UH1.AA5 202.25,41.64 v2(202.05,41.44)
  BOTTOM w0.102: UH1.A8 192.85,40.08 192.89,40.04 193.07,40.04 193.09,40.02 193.44,40.02 193.46,40.05 194.12,40.05 UH1.D8 ; v2(188.98,37.37) v2(188.98,38.39) 188.98,38.56 189.32,38.9 190.28,38.9 190.92,38.26 193.1,38.26 193.12,38.28 193.41,38.28 193.61,38.08 UH1.C12 ; v2(218.53,33.94) 218.16,33.94 217.68,33.46 UH1.BG22 ; v2(129.19,85.34) 128.14,86.38 v3(127.81,86.38) ; v3(191.23,49.03) 191.23,48.72 v2(191.49,48.46) ; UH1.D12 194.09,37.82 193.12,37.82 192.92,37.62 192.62,37.62 192.54,37.69 191.54,37.69 v2(191.16,37.31) ; v3(45.75,58.56) 45.83,58.56 v2(46.28,59.01)
  BOTTOM w0.127: v3(135.94,86.89) 135.78,86.89 v2(134.92,87.75) ; UH1.T4 200.06,42.12 200.25,42.3 200.25,42.95 ; UC1.C37 119.58,79.33 119.24,79.67 119.02,79.67 UC1.D38 ; 201.62,42.72 201.47,42.57 201.47,42.56 201.46,42.55 201.46,42 UH1.V4
  BOTTOM w0.152: UH1.AH38 v2(206.64,25.38) ; 206.02,31.4 UH1.AJ27 ; 206.02,31.4 UH1.AJ25 ; 206.02,31.4 UH1.AG25 ; 206.02,31.4 UH1.AG27 206.02,30.62 ; UH1.AJ27 206.02,30.62 ; UH1.AJ27 206.77,31.38 v2(206.77,31.47) ; UH1.AE38 v2(205.21,25.46) ; v2(198.34,27.97) 198.16,28.15 UH1.M32 ; UC1.BN4 82.36,55.39 82.66,55.7 UC1.BM5 ; UH1.AN38 v2(208.98,25.34) ; UH1.AJ30 206.73,29.14 v2(206.73,29.08) 206.73,29.01 UH1.AJ31 206.02,29.07 ; UH1.AJ30 206.02,29.07 ; UH1.AJ30 206.02,29.85 ; UH1.AJ30 206.78,29.84 v2(206.78,29.92) ; v2(198.02,34.32) 198.18,34.16 UH1.M21 ; UC1.AJ3 UC1.AJ2 UC1.AJ1 v2(100.31,52.63) ; UC1.AJ3 UC1.AJ4 UC1.AJ5 UC1.AJ6 ; UC1.AJ3 99.98,54.15 99.87,54.15 ; v2(112.93,52.45) 112.95,52.47 112.95,52.98 112.88,53.04 UC1.N1 UC1.N2 UC1.N3 ; v2(87.29,52.21) 87.74,52.66 UC1.BE1 UC1.BE2 87.74,53.95 87.75,53.96 87.75,54.34 87.74,54.35 UC1.BE3 ; v2(114.96,54.19) 115.24,54.48 UC1.K3 ; UC1.AR3 UC1.AR2 UC1.AR1 v2(95.28,52.62) ; UH1.F43 UH1.E42 v2(194.44,24.06) ; v2(202.27,19.47) 202.28,19.47 202.4,19.59 UH1.AA49 ; UH1.AK4 207.13,41.84 207.28,42 ; v2(196.56,29.05) 196.66,29.15 UH1.J29 ; UH1.AM49 207.95,18.2 208.03,18.13 208.03,18.12 208.04,18.11 208.04,17.94 208.75,17.23 208.75,16.3 v2(208.77,16.29) ; 202.18,31.44 v2(202.18,31.36) ; v2(202.18,31.36) UH1.W25 201.76,31.86 202.14,32.24 ; v2(202.18,31.36) 201.83,31.01 UH1.W27 ; v2(205.21,21.65) 205.13,21.73 UH1.AE46 ; v2(202.96,27.69) 203.02,27.74 UH1.AC33 ; UC1.AC4 105.22,55.13 v2(104.89,54.8) ; UC1.AC4 UC1.AC3 UC1.AC2 105.34,53.78 105.33,53.78 105.34,53.65 UC1.AC1 105.34,52.99 v2(105.1,52.76) ; UC1.AC4 105.34,55.3 105.35,55.31 105.35,55.64 105.34,55.65 UC1.AC5 ; 206.02,29.07 UH1.AG30 206.02,29.85 ; UH1.AC46 203.03,21.73 v2(202.95,21.65) ; UH1.BB41 v2(213.72,24.06) 213.72,24.54 UH1.BC40 ; v2(198.72,24.83) 199.23,25.34 UH1.R38 ; UH1.C25 193.94,31.79 193.98,31.75 v2(194.36,31.75) 194.52,31.59 UH1.E26 ; 207.28,42 207.28,41.95 207.4,41.83 207.4,41.69 207.57,41.51 207.75,41.34 208.01,41.34 208.04,41.37 208.08,41.37 208.25,41.55 208.76,41.55 209.05,41.84 UH1.AP4 ; 207.28,42 v2(207.28,42.05) ; UC1.K3 115.4,54.6 115.41,54.61 115.41,54.99 115.4,55 UC1.K4 ; UC1.K3 UC1.K2 UC1.K1 ; v2(199.63,40.39) 199.6,40.42 199.17,40.42 199.17,40.42 199.12,40.42 198.83,40.71 198.83,41.25 198.56,41.52 198.56,41.75 v2(198.66,41.86) ; v2(199.63,40.39) 200.21,40.39 UH1.T7 200.28,40.46 UH1.T5 200.06,41.86 UH1.T4 199.82,42.1 UH1.R4 ; v2(199.63,40.39) 199.63,39.93 199.58,39.89 199.58,39.46 199.8,39.24 199.8,38.68 200.25,38.23 v2(200.31,38.23) 200.33,38.2 UH1.U12 200.82,38.27 201.12,38.57 v2(201.53,38.57) ; 206.02,29.85 UH1.AJ28 ; 206.02,29.85 UH1.AG28 206.02,30.62 ; UH1.AM1 207.95,43.7 208.13,43.87 208.13,45.43 209.41,46.72 209.41,47.42 210.16,48.16 210.33,48.34 v2(210.33,48.94) ; UH1.AD2 UH1.AD1 204.08,44.86 v2(203.99,44.95) ; UH1.BG37 215.39,25.96 215.71,26.27 216.4,26.27 216.82,25.84 v2(217.08,25.84) ; UH1.R4 UH1.P4 198.67,41.84 v2(198.66,41.86) ; UH1.R4 199.61,41.59 v2(199.48,41.46) ; UH1.R4 UH1.R3 ; 206.02,30.62 UH1.AJ28 ; UH1.U38 v2(200.28,25.37) ; v2(198.66,41.86) 198.51,41.89 UH1.M5 ; v2(194.44,35.11) 194.44,34.64 UH1.E19 ; v2(194.44,35.11) UH1.E17 ; v2(194.44,35.11) 194.28,35.74 UH1.D17 ; UH1.J4 196.9,41.84 196.63,41.57 v2(196.63,41.5) 196.23,41.5 195.88,41.14 UH1.G6 UH1.H8 UH1.J9 UH1.J10 UH1.K11 ; UC1.T3 110.25,54.48 v2(109.93,54.17) ; UC1.T3 UC1.T4 UC1.T5 ; UC1.T3 UC1.T2 UC1.T1 110.37,53.08 110.37,53.08 110.37,52.77 109.96,52.36 v2(109.96,52.36) ; 201.78,36.1 UH1.Y17 ; UH1.Y17 201.78,35.53 ; UH1.Y17 202.35,35.53 ; UH1.Y17 202.35,36.1 ; 203.69,35.27 UH1.AD19 204.47,35.27 ; UH1.AJ25 206.02,32.17 ; UH1.AJ25 206.72,31.47 v2(206.77,31.47) ; UH1.AJ25 206.79,32.17 UH1.AK25 206.87,31.47 v2(206.77,31.47) ; 206.02,32.17 UH1.AG23 205.54,32.56 205.23,32.24 ; 206.02,32.17 UH1.AG25 ; UC1.W3 107.76,54.48 107.41,54.12 v2(107.41,54.15) ; UC1.W3 UC1.W4 UC1.W5 ; UC1.W3 UC1.W2 107.85,53.7 107.85,53.48 UC1.W1 107.85,52.56 v2(107.41,52.19) ; v2(213.72,39.51) 213.72,39.03 UH1.BC10 ; v2(213.72,39.51) UH1.BC8 ; v2(213.72,39.51) UH1.BB9 ; 202.14,32.24 202.53,31.86 UH1.AA25 ; 202.14,32.24 v2(202.14,32.95) v2(202.14,33.72) UH1.AA20 ; UH1.J40 196.92,24.52 UH1.K39 197.17,24.71 197.64,25.18 197.93,25.18 198.09,25.34 v2(198.15,25.34) UH1.N38 ; UH1.J48 196.8,20.84 UH1.J47 196.8,21.26 v2(196.5,21.56) 196.5,21.57 196.34,21.73 196.34,21.97 195.88,22.43 UH1.G44 ; v2(205.24,38.24) 205.11,38.11 UH1.AE12 ; 206.81,34.51 v2(206.81,34.51) 206.77,34.51 UH1.AJ19 ; v2(198.94,29.26) 199.02,29.33 UH1.P29 ; UH1.V46 200.83,21.73 v2(200.76,21.65) ; v2(206.77,31.47) 207.18,31.07 UH1.AK27 v2(206.75,30.58) UH1.AJ28 ; UH1.AL12 207.11,37.98 206.97,37.99 v2(206.88,38.08) 206.8,37.99 206.29,37.99 UH1.AH12 ; UH1.AC4 204.05,41.84 v2(204.1,41.8) ; v2(199.33,30.23) 199.34,30.23 UH1.R29 ; UH1.T17 200.5,35.6 UH1.U17 ; UH1.R16 UH1.N16 UH1.M16 198.45,35.82 v2(198.45,35.74) 198.16,35.46 UH1.M18 ; UC1.N3 112.77,54.48 v2(112.44,54.15) ; UC1.N3 UC1.N4 UC1.N5 ; UH1.F41 194.83,23.93 194.77,23.95 v2(194.44,24.06) ; UH1.Y10 201.93,38.96 v2(201.53,38.57) ; v2(206.78,29.92) 207.18,29.52 UH1.AK30 ; v2(206.78,29.92) 206.72,29.92 UH1.AJ28 ; v2(206.78,29.92) 206.87,29.92 UH1.AK28 ; UH1.BC26 213.72,31.13 v2(213.72,30.66) ; v2(201.53,38.57) 201.39,38.72 201.39,39.06 v2(201.55,39.22) ; v2(213.72,32.91) 213.72,32.44 UH1.BC24 ; v2(202.92,33.72) UH1.AA20 ; UH1.AA20 v2(202.92,34.5) ; UH1.Y12 201.77,38.19 v2(201.55,37.96) ; v2(213.33,22.7) UH1.BD43 214.13,22.8 UH1.BE44 ; v2(213.33,22.7) UH1.BC45 ; v2(213.33,22.7) UH1.BB43 ; 198.71,27.43 UH1.N34 UH1.R34 200.17,27.43 200.21,27.47 ; UH1.BG17 216.06,35.66 v2(216.12,35.72) ; UH1.AD22 204.47,33.72 UH1.AF22 205.24,33.72 UH1.AG22 UH1.AJ20 ; UH1.AN16 UH1.AR16 UH1.AT16 210.19,35.95 v2(210.18,35.59) 210.18,35.22 UH1.AT18 ; UH1.AE4 205.13,41.84 v2(205.21,41.92) ; UH1.AJ19 206.02,34.5 UH1.AJ20 ; UH1.AJ19 206.79,35.27 UH1.AK19 207.57,34.5 UH1.AK20 206.79,33.72 UH1.AJ20 ; UH1.N12 198.24,38.23 v2(198.08,38.07) ; UH1.U17 201.11,36.2 ; UH1.U17 UH1.U15 ; UH1.U17 201.11,35.63 ; UH1.U17 200.54,36.2 ; UH1.BA44 212.28,22.41 211.8,21.93 v2(211.8,21.65) 211.73,21.73 UH1.AW46 ; v2(204.14,18.88) 204.08,18.93 UH1.AD49 ; UH1.BC35 213.72,26.74 v2(213.72,26.27) ; UH1.P46 198.64,21.73 v2(198.56,21.65) ; UH1.BG28 215.63,29.87 218.98,29.87 219.23,30.12 221.16,30.12 221.66,29.62 v2(221.83,29.62) ; v2(207.86,25.18) 207.67,25.37 UH1.AL38 ; v2(194.44,24.06) 194.44,24.54 UH1.E40 ; v2(201.52,25.38) UH1.Y38 ; UH1.R26 199.78,31.33 v2(199.48,31.63) ; v2(202.92,34.5) UH1.AB19 ; v2(202.92,34.5) UH1.AA19 ; UH1.T49 200.55,19.97 200.73,19.79 v2(200.87,19.79) ; UH1.AG1 205.76,44.63 v2(205.83,44.7) ; UH1.BC13 v2(213.72,37.3) 213.72,36.83 UH1.BC15 ; UH1.E24 194.44,32.44 v2(194.44,32.91) UH1.E22 ; v2(192.15,28.04) 192.36,28.04 192.49,27.91 UH1.A33 ; v2(213.72,28.46) 213.72,28.93 UH1.BC31 ; UH1.M34 v2(198.08,26.69) 198.46,26.69 UH1.N35 ; UH1.U33 v2(201.52,27.75) 201.52,27.76 UH1.Y33 ; UH1.E13 v2(194.44,37.3) 194.44,36.83 UH1.E15 UH1.D16 ; v2(191.8,30.61) 191.8,30.51 192.2,30.11 UH1.A28 ; UH1.A8 192.66,40.18 191.86,40.18 191.7,40.34 v2(191.7,40.36) ; v2(202.91,29.06) UH1.AA31 ; v2(202.91,29.06) 202.91,29.08 ; v2(202.91,29.06) 202.53,29.44 UH1.AA30 ; v2(202.91,29.06) 202.93,29.06 UH1.AB31 ; UH1.AN12 v2(208.98,38.23) ; UH1.AT1 210.18,44.68 210.97,45.48 210.97,46.53 CC302.2 ; UC1.BB6 90.32,56.36 90.32,55.85 UC1.BB5 90.25,55.65 90.27,55.64 90.27,55.26 90.25,55.25 UC1.BB4 90.25,55 90.27,54.99 90.27,54.61 90.25,54.6 UC1.BB3 90.28,54.44 90.28,53.86 UC1.BB2 90.25,53.69 90.25,53.68 90.25,53.32 90.25,53.31 UC1.BB1 90.25,53.04 90.3,52.99 90.3,52.64 v2(89.9,52.24) ; UH1.AG25 205.63,31.84 205.23,32.24 ; v2(191.88,24.76) 191.96,24.76 192.77,25.57 UH1.A37 ; UH1.AC38 v2(202.95,25.46) ; UH1.AR38 209.92,25.34 v2(210.02,25.24) 210.17,25.24 210.34,25.07 210.6,25.07 210.72,24.96 210.81,24.96 UH1.AV39 211.24,24.52 UH1.AW40 ; UH1.AF28 v2(204.49,30.6) ; UH1.N37 v2(198.15,26.1) ; v2(199.18,38.23) UH1.R12 ; UH1.M49 197.98,19.59 197.84,19.45 v2(197.78,19.45) ; v2(210.22,34.22) 209.98,33.98 UH1.AT21 ; UH1.E35 194.55,26.81 194.94,27.2 194.94,27.7 195.26,28.01 v2(195.41,28.01) ; UH1.AN34 UH1.AR34 ; UH1.AT26 v2(209.91,30.66) ; UH1.E33 v2(194.44,28.46) ; v2(194.44,28.46) 194.44,28.93 UH1.E31 ; v2(194.44,28.46) UH1.D33 ; v2(210.07,32.92) 209.91,32.76 UH1.AT24 ; UH1.E8 194.57,39.94 194.33,39.55 194.35,39.48 v2(194.33,39.44) 194.34,39.43 194.34,39.13 UH1.E10 ; 200.66,44.08 200.95,43.79 201.01,43.79 201.15,43.65 ; UH1.E31 UH1.D30 ; UH1.E31 UH1.C30 ; UH1.P26 v2(199.02,30.69) ; v2(79.78,54.2) 79.85,54.28 80.31,54.42 UC1.BT3 ; UH1.J26 v2(196.73,30.69) ; UH1.AC12 202.9,38.11 v2(202.85,38.06) ; UH1.AW10 UH1.AV11 ; 200.7,34.39 UH1.V20 v2(201.37,33.72) UH1.V22 ; 205.23,32.24 204.85,31.87 UH1.AF25 204.47,32.17 UH1.AD25 203.69,32.17 UH1.AB25 ; UH1.AK46 207.28,21.73 v2(207.38,21.62) ; UH1.BG33 215.39,27.48 v2(215.44,27.43) ; UH1.AH33 206.55,27.76 v2(206.62,27.69) 206.69,27.75 UH1.AL33 ; UC1.BH5 UC1.BH4 UC1.BH3 UC1.BH2 ; UH1.AT29 209.94,29.73 v2(209.94,29.13) ; v2(213.72,35.11) 213.72,34.64 UH1.BC19 ; UH1.BA14 v2(212.21,37.57) ; v2(102.83,52.68) UC1.AF1 UC1.AF2 UC1.AF3 UC1.AF4 103.26,55.56 103.26,56.02 UC1.AE6 ; UH1.AE33 v2(205.21,27.74) ; UH1.M24 v2(198.25,32.91)
  BOTTOM w0.203: UC1.BA11 UC1.BA12 90.81,60.34 v2(90.43,60.71) 90.07,60.35 89.99,60.35 UC1.BB12 89.84,60.48 89.75,60.48 v2(89.52,60.71) ; UC1.BA11 91.1,59.69 v2(91.33,59.92) ; UC1.BA11 UC1.BA10 ; 82.56,60.03 82.31,60.28 UC1.BN12 ; 82.56,60.03 82.94,60.41 UC1.BM12 83.27,60.73 v2(83.27,60.79) 83.27,60.86 UC1.BL13 83.93,61.52 83.99,61.52 ; 82.56,60.03 UC1.BM11 82.96,59.58 v2(83.31,59.23) 82.96,58.88 UC1.BM9 82.71,58.59 82.71,58.3 UC1.BM8 82.71,57.8 82.71,57.52 UC1.BM7 UC1.BN7 ; v2(96.73,76.87) 96.66,76.87 ; 96.66,76.87 UC1.AP34 ; 96.66,76.87 96.65,76.87 UC1.AP33 ; v2(96.83,58.78) v2(96.84,59.41) 96.84,60.05 v2(96.83,60.05) ; v2(96.83,58.78) v2(96.83,58.14) ; v2(96.83,58.78) 96.58,59.04 UC1.AP10 ; 117.5,54.15 UC1.F2 117.82,53.9 117.89,53.96 117.89,54.34 117.82,54.4 UC1.F3 ; 117.5,54.15 v2(117.43,54.15) ; 117.5,54.15 UC1.F3 ; UC1.N9 112.95,58.39 113.23,58.66 v2(113.29,58.66) 113.29,58.19 UC1.N8 ; UC1.N9 UC1.N8 ; UC1.N9 UC1.N10 UC1.N11 ; UC1.H35 116.41,78.25 116.27,78.25 UC1.J36 116.33,78.82 v2(116.38,78.82) ; v2(120.04,64.16) 119.68,64.51 UC1.C17 119.37,64.89 119.37,65.03 UC1.D18 ; UC1.BC13 88.85,60.99 v2(88.6,60.74) ; UC1.BC13 UC1.BC12 ; UC1.BC13 UC1.BC14 ; UC1.AG10 102.24,59.41 v2(102.33,59.41) ; UC1.BP33 81.91,75.91 81.91,75.77 UC1.BN31 82.62,75.06 v2(82.62,75.01) 82.62,74.9 UC1.BN30 ; v2(79.36,55.95) 79.39,55.97 80.34,55.97 UC1.BT5 ; UC1.T9 110.09,58.25 110.11,58.24 110.11,57.89 110.09,57.88 UC1.T8 UC1.T7 109.84,56.84 109.84,56.74 UC1.U6 UC1.V6 108.44,56.18 108.25,56.18 UC1.W5 ; UC1.T9 110.17,58.39 v2(110.56,58.78) 110.35,58.78 UC1.T10 ; UC1.T9 UC1.T10 ; UC1.AM37 97.98,79.15 v2(98.3,79.48) 97.97,79.8 UC1.AM38 ; UC1.K9 115.6,58.48 115.6,58.94 UC1.K10 ; UC1.K9 115.6,58.29 115.6,57.83 UC1.K8 ; UC1.K9 115.45,58.39 v2(115.08,58.75) 115.37,59.04 UC1.K10 ; UC1.BM38 83.1,79.81 83.45,80.16 v2(83.48,80.16) 83.49,80.16 83.81,79.84 UC1.BL38 ; UC1.BH6 85.13,56.43 v2(84.78,56.08) ; UC1.BH6 85.4,56.61 UC1.BH7 ; UC1.BH6 UC1.BG6 UC1.BF6 86.92,56.43 v2(87.28,56.07) 87.43,55.92 87.6,55.92 UC1.BE5 ; UC1.BH6 85.22,56.33 85.26,56.29 85.26,55.91 85.22,55.87 UC1.BH5 85.08,55.78 v2(84.78,56.08) ; UC1.BN2 82.62,53.83 UC1.BM2 82.83,54.24 82.83,54.76 UC1.BM3 82.86,54.99 v2(83.14,55.28) 82.86,55.56 UC1.BM5 ; UC1.H32 117.04,76.14 117.2,76.14 v2(117.33,76.01) UC1.F31 ; UC1.G16 117.08,63.73 v2(117.41,63.4) 117.73,63.08 UC1.F15 ; UC1.AL9 UC1.AL10 99.5,59.41 v2(99.58,59.41) v2(99.58,58.78) ; UC1.AL9 99.19,58.39 v2(99.58,58.78) ; UC1.AL9 UC1.AL8 ; JEDP1.6 121.15,106.43 121.15,107.42 v2(120.34,108.23) ; UC1.BR7 81.01,57.38 v2(81.28,57.66) 81.66,57.29 UC1.BP7 UC1.BN7 ; UC1.BF33 86.96,76.55 v2(87.28,76.87) 86.95,77.2 UC1.BF34 ; v2(94.08,60.7) 93.88,60.5 93.72,60.34 UC1.AU12 UC1.AU11 ; UC1.AN6 96.91,56.38 UC1.AN5 97.23,55.45 v2(97.4,55.45) 97.73,55.78 UC1.AM5 ; 95.92,74.93 95.91,74.93 95.59,75.25 UC1.AR31 ; 95.92,74.93 UC1.AR30 ; 95.92,74.93 v2(95.94,74.93) ; UC1.Y10 UC1.Y9 UC1.Y8 UC1.Y7 107.1,56.84 106.69,56.84 106.58,56.73 106.48,56.73 UC1.AB6 UC1.AC6 105.34,56.3 105.35,56.29 105.35,55.91 105.34,55.9 UC1.AC5 ; UC1.Y10 107.44,59.04 v2(107.81,59.41) 107.63,59.59 107.62,59.59 107.52,59.69 UC1.Y11 UC1.Y10 ; UC1.AF14 UC1.AF13 UC1.AF12 102.45,60.01 v2(102.29,60.01) 101.97,59.69 UC1.AG11 ; UC1.M6 UC1.N6 ; UC1.N6 112.88,56.78 112.84,56.83 UC1.N7 UC1.N8 ; UC1.N6 112.92,56.39 112.92,55.82 UC1.N5 ; UC1.N6 UC1.P6 ; v2(102.41,56.71) 102.34,56.71 102.06,56.43 UC1.AG6 UC1.AH6 UC1.AJ6 100.06,56.68 99.72,56.68 99.62,56.78 99.43,56.78 UC1.AL7 UC1.AL8 ; v2(85.86,60.05) 85.58,60.34 UC1.BH12 ; v2(116.76,60.25) 117.08,60.58 UC1.G12 ; v2(116.76,60.25) 116.43,59.93 UC1.H11 ; v2(116.76,60.25) 116.43,60.58 UC1.H12 ; UC1.K10 115.61,59.04 v2(115.95,59.37) ; UC1.A24 120.98,70.2 120.7,70.49 v2(120.01,70.49) 119.68,70.81 UC1.C25 119.29,71.28 119.29,71.42 UC1.D26 119.03,71.74 v2(119.36,72.06) ; v2(94.09,58.78) v2(94.1,59.41) 93.92,59.59 93.9,59.59 93.81,59.69 UC1.AU11 ; v2(94.09,58.78) v2(94.09,58.14) ; v2(94.09,58.78) 93.83,59.04 UC1.AU10 ; v2(120.01,57.89) 120.01,57.82 UC1.C8 UC1.D6 ; v2(120.01,57.89) 120.17,58.05 120.17,58.12 UC1.B9 UC1.A9 ; v2(120.01,57.89) 119.68,58.21 UC1.C9 119.29,58.68 ; v2(79.83,55.03) 79.99,55.19 UC1.BT4 ; UC1.BN19 82.09,66.14 82.09,66.5 UC1.BN20 ; UT5.H8 33.88,89.23 34.32,89.67 v2(34.32,89.75) ; UC1.K11 115.63,59.69 v2(115.95,59.37) ; v2(79,60.66) 79.01,60.67 80.1,60.67 UC1.BT12 UC1.BR12 81.14,60.41 81.16,60.39 81.51,60.39 81.53,60.41 UC1.BP12 UC1.BN12 ; v2(85.86,58.14) 85.46,57.74 UC1.BH8 ; v2(85.86,58.14) 85.62,58.39 UC1.BH9 ; v2(85.86,58.14) 85.89,58.12 85.89,57.39 85.58,57.09 UC1.BH7 ; UC1.D24 119.29,69.84 119.29,69.7 UC1.C23 119.68,69.24 v2(120.01,68.91) ; UC1.F36 117.91,78.82 v2(117.99,78.82) 117.99,79.36 118.09,79.46 UC1.E38 ; 95.87,77.52 v2(95.94,77.52) ; 95.87,77.52 UC1.AR35 ; 95.87,77.52 95.87,77.52 UC1.AR34 ; UC1.AP12 96.74,60.7 v2(96.85,60.7) 96.93,60.7 UC1.AN12 ; UC1.AP12 96.26,60.34 v2(95.92,60) ; UC1.AP12 96.55,60.34 v2(96.83,60.05) ; UC1.AP12 96.05,60.67 v2(95.92,60.67) 95.78,60.67 UC1.AR13 UC1.AR14 ; UC1.BH11 85.59,59.69 v2(85.87,59.41) ; UC1.BH11 UC1.BH10 ; UC1.BH11 UC1.BH12 ; UH1.K11 v2(197.11,39.39) ; v2(85.86,58.78) 85.6,59.04 UC1.BH10 ; v2(245.66,16.81) 245.68,16.84 UN7.3 ; 79.45,78.42 79.52,78.49 UC1.BT36 80.47,78.37 UC1.BR36 ; 79.45,78.42 79.45,77.89 79.77,77.57 80.26,77.57 UC1.BT35 ; 79.45,78.42 v2(79.45,78.5) ; UC1.BM27 83.28,72.55 v2(83.28,72.62) 82.96,72.94 UC1.BM28 ; UC1.T13 UC1.T12 ; UC1.T12 110.26,60.34 110.55,60.05 ; UC1.T12 UC1.T11 ; UC1.T12 109.83,60.6 109.58,60.6 109.31,60.34 UC1.V12 109.04,60.48 108.4,60.48 UC1.W12 ; UC1.AD9 UC1.AD8 UC1.AD7 ; UC1.AD9 UC1.AD10 ; UC1.AD9 104.39,58.39 v2(104.13,58.12) ; v2(79.55,71.27) 79.71,71.44 UC1.BT26 ; UC1.BA6 UC1.BB6 ; UC1.BB6 90.64,56.81 90.64,56.84 UC1.BA7 UC1.BA8 ; UC1.BB6 90.19,56.43 v2(89.86,56.09) 89.53,56.43 UC1.BC6 UC1.BD6 ; v2(84.78,56.08) 84.68,56.08 84.38,56.38 UC1.BK6 UC1.BL6 ; UC1.G26 117.4,71.99 v2(117.4,72.05) 117.65,72.3 117.65,72.31 117.73,72.39 UC1.F27 ; UC1.BG14 86.39,61.56 86.39,61.06 UC1.BG13 UC1.BG12 86.44,60.34 v2(86.8,60.7) 86.84,60.7 87.21,60.34 UC1.BF12 87.31,60.34 v2(87.69,60.71) ; UC1.AP11 96.74,60.05 v2(96.83,60.05) ; UC1.AN12 97.12,60.34 v2(96.83,60.05) ; UC1.AN12 97.55,60.6 97.95,60.6 UC1.AM12 98.47,60.6 98.86,60.6 UC1.AL12 ; UH1.A5 UH1.A4 UH1.A3 UH1.A2 ; v2(86.49,78.82) 86.16,79.15 UC1.BG37 ; UC1.AD10 UC1.AD11 ; UC1.AD10 104.98,59.41 v2(105.07,59.41) 105.06,59.42 v2(105.06,60.05) ; UC1.AD11 104.97,60.05 v2(105.06,60.05) ; UC1.AD11 UC1.AD12 104.78,60.34 v2(105.06,60.05) ; UC1.AV37 93.26,79.15 v2(93.58,79.48) 93.25,79.8 UC1.AV38 ; v2(79.8,67.5) UC1.BT21 UC1.BR21 ; 88.16,56.68 88.15,56.69 UC1.BD7 ; 88.16,56.68 88.32,56.68 UC1.BD6 ; 88.16,56.68 87.99,56.68 UC1.BE6 ; UC1.T11 110.28,59.69 v2(110.56,59.41) 110.18,59.04 UC1.T10 ; UC1.T11 UC1.T10 ; UC1.BL35 83.54,77.85 v2(83.3,78.09) 82.96,77.75 UC1.BM35 ; v2(91.33,59.28) 91.09,59.04 UC1.BA10 ; v2(193.92,41.28) 193.96,41.64 UH1.C5 ; UC1.BR38 80.46,79.8 v2(80.35,79.92) ; UC1.BH10 UC1.BH9 ; UC1.BD6 88.46,56.43 v2(88.13,56.1) 88.13,56.09 87.82,55.78 UC1.BE5 ; UC1.AR3 95.29,54.49 95.29,54.99 95.28,55 UC1.AR4 95.28,55.26 95.28,55.27 95.28,55.63 95.28,55.64 UC1.AR5 ; UC1.G5 117.18,55.92 UC1.F5 ; UC1.G5 116.97,55.78 116.64,55.45 ; UC1.G5 117.04,55.85 117.09,55.9 117.09,56.28 117.04,56.34 UC1.G6 ; UC1.BN7 82.38,57.19 v2(82.38,56.73) ; v2(115.34,80.59) 115.23,80.49 UC1.K38 ; UC1.N12 112.98,60.34 v2(113.3,60.02) ; UC1.N12 112.7,60.48 112.06,60.48 UC1.P12 111.78,60.48 111.15,60.48 UC1.R12 110.84,60.34 110.55,60.05 ; UC1.N12 UC1.N11 ; v2(91.21,78.82) 90.89,79.15 UC1.BA37 90.82,79.22 90.88,79.29 90.88,79.66 90.82,79.73 UC1.BA38 ; v2(121.54,77.74) 121.44,77.64 UC1.A34 ; UC1.AU7 93.63,56.46 UC1.AU6 ; UC1.AU7 93.89,56.84 94.03,56.84 UC1.AT6 ; UC1.AU7 93.63,57.25 93.64,57.26 93.64,57.61 93.63,57.62 UC1.AU8 93.69,57.74 v2(94.09,58.14) ; v2(120.01,67.34) 120.01,67.4 UC1.C21 119.29,68.13 119.29,68.27 UC1.D22 ; UC1.L34 114.51,77.2 v2(114.84,76.87) 114.52,76.55 UC1.L33 ; UC1.BH7 UC1.BH8 ; v2(208.98,38.23) UH1.AR12 ; 110.55,60.05 v2(110.55,60.03) ; v2(83.28,71.04) 82.96,71.37 UC1.BM26 ; v2(94.36,76.22) 94.04,76.55 UC1.AU33 ; v2(219.12,31.84) 219.05,31.84 218.99,31.79 UH1.BG25 ; UC1.C31 119.68,75.72 v2(119.36,76.05) 119.03,76.37 UC1.D33 ; UC1.AL34 98.63,77.2 v2(98.3,76.87) 98.62,76.55 UC1.AL33 ; UC1.D16 119.29,63.54 119.29,63.4 UC1.C15 119.68,62.94 v2(120.01,62.61) ; v2(94.09,58.14) 93.85,58.39 UC1.AU9 UC1.AU10 ; UC1.D38 119.26,80.18 v2(119.26,80.38) ; UC1.A4 UC1.A3 120.41,54.43 UC1.B3 ; UC1.BE5 87.74,55.65 87.75,55.64 87.75,55.26 87.74,55.25 UC1.BE4 87.74,55 87.75,54.99 87.75,54.61 87.74,54.6 UC1.BE3 87.32,54.06 v2(87.28,54.06) ; 83.99,61.52 84.26,61.26 UC1.BK13 ; 83.99,61.52 84.26,61.78 UC1.BK14 84.26,61.99 v2(83.87,62.38) 83.86,62.38 83.86,62.4 84.23,62.78 UC1.BK15 UC1.BJ15 ; UC1.BJ30 84.25,74.12 UC1.BK29 83.82,74.01 UC1.BL29 ; UC1.BC34 89.32,77.2 v2(89.64,77.52) ; v2(99.81,54.15) 99.87,54.2 ; 99.87,54.2 99.87,54.68 UC1.AK4 ; 99.87,54.2 99.87,54.15 ; UC1.BA9 91.09,58.39 v2(91.36,58.11) 90.98,57.74 UC1.BA8 ; UC1.BA9 UC1.BA8 ; UC1.BA9 UC1.BA10 ; v2(121.57,59.2) 121.44,59.07 UC1.A10 ; UC1.BN12 82.31,60.45 82.96,61.1 UC1.BM13 ; v2(96.83,58.14) 96.59,58.39 UC1.AP9 ; v2(96.83,58.14) 96.43,57.74 UC1.AP8 ; UC1.BD37 88.53,79.15 v2(88.85,79.48) 88.52,79.8 UC1.BD38 ; v2(80,76.52) 80,76.45 UC1.BT32 ; 201.62,42.72 201.65,42.75 201.65,43.32 201.32,43.65 201.15,43.65 ; v2(95.94,78.82) 95.61,79.15 UC1.AR37 ; UC1.A20 v2(121.56,66.94) ; UC1.BG38 v2(86.49,80.13) ; UC1.B37 UC1.C37 ; UC1.AW5 UC1.AW4 UC1.AW3 92.44,54.15 v2(92.32,54.15) 92.65,53.83 UC1.AW2 UC1.AW1 ; v2(201.26,45.85) 201.99,45.85 202.26,45.58 202.26,44.89 202,44.64 200.87,44.64 200.66,44.42 200.66,44.08 ; v2(85.11,52.46) 84.97,52.6 UC1.BH1 84.97,53.57 UC1.BH2 ; UC1.BH9 UC1.BH8 ; UC1.AU11 UC1.AU10 ; UH1.AC17 203.5,35.46 203.69,35.27 ; v2(117.41,58.68) 117.73,58.35 UC1.F9 117.73,58.21 v2(118.06,57.89) ; UC1.AL8 99.17,57.74 v2(99.58,58.14) v2(99.58,58.78) ; 116.64,55.45 116.56,55.45 UC1.J4 UC1.K4 115.4,55.25 115.41,55.26 115.41,55.64 115.4,55.65 UC1.K5 ; 116.64,55.45 116.97,55.13 UC1.G4 UC1.F4 ; UC1.M13 UC1.M12 113.61,60.34 v2(113.3,60.02) ; v2(113.3,60.02) 112.96,59.69 UC1.N11 ; UC1.AU34 94.04,77.2 v2(94.36,77.52) ; UC1.AR33 95.87,76.22 ; 95.87,76.22 95.87,76.22 UC1.AR32 ; 95.87,76.22 v2(95.94,76.22) ; UC1.BD12 UC1.BD11 UC1.BD10 UC1.BD9 UC1.BD8 ; v2(95.94,80.13) 95.62,79.8 UC1.AR38 ; UC1.E9 118.38,58.21 v2(118.06,57.89) ; v2(99.88,78.83) 100.2,79.15 UC1.AJ37 100.27,79.22 100.21,79.29 100.21,79.66 100.27,79.73 UC1.AJ38 ; v2(89.82,54.18) 90.03,54.38 90.03,54.38 90.13,54.48 UC1.BB3 ; UC1.AA12 106.18,60.6 105.78,60.6 UC1.AC12 105.35,60.34 v2(105.06,60.05) ; UC1.A22 121.4,68.52 v2(121.61,68.73) ; UC1.A26 121.67,71.67 v2(121.84,71.84) ; UC1.BC33 89.31,76.55 v2(89.64,76.22) ; UC1.BD7 88.25,57.09 88.62,57.46 88.62,58.13 v2(88.61,58.14) 88.55,58.14 UC1.BD8 ; UC1.BD7 UC1.BD8 ; UC1.AG7 UC1.AG8 ; UC1.BM23 82.96,69.14 v2(82.63,69.47) 82.31,69.79 UC1.BN24 ; UH1.AG49 205.76,20.08 205.58,20.26 205.58,21.27 v2(205.21,21.65) ; v2(118.75,73.62) 118.05,73.62 117.73,73.93 UC1.F29 ; v2(115.88,57.36) 116.17,57.07 UC1.J7 116.66,57.07 UC1.G8 UC1.F8 117.73,57.56 v2(118.06,57.89) ; UC1.L30 UC1.L29 ; UC1.G20 117.08,66.88 v2(117.41,66.55) 117.73,66.23 UC1.F19 117.73,66.09 v2(118.06,65.76) ; v2(121.49,75.05) 121.01,75.05 UC1.A30 ; 119.29,58.68 UC1.D9 ; 119.29,58.68 119.29,58.82 UC1.D10 ; UC1.F4 117.72,54.58 UC1.F3 ; UC1.F4 117.81,55.13 117.85,55.08 118.23,55.08 118.27,55.13 UC1.E4 ; v2(115.95,59.37) 116.25,59.07 UC1.J10 ; UC1.D12 119.4,60.28 119.4,60.14 UC1.C11 119.68,59.79 v2(120.01,59.46) ; UC1.D14 119.29,61.97 119.29,61.83 UC1.C13 119.68,61.36 v2(120.01,61.04) ; UC1.AY34 91.67,77.2 v2(92,76.87) 91.68,76.55 UC1.AY33 ; UH1.F47 194.63,20.33 193.97,20.33 UH1.C48 ; 82.63,64.74 82.31,65.07 UC1.BN18 UC1.BP18 UC1.BR18 UC1.BT18 79.84,65.14 v2(79.65,65.33) ; UC1.A28 121,73.26 121.13,73.26 v2(121.57,73.7) ; v2(120.01,65.76) 119.68,66.09 UC1.C19 119.29,66.55 119.29,66.69 UC1.D20 ; v2(212,38.82) 211.94,38.89 211.75,38.89 UH1.AW10 ; v2(118.06,64.19) 117.73,64.51 UC1.F17 117.73,64.72 UC1.G18 116.99,65.28 116.47,65.28 UC1.H18 UC1.J18 ; UC1.BH12 85.27,60.34 v2(84.95,60.01) 84.58,60.38 UC1.BJ12 ; UC1.AD6 104.17,56.09 v2(104.08,56.09) 104,56.09 UC1.AE6 ; UC1.A18 121.49,65.37 v2(121.68,65.18) ; UC1.F11 117.73,59.79 v2(118.06,59.46) ; UC1.AH12 100.96,60.34 101.27,60.65 v2(101.41,60.65) ; UH1.AW4 v2(211.8,41.92) UH1.BA5 UH1.BA6 ; UC1.AH33 101.13,76.55 v2(101.45,76.87) 101.12,77.2 UC1.AH34 ; UC1.AM4 97.8,55 97.82,54.97 97.82,54.63 97.8,54.6 UC1.AM3 UC1.AM2 UC1.AM1 v2(97.8,52.63) ; UC1.BN34 82.31,76.88 v2(81.98,76.56) 81.98,76.62 UC1.BP34 UC1.BR34 ; UC1.A16 v2(121.62,63.79) ; UC1.A14 v2(121.54,62.22) ; UC1.A12 v2(121.62,60.64) ; v2(193.26,41.69) 193.3,41.7 UH1.C4 ; UH1.AT45 210.02,21.93 209.88,22.07 209.4,22.07 UH1.AP46 209.05,21.76 208.75,22.07 208.21,22.07 208.02,22.26 207.74,22.26 207.73,22.25 207.73,22.25 207.42,21.94 207.42,21.66 v2(207.38,21.62)
  BOTTOM w0.254: 82.96,73.78 UC1.BM29 ; 82.96,73.78 v2(83.32,73.41) 83.61,73.7 UC1.BL29 ; 82.96,73.78 82.96,73.7 v2(82.67,73.41) 82.31,73.78 ; v2(84.92,77.52) 84.59,77.85 UC1.BJ35 UC1.BJ36 ; UH1.AB25 202.92,31.4 ; 202.92,31.4 UH1.AA25 ; 202.92,31.4 v2(202.92,31.35) ; PR1729.1 v2(102.88,83.54) ; UC1.BK29 84.58,73.67 UC1.BJ29 ; UC1.BG14 86.15,61.8 86.01,61.8 85.39,62.42 85.39,62.43 ; v2(34.08,23.57) 33.72,23.21 JDIMM1.23 ; UC1.BT8 80.91,57.26 UC1.BR7 ; v2(260.68,11.66) 260.68,11.98 260.85,12.15 JSATA1.12 ; JDIMM2.36 117.97,12.85 v2(117.94,12.82) ; UC1.AL12 99.26,60.48 99.39,60.48 v2(99.58,60.66) 99.91,60.99 UC1.AJ13 ; UC1.B3 120.23,54.51 v2(119.73,54.51) ; UC1.BE6 87.81,56.43 v2(88.13,56.1) ; UC1.BN29 82.31,73.78 ; 82.31,73.78 82.31,73.74 v2(81.96,73.39) 81.66,73.69 UC1.BP29 UC1.BR29 UC1.BT29 ; v2(83.31,67.08) 83.61,66.78 UC1.BL20 83.74,66.58 83.74,66.1 83.61,65.97 UC1.BL19 UC1.BL18 ; v2(83.31,67.08) 83.26,67.13 83.26,67.13 83.24,67.16 UC1.BM21 82.81,67.36 82.45,67.36 UC1.BN21 ; v2(83.31,67.08) 83.61,67.38 UC1.BL21 ; UH1.A46 UH1.B47 UH1.B48 ; UH1.A46 UH1.A45 ; UH1.A46 UH1.A47 UH1.B48 ; v2(199.74,50.52) 200.82,50.52 YH2.2 ; v2(111.16,73.17) 111.29,73.31 UC1.R29 ; UC1.AK30 UC1.AK29 99.48,73.54 99.78,73.24 v2(99.78,73.17) ; 198.55,48.85 198.18,48.48 198.18,47.92 197.2,46.94 CH14.2 197.14,45.96 v2(197.21,45.88) ; 198.55,48.85 YH2.4 ; 198.55,48.85 197.94,48.85 197.58,49.2 197.58,51.1 197.84,51.36 201.68,51.36 201.94,51.1 201.94,47.94 201.26,47.27 CH13.2 v2(201.26,45.85) ; UC1.BT26 UC1.BR26 UC1.BP26 ; PU2001.2 105.33,89.97 v2(105.05,89.69) ; UC1.AN30 UC1.AN29 97.12,73.42 v2(97.37,73.17) ; v2(83.28,71.04) UC1.BM25 UC1.BM24 82.96,69.79 v2(82.63,69.47) ; v2(14.14,117.63) 13.99,117.48 DT18.1 ; v2(342.46,54.51) 342.65,54.32 JNGFF2.73 ; UC1.AG6 101.86,56.55 UC1.AG7 ; v2(151.41,62.12) 151.23,61.94 PU401.6 ; v2(92.77,73.38) 92.4,73.75 UC1.AW29 UC1.AW30 ; v2(110.12,12.81) 109.8,12.81 109.47,13.13 JDIMM2.2 ; UC1.AG10 101.73,59.04 v2(101.4,58.71) ; UC1.G28 117.04,73.24 116.78,73.5 v2(116.78,73.61) ; v2(119.4,73.65) 119.68,73.93 UC1.C29 ; UC1.F25 117.46,70.61 117.46,70.54 v2(117.43,70.51) ; PU2001.14 107.92,88 v2(107.9,87.98) ; UC1.K1 115.4,53.15 115.58,52.97 115.58,52.51 v2(115.52,52.45) ; JESPI.9 269.08,22.36 269.35,22.08 v2(269.35,21.78) ; v2(117.42,69.69) 117.73,69.37 UC1.F23 117.37,68.94 v2(117.37,68.9) ; v2(117.42,69.69) 117.08,70.02 UC1.G24 ; v2(117.42,69.69) 117.08,69.35 UC1.G23 ; UC1.BJ31 84.41,75.36 84.41,75.79 UC1.BJ32 84.41,76.01 84.41,76.44 UC1.BJ33 ; JEDP1.4 122.15,106.42 v2(122.15,105.3) ; v2(174.2,16.97) 172.97,15.74 JDIMM2.248 ; v2(104.96,56.76) 104.64,57.09 UC1.AD7 ; v2(104.96,56.76) 104.9,56.76 104.57,56.43 UC1.AD6 ; v2(104.96,56.76) 105.3,56.43 UC1.AC6 ; v2(88.59,59.94) 88.2,60.34 UC1.BD12 ; UC1.BN24 82.26,69.91 81.83,69.91 81.78,69.86 UC1.BP24 81.56,69.86 81.51,69.91 81.1,69.91 81.05,69.86 UC1.BR24 ; UC1.BJ33 84.84,76.87 v2(84.92,76.87) ; UC1.BJ33 84.52,76.55 v2(84.13,76.94) 84.13,76.94 UC1.BL33 83.34,76.16 UC1.BM33 ; v2(316.52,34.35) 316.37,34.35 315.57,35.15 CE57.2 ; PR206.2 46.43,4.76 v2(46.43,5.18) 46.51,5.27 PU200.15 ; v2(212,38.82) 212.21,38.61 UH1.BA12 ; UC1.J33 116.03,76.54 116.08,76.54 116.18,76.44 116.25,76.44 v2(116.42,76.26) 116.1,75.94 116.02,75.94 116.02,75.94 UC1.J32 ; UC1.BJ15 UC1.BJ14 85.05,62.03 UC1.BH14 85.44,62.37 85.39,62.43 ; UH1.A2 192.37,43.44 v2(192.26,43.4) ; UC1.K7 115.62,57.09 v2(115.88,57.36) UC1.K8 ; JDIMM2.90 131.47,13.22 v2(131.9,12.79) ; RT416.2 11.28,115.53 v2(11.1,115.34) ; v2(192.25,19.98) 192.37,19.86 193.02,19.86 193.12,19.96 UH1.B49 UH1.B48 ; v2(92,62.5) 92,61.84 UC1.AY14 ; v2(101.41,60.65) 101.75,60.99 UC1.AG13 102.51,61.64 UC1.AF14 ; UH1.AA27 v2(202.18,31.36) ; v2(123.22,12.82) 122.97,13.06 JDIMM2.56 ; v2(338.56,55.05) 338.65,54.95 JNGFF2.57 ; UH1.BG2 215.76,43.61 215.87,43.61 v2(215.88,43.62) 216.16,43.33 216.16,42.97 215.43,42.24 UH1.BG4 ; UH1.BG2 UH1.BF2 ; UH1.BG2 UH1.BG3 ; UH1.BG2 UH1.BF1 UH1.BF2 ; UC1.AG29 101.84,73.18 v2(101.84,73.18) ; v2(300.3,34.01) 300.65,34.36 JNGFF1.18 ; JSATA1.7 258.35,12.04 258.1,11.79 v2(257.06,11.79) 256.85,11.99 JSATA1.4 ; v2(120.15,105.42) 120.15,106.42 JEDP1.8 ; UH1.B48 UH1.A48 ; UH1.B48 UH1.C48 ; UC1.G10 117.08,59 v2(117.41,58.68) 117.41,58.61 UC1.G9 ; UH1.BG4 UH1.BG3 ; UH1.BG4 UH1.BF3 ; v2(119.73,54.51) 119.73,53.98 UC1.C2 ; v2(119.73,54.51) 119.63,54.41 UC1.D3 ; v2(263.2,26.39) 263.82,26.39 264.08,26.14 JESPI.11 ; UC1.J25 115.73,70.84 v2(116.06,70.51) 116.38,70.83 UC1.H25 ; v2(104.54,73.17) 104.45,73.26 104.45,73.63 104.21,73.88 UC1.AD29 103.92,73.61 v2(103.92,73.17) ; v2(174.19,15.44) 173.97,15.22 JDIMM2.252 ; UC1.A6 121.59,56.72 v2(121.61,56.74) ; v2(89.33,16.52) 88.65,15.85 88.65,15.3 88.47,15.12 JDIMM1.234 ; JDIMM2.14 112.47,13.13 112.84,12.75 v2(113.11,12.75) ; v2(88.53,95.2) 88.53,95.3 88.27,95.56 PU1900.14 ; UC1.AT30 UC1.AT29 94.76,73.3 v2(95.02,73.05) ; v2(119.37,75.17) 119.03,74.84 UC1.D30 ; v2(88.59,59.36) 88.48,59.36 UC1.BD11 ; UC1.BP21 81.66,67.57 v2(81.98,67.89) 82.31,67.57 UC1.BN21 ; UC1.BT24 UC1.BR24 ; UC1.BR24 UC1.BR25 UC1.BP25 ; UC1.L29 114.44,73.32 114.36,73.24 v2(114.36,73.09) ; UH1.BF3 UH1.BF2 ; UH1.BF3 UH1.BG3 ; v2(75.29,20.39) 75.22,20.45 JDIMM1.181 ; v2(78.72,16.58) 78.92,16.58 79.23,16.27 79.23,15.49 79.22,15.48 ; UC1.AU12 93.39,60.1 92.98,60.1 92.74,60.34 UC1.AW12 92.5,60.11 92.06,60.11 91.83,60.34 UC1.AY12 91.39,59.92 v2(91.33,59.92) ; v2(101.44,78.84) 101.11,78.5 UC1.AH36 UC1.AH35 ; UC1.BK22 UC1.BJ22 85.41,68.29 v2(85.47,68.34) ; UH1.AT32 210.5,28.03 v2(210.5,27.99) 210.02,27.52 UH1.AT34 UH1.AR34 ; v2(78.83,19.78) 78.22,20.39 JDIMM1.193 ; UC1.AG30 101.91,74.55 v2(102.26,74.9) ; v2(12.24,109.82) 12.68,110.26 DT13.1 ; UC1.E34 118.51,77.31 118.51,77.72 UC1.E35 118.03,78.2 117.98,78.23 117.86,78.23 UC1.F36 ; v2(13.06,109.63) 13.26,109.43 DT6.1 ; v2(82.38,56.73) UC1.BM6 ; UC1.BM6 82.75,56.38 v2(83.18,56.8) ; UC1.BM6 UC1.BM5 ; JDIMM2.231 168.72,21.28 168.87,21.13 168.87,18.64 v2(168.3,18.07) ; UC1.A24 121.5,70.09 v2(121.56,70.03) ; 85.82,17.32 85.82,15.6 85.47,15.24 JDIMM1.222 ; v2(98.62,62.33) 98.64,62.32 98.64,62.12 UC1.AL14 ; v2(85.48,70.65) UC1.BJ25 UC1.BK25 ; CN9.2 265.15,15.58 263.85,14.27 JSATA1.18 263.85,12.44 263.37,11.96 v2(263.37,11.76) ; v2(196.5,21.56) 196.66,21.73 UH1.J46 ; UC1.AR30 UC1.AR29 ; UC1.AA12 106.7,60.34 UC1.Y13 UC1.Y14 ; UC1.V30 108.93,74.55 v2(108.56,74.93) ; v2(83.18,56.8) 82.93,57.05 82.93,57.24 UC1.BM7 ; v2(83.18,56.8) UC1.BL6 ; UC1.BE30 UC1.BE29 87.67,73.77 v2(88.02,73.42) ; v2(106.32,73.17) 106.32,73.66 106.56,73.9 UC1.AA29 106.6,73.9 106.84,73.66 106.84,73.27 v2(106.94,73.17) ; JEDP1.23 112.65,105.45 v2(112.6,105.4) ; v2(85.5,64.98) 85.35,65.14 UC1.BJ18 UC1.BK18 ; UC1.BL22 UC1.BM22 UC1.BM23 ; v2(88.59,58.75) 88.44,58.75 UC1.BD10 ; UC1.T14 UC1.T13 ; v2(85.35,62.46) 85.39,62.43 ; v2(118.89,24.12) 118.72,23.94 JDIMM2.39 ; v2(29.62,85.2) 30.11,85.69 UT5.A1 ; UC1.G14 117.73,61.57 UC1.F13 117.73,61.39 v2(118.09,61.03) ; v2(254.4,11.65) 254.42,11.63 255.1,11.63 255.35,11.88 JSATA1.1 ; v2(113.3,59.34) 113,59.04 UC1.N10 ; 82.63,64.74 82.96,65.07 UC1.BM18 ; v2(94.76,98.28) 95.58,98.28 ; v2(116.54,105.27) 116.65,105.38 116.65,106.42 JEDP1.15 ; v2(95.94,78.82) 95.62,78.5 UC1.AR36 ; v2(90.41,73.41) 90.03,73.78 UC1.BB29 UC1.BB30 ; DT10.1 12.28,117.48 v2(12.18,117.37) ; UC1.A3 120.98,53.91 v2(120.9,53.83) ; PU200.4 46.06,9.54 v2(46.1,9.58) ; v2(96.84,59.41) 96.65,59.41 UC1.AP11 ; CC300.2 74.99,73.8 v2(74.44,73.25) ; JDIMM2.1 109.22,21.68 109.09,21.55 108.68,21.55 108.48,21.75 107.7,21.75 107.49,21.54 107.49,20.93 v2(107.41,20.85) ; v2(111.99,105.45) 112.15,105.6 JEDP1.24 ; v2(38.3,23.54) 38.72,23.12 JDIMM1.43 ; v2(12.87,115.74) 13.11,115.74 DT17.1 ; UC1.BN14 82.09,62.2 81.87,62.2 UC1.BP14 81.66,62.06 v2(81.33,62.38) 81.01,62.06 UC1.BR14 UC1.BT14 ; JLED1.3 v2(322.04,6.88) ; JDIMM2.22 114.47,13.24 114.9,12.81 v2(115.05,12.81) ; v2(76.81,19.8) 76.22,20.39 JDIMM1.185 ; v2(118.06,67.34) 118.06,67.46 117.79,67.73 UC1.F21 117.73,67.8 v2(117.41,68.13) 117.08,68.45 UC1.G22 116.98,68.42 116.48,68.42 UC1.H22 116.23,68.37 115.88,68.37 UC1.J22 ; v2(118.75,73.62) 119.03,73.33 UC1.D28 ; JDIMM1.60 42.97,12.83 v2(43.18,12.62) ; UC1.M14 UC1.M13 ; v2(97.4,55.45) 97.57,55.28 97.61,55.28 97.76,55.13 UC1.AM4 ; v2(111.41,105.4) 111.41,105.58 111.65,105.82 111.65,106.42 JEDP1.25 ; 200.13,36.15 200.11,36.14 UH1.R16 ; v2(31.2,19.68) 32.72,21.2 JDIMM1.19 ; UC1.BM13 UC1.BM14 UC1.BL14 83.61,62.13 v2(83.87,62.38) ; v2(128.2,12.81) 128.47,13.08 JDIMM2.78 ; UC1.K5 115.07,56.1 v2(114.96,56.1) ; UC1.BN20 UC1.BN21 ; UC1.C5 119.68,56 v2(119.36,56.32) ; v2(45.7,61.26) PU2000.14 ; UH1.BF49 UH1.BF48 UH1.BG48 215.71,20.01 215.71,19.48 v2(215.66,19.43) 215.5,19.43 215.04,19.89 UH1.BF49
  BOTTOM w0.279: JKBTP1.12 138.52,9.38 139.11,8.79 v2(139.11,8.34)
  BOTTOM w0.305: v2(50.5,15.33) 50.47,15.3 JDIMM1.90 ; v2(132.9,15.66) 132.47,15.23 JDIMM2.94 ; v2(33.24,16.08) 33.24,15.34 33.47,15.11 JDIMM1.22 ; JDEG1.10 334.4,13.71 v2(334.31,13.61) ; v2(42.53,23.56) 42.22,23.25 JDIMM1.57 ; JDIMM2.234 169.47,15.3 170.3,16.13 v2(170.54,16.13) ; JNGFF1.7 v2(296.16,37.11) 296.12,37.15 296.12,38.3 295.82,38.61 JNGFF1.1 ; JNGFF2.39 334.15,54.47 v2(334.36,54.69) ; JDIMM1.167 71.72,20.93 71.84,20.81 71.84,20.4 v2(71.28,19.84) ; JDIMM1.10 30.47,15.67 29.63,16.51 v2(29.63,17.82) ; JDIMM1.238 89.47,13.18 v2(89.73,12.92) ; JDIMM2.238 170.47,12.93 170.27,12.72 169.59,12.72 v2(169.54,12.67) ; JNGFF2.33 v2(332.65,54.41) ; JDIMM2.51 121.72,20.59 v2(122,20.31) ; v2(129.54,19.36) 129.02,19.89 129.02,20.73 129.22,20.93 JDIMM2.81 ; v2(172.19,19.12) 171.72,19.59 JDIMM2.243 ; JDIMM2.35 117.72,21.05 117.61,20.94 117.61,20.18 v2(118.09,19.7) ; UC1.AW30 92.41,74.55 v2(92.79,74.93) ; JDIMM2.202 161.47,12.93 161.63,12.78 162.03,12.78 v2(162.04,12.78) 162.06,12.8 162.38,12.8 162.47,12.89 JDIMM2.206 ; v2(301.57,9.68) 301.5,9.68 301.2,9.98 CZ66.2 ; JNGFF1.51 296.19,26.11 v2(296.27,26.19) ; JDIMM2.26 115.47,15.23 v2(114.48,16.22) ; JDIMM2.201 161.22,19.57 v2(160.98,19.33) ; JDIMM2.106 135.47,15.02 v2(135.11,15.38) ; JDIMM1.176 73.97,15.15 74.06,15.24 74.06,15.95 v2(73.49,16.52) ; JDIMM1.217 84.22,23.53 v2(84.59,23.91) ; JDIMM2.205 162.22,20.99 162.01,20.78 162.01,19.96 162.37,19.6 v2(162.77,19.6) ; v2(114.51,19.75) 115.72,20.96 JDIMM2.27 ; UC1.U37 v2(110.11,79.48) UC1.U38 ; JDIMM1.235 88.72,21.48 88.85,21.35 88.85,20.5 v2(89.61,19.74) ; v2(36.71,18.2) 36.19,18.72 36.19,20.83 36.72,21.36 JDIMM1.35 ; v2(126.05,19.62) 126.7,20.28 126.7,20.74 126.22,21.22 JDIMM2.69 ; v2(166.06,16.1) 166.61,15.56 166.61,15.24 166.47,15.1 JDIMM2.222 ; 48.85,12.64 v2(48.88,12.64) 49.47,13.23 JDIMM1.86 ; JKBTP1.1 144.02,9.47 144.51,8.98 v2(144.51,8.34) ; JDIMM2.102 134.47,15.13 v2(134.21,15.39) ; v2(331.13,54.64) 331.13,54.28 331.15,54.26 JNGFF2.27 ; JKBTP1.6 141.52,9.28 141.52,8.84 141.52,8.84 v2(141.52,8.36) ; UC1.BE30 87.69,74.55 v2(88.07,74.93) ; v2(111.24,15.96) 111.47,15.73 JDIMM2.10 ; JDIMM2.192 158.97,15.15 158.7,15.43 158.7,16.26 v2(159.21,16.78) ; v2(87.61,19.79) 87.12,20.28 87.12,20.73 86.72,21.12 JDIMM1.227 ; v2(153.83,20.11) 153.46,20.47 153.46,21.18 153.72,21.44 JDIMM2.171 ; v2(124.26,19.7) 123.75,20.21 123.75,20.8 124.22,21.26 JDIMM2.61 ; JNGFF3.45 v2(349.58,10.99) ; v2(45.77,18.73) 45.77,19.85 46.22,20.3 JDIMM1.73 ; JDIMM2.64 124.97,17.16 v2(124.13,18) ; CV12.2 v2(109.96,104.43) ; v2(35.28,16.52) 35.35,16.46 36.06,16.46 36.52,16 36.52,15.49 36.97,15.04 JDIMM1.36 ; JDIMM2.93 132.22,20.67 131.27,19.73 v2(131.04,19.73) ; JDIMM1.102 53.47,15.52 53.29,15.71 52.79,15.71 v2(52.79,15.71) ; v2(112.68,18.23) 111.96,18.95 111.96,20.68 112.72,21.44 JDIMM2.15 ; v2(301.61,5.96) 301.47,5.96 300.84,6.58 300.84,6.89 300.83,7.39 300.83,8.2 JUSH1.24 ; v2(120.42,19.67) 121,20.25 121,20.83 120.72,21.11 JDIMM2.47 ; JNGFF1.39 v2(293.34,29.11) ; JUSH1.25 300.33,7.86 300.34,7.1 300.34,6.26 v2(300.73,5.87) ; UC1.AL4 98.7,55.13 v2(99.06,55.48) 99.41,55.13 UC1.AK4 ; v2(161.01,16.61) 159.97,15.57 JDIMM2.196 ; UC1.N33 112.54,76.8 v2(112.53,76.88) 112.53,76.95 UC1.N34 ; JDIMM1.77 47.22,21.27 47.22,21.27 46.85,20.9 46.85,18.5 v2(47.35,18) ; v2(114.72,24.04) JDIMM2.23 ; JDIMM1.247 91.72,20.25 91.79,20.25 v2(92.6,19.44) 93.21,20.05 93.21,20.29 92.75,20.76 92.72,20.76 JDIMM1.251 ; JKBTP1.19 135.02,10.66 134.72,10.96 CZ85.2 ; JDIMM1.172 72.97,13.26 v2(72.54,12.83) ; UC1.W34 108.49,76.86 v2(108.55,76.86) ; UC1.R30 UC1.R29 ; JDIMM1.5 29.22,21.18 v2(28.19,20.15) ; v2(157.41,23.84) 157.22,23.65 JDIMM2.185 ; v2(131.02,20.33) 130.22,21.13 JDIMM2.85 ; v2(261.94,11.76) 261.85,11.85 JSATA1.14 ; JDIMM1.175 73.72,21.03 73.91,20.84 73.91,20.31 74.18,20.04 74.18,18.68 75.01,17.85 v2(75.26,17.85) ; JDIMM2.218 165.47,15.2 v2(164.41,16.26) ; JDIMM2.213 164.22,20.49 v2(164.73,19.98) ; JDIMM1.192 77.97,13.02 78.15,12.84 78.69,12.84 v2(78.69,12.84) ; JUSBC1.A1 8.07,111.13 8.53,110.67 v2(8.53,110.62) ; v2(162.74,17.9) 162.88,17.9 163.51,18.53 163.51,19.49 163.22,19.78 JDIMM2.209 ; JDIMM1.226 86.47,12.77 v2(86.47,12.77) ; JDIMM2.19 113.72,20.75 v2(112.72,19.75) ; v2(153.86,18.25) 152.72,19.39 JDIMM2.167 ; JDIMM1.78 47.47,13.07 v2(47.88,12.66) ; JDB1.6 v2(53.89,97.39) ; v2(162.69,16.12) 163.47,15.34 JDIMM2.210 ; UC1.V30 UC1.V29 ; JNGFF1.57 293.92,24.61 293.86,24.54 293.57,24.54 293.43,24.4 v2(293.44,24.4) ; v2(164.78,17.92) 165.48,18.62 165.48,20.45 165.22,20.72 JDIMM2.217 ; UC1.AN30 97.13,74.55 v2(97.5,74.92) ; UC1.T33 v2(110.9,76.87) 110.57,77.2 UC1.T34 ; JNGFF2.71 342.15,54.01 v2(341.7,54.46) ; v2(296.57,32.49) 296.22,32.83 296.22,33.72 295.83,34.11 JNGFF1.19 ; v2(159.32,20.26) 160.22,21.16 JDIMM2.197 ; JDIMM2.168 152.97,15.66 v2(153.02,15.71) ; JSPI1.20 v2(221.14,9.36) ; v2(53.99,12.78) 54.47,13.26 JDIMM1.106 ; v2(119.36,72.06) 119.36,72.13 UC1.C27 ; v2(126.1,17.85) 125.22,18.72 JDIMM2.65 ; CZ1.2 119.45,103.99 119.23,104.21 v2(119.23,104.31) ; v2(360.96,11.58) 360.58,11.21 JNGFF3.1 ; v2(168.6,12.67) 168.47,12.81 JDIMM2.230 ; UC1.Y38 v2(107.75,79.48) UC1.Y37 ; v2(31.58,12.59) 31.47,12.69 JDIMM1.14 ; JDIMM1.230 87.47,15.08 87.51,15.08 87.8,15.38 87.8,15.95 v2(87.34,16.41) ; v2(129.57,16.09) 129.26,15.79 129.26,15.15 129.47,14.95 JDIMM2.82 ; v2(168.33,16.32) 167.47,15.46 JDIMM2.226 ; v2(99.85,74.93) 99.48,74.57 UC1.AK30 ; JNGFF3.15 v2(357.08,11.11) ; v2(50.35,20.39) 49.97,20.39 49.22,21.13 JDIMM1.85 ; JDIMM2.30 116.47,16.21 v2(116.41,16.27) ; v2(155.35,23.71) 155.34,23.72 154.89,23.72 154.72,23.56 JDIMM2.175 ; v2(168.3,19.75) 167.72,20.33 JDIMM2.227 ; v2(47.45,16.25) 48.47,15.23 JDIMM1.82 ; v2(80.55,18.15) 80.22,18.48 JDIMM1.201 ; JDIMM2.31 116.72,19.09 v2(116.41,18.79) ; JDIMM1.214 83.47,13.25 83.06,12.84 v2(82.82,12.84) 82.47,13.19 JDIMM1.210 ; v2(166.55,20.36) 166.72,20.53 JDIMM2.223 ; v2(41.96,20.11) 43.22,21.36 JDIMM1.61 ; JSPI1.18 222.14,9.09 v2(221.86,9.36) 221.64,9.14 JSPI1.19 ; v2(118.11,16.12) 118.3,16.12 118.97,15.45 JDIMM2.40 ; CZ68.2 306.94,9.77 v2(307.01,9.7) ; v2(325.78,52.02) 325.65,52.15 JNGFF2.5 ; CZ64.2 304.78,9.99 v2(304.44,9.65) ; v2(50.52,15.94) 50.54,15.93 51.09,15.93 51.47,15.54 JDIMM1.94 ; v2(129.57,17.72) 128.22,19.07 JDIMM2.77 ; JDIMM1.93 51.22,23.63 51.04,23.81 50.53,23.81 v2(50.49,23.85) ; JDIMM1.213 83.22,20.89 v2(84.47,19.64) ; JDIMM1.231 87.72,21.38 88.16,20.94 88.16,18.62 v2(87.6,18.06) ; UC1.AB33 v2(106.18,76.87) UC1.AB34 ; v2(36.74,16.58) 37.06,16.58 37.97,15.67 JDIMM1.40 ; v2(89.34,18.14) 90.15,18.95 90.15,20.87 89.72,21.3 JDIMM1.239 ; JKBTP1.4 142.52,9.28 142.52,9.27 142.52,8.87 142.71,8.69 v2(142.71,8.25) ; JNGFF3.57 v2(346.58,10.75) ; v2(92.82,16.46) 93.32,15.97 93.32,15.48 92.97,15.14 JDIMM1.252 ; JDIMM1.52 40.97,16.86 v2(40.39,17.44) ; JNGFF2.3 325.15,54.38 325.46,54.69 v2(325.51,54.69) ; UC1.P38 112.05,79.8 v2(111.72,79.47) 112.03,79.15 UC1.P37 ; JDIMM1.189 77.22,20.97 77.36,20.83 77.36,18.63 v2(76.79,18.05) ; JDIMM1.202 80.47,15.56 v2(80.57,15.66) ; v2(41.86,15.33) 41.97,15.22 JDIMM1.56 ; JDIMM1.180 74.97,16.62 v2(73.44,18.15) ; JNGFF2.11 327.15,52.06 v2(327.08,51.99) ; JDIMM2.176 154.97,15.33 v2(153.95,16.35) ; v2(154.4,12.75) 154.25,12.75 153.97,13.03 JDIMM2.172 ; JDIMM1.64 43.97,15.13 43.56,15.53 43.56,16.06 v2(44.22,16.71) ; JDIMM1.9 30.22,20.99 v2(29.66,20.42) ; JDIMM2.89 131.22,24.01 v2(131.26,24.05) ; JNGFF1.75 295.87,20.11 v2(295.94,20.18) ; JDIMM1.18 32.47,15.4 31.57,16.31 31.17,16.31 v2(31.05,16.42) ; JDIMM1.223 85.72,20.4 v2(86.03,20.09) ; v2(33.39,19.32) 34.72,20.64 JDIMM1.27 ; 79.22,15.48 78.97,15.23 JDIMM1.196 ; 120.54,16.08 v2(120.55,16.09) 121.06,15.59 121.06,14.95 120.97,14.86 JDIMM2.48 ; v2(134.12,20.33) 134.72,20.94 JDIMM2.103 ; JDIMM2.181 156.22,21.15 v2(155.32,20.26) ; JDIMM2.188 157.97,15.71 v2(157.18,16.5) ; v2(118.06,17.87) 119.97,15.96 JDIMM2.44 ; CA7.2 120.13,104.09 v2(119.99,104.23) ; JDIMM1.205 81.22,20.74 82,19.96 82.26,19.96 v2(82.49,19.74) ; JDIMM2.60 123.97,14.96 123.61,15.32 123.61,15.72 v2(124.16,16.27) ; v2(82.46,16.44) 81.49,15.47 81.47,15.47 JDIMM1.206 ; JKBTP1.18 135.52,9.45 134.54,8.47 v2(134.54,8.38) ; v2(296.41,30.93) 296.09,30.61 JNGFF1.33 ; JDIMM1.65 44.22,23.66 v2(44.24,23.68) ; JDIMM2.189 158.22,20.79 157.36,19.93 v2(157.13,19.93) ; v2(52.93,23.61) 52.72,23.4 JDIMM1.99 ; JDIMM2.193 159.22,23.63 v2(159.29,23.71) ; v2(44.23,20.08) 45.22,21.08 JDIMM1.69 ; v2(261.09,17.42) CN10.2 CN11.2 ; v2(127.56,18.84) 127.68,18.96 127.67,18.97 127.67,20.94 127.22,21.39 JDIMM2.73 ; v2(348.18,11.02) 348.18,11.02 348.18,11.02 348.08,10.93 JNGFF3.51 ; JDIMM2.6 110.47,16.07 109.9,16.64 v2(109.73,16.64) ; UC1.AC38 v2(105.39,80.13) ; v2(135.46,23.81) 135.72,23.56 JDIMM2.107 ; JDIMM1.30 v2(35.47,15.39) ; v2(44.74,12.91) 44.97,13.13 JDIMM1.68 ; UD1.3 69.18,58.87 70.32,57.73 74.53,57.73 v2(74.79,57.47) ; v2(35.23,18.89) 35.72,19.37 JDIMM1.31 ; JNGFF3.39 v2(351.08,11.02) ; JDB1.7 57.23,100.78 57.95,100.05 v2(59.53,100.05) ; JDIMM2.98 133.47,12.82 v2(133.48,12.81) ; JNGFF3.33 v2(352.58,11.01) ; v2(112.71,16.6) 112.88,16.6 113.47,16.02 JDIMM2.18 ; JDIMM2.184 v2(156.97,12.49) ; v2(90.4,74.94) 90.03,74.58 UC1.BB30 ; JDIMM1.48 39.97,15.24 v2(38.89,16.32) ; JDIMM1.184 75.97,15.61 v2(76.81,16.45) ; v2(127.59,16.12) 126.97,15.5 JDIMM2.72 ; UC1.AD30 UC1.AD29 ; JNGFF1.63 293.6,23.11 v2(293.46,23.25) ; v2(47.61,100.21) 47.33,100.48 47.33,100.82 47.02,101.14 PU1201.4 ; v2(81.95,23.93) 82.22,23.67 JDIMM1.209 ; v2(108.25,20.32) 109.28,20.32 110.22,21.25 JDIMM2.5 ; JNGFF3.21 v2(355.58,11.06) ; JDIMM1.26 34.47,12.99 v2(34.14,12.66) ; JDIMM1.188 76.97,13.22 v2(76.59,12.84) ; JNGFF3.3 360.08,11.47 360.2,11.59 v2(360.2,11.84) ; v2(133.68,23.92) 133.72,23.88 JDIMM2.99 ; UC1.AT30 94.76,74.57 v2(95.13,74.94) ; UC1.W33 v2(108.54,76.22) ; JUSH1.10 307.83,7.75 307.84,7.55 307.54,7.25 v2(307.54,6.88) ; JDIMM1.47 39.72,20.76 38.87,19.9 v2(38.87,19.8) ; v2(50.35,20.97) 50.22,21.1 JDIMM1.89 ; v2(120.42,17.74) 119.72,18.45 JDIMM2.43 ; JNGFF3.27 v2(354.08,11.01) ; JDIMM1.98 52.47,12.96 v2(52.76,12.67) ; v2(90.87,18.55) 90.72,18.7 JDIMM1.243 ; JDIMM1.168 71.97,15.58 v2(71.88,15.67) ; UC1.AA29 UC1.AA30 ; JDIMM2.244 171.97,16.14 v2(172.26,16.43) ; JDIMM1.51 40.72,20.22 v2(40.39,19.89) ; JDB1.8 v2(55,96.51) ; v2(121.97,17.64) 123.05,18.71 123.05,21.12 123.22,21.29 JDIMM2.57 ; JDIMM1.218 84.47,15.04 84.62,15.19 84.73,15.19 85.12,15.58 85.12,15.89 v2(84.57,16.44) ; v2(163.8,12.79) 164.26,12.79 164.47,13 JDIMM2.214 ; v2(45.83,16.22) 45.97,16.08 JDIMM1.72 ; JDIMM2.86 130.47,14.99 v2(131.04,15.56) ; JDIMM1.248 91.97,13.15 v2(91.67,12.85) ; CZ67.2 v2(302.72,9.64) ; v2(293.04,22.05) 293.47,21.61 JNGFF1.69 ; v2(103.81,76.22) UC1.AE33 UC1.AE34 ; v2(78.77,18.25) 79.54,19.03 79.54,21.08 79.22,21.41 JDIMM1.197 ; JNGFF1.45 296.05,27.61 296.5,28.07 v2(296.5,29.23) ; v2(110.8,20.21) 110.8,20.82 111.22,21.24 JDIMM2.9 ; v2(122.18,16.16) 121.97,15.95 JDIMM2.52 ; v2(90.97,16.08) JDIMM1.244 ; JDIMM2.235 169.72,20.06 v2(170.54,19.24) ; v2(47.48,19.88) 48.22,20.62 JDIMM1.81 ; JDIMM2.239 170.72,20.92 v2(170.59,20.79) ; JDIMM1.107 54.72,21.38 53.75,20.41 v2(52.76,20.41) ; JUSH1.6 309.83,7.17 v2(309.55,6.9) 309.33,7.12 JUSH1.7 ; JDIMM2.247 172.72,21.13 173.83,20.01 v2(174.22,20.01) ; UC1.AC37 v2(105.39,78.82) ; 85.82,17.32 v2(86.03,17.53) ; JNGFF3.9 v2(358.55,11.71) ; JNGFF2.51 337.15,54.01 336.77,54.38 336.6,54.38 v2(336.55,54.43) ; JDIMM2.251 173.72,23.39 v2(173.99,23.66) ; v2(126.05,16.22) 125.83,16 125.83,15.32 125.97,15.17 JDIMM2.68 ; JNGFF2.45 v2(335.65,54.37)
  BOTTOM w0.356: CL19.2 v2(345.72,123.57) ; RT419.2 11.44,109.6 v2(11.22,109.82) ; v2(213.83,14.25) 213.57,14.5 RH634.2 ; UZ61.3 140.24,82.64 140.08,82.48 139.58,82.48 v2(139.57,82.49) ; v2(52.78,21.04) 52.8,21.02 53.5,21.02 53.72,21.24 JDIMM1.103 ; v2(36.66,19.73) 37.72,20.79 JDIMM1.39 ; CH268.1 223.13,42.31 222.98,42.46 221.81,42.46 RH637.1 ; RT417.2 10.82,117.28 10.59,117.05 10.08,117.05 v2(10.08,117.06) ; v2(28.31,16.27) 28.52,16.06 28.75,16.06 29.47,15.34 JDIMM1.6 ; v2(224.27,44.09) 224.2,44.16 RH636.1
  BOTTOM w0.381: v2(320.12,84.35) 320.33,84.14 CL10.2 ; UH7.3 233.45,27.27 RH635.2 232.94,27.3 232.29,26.66 v2(232.27,26.66) ; v2(69.51,104.75) 69.58,104.81 69.58,105.37 69.15,105.8 PQ1207.1 ; RT64.2 RT65.2 v2(34.98,81.56) ; v2(89.4,11.11) 89.88,11.11 PC111.2 ; RH627.2 174.24,50.02 CH342.2 174.24,49.42 173.17,48.35 v2(172.26,48.35) ; RE77.2 321.31,42.74 321.81,42.24 v2(321.81,42.06) 321.81,41.5 321.31,41 CE38.2 ; RH401.2 221.97,37.62 v2(222.14,37.8) ; v2(263.2,23.68) 263.05,23.68 262.41,23.05 UE6.3 ; CN17.2 246.93,11.58 247.2,11.31 247.76,11.31 v2(247.81,11.36) ; v2(223.82,41.64) 223.78,41.64 223.62,41.8 CH268.1 ; CE25.2 324.53,33.93 v2(324.66,33.81) ; v2(18.72,105.56) 18.5,105.78 RT415.2 ; CE20.2 320.81,28.86 v2(321.2,28.86) ; CH20.2 189.59,46.98 CC332.2 ; 4.23,35.76 4.33,35.66 PC947.2 ; v2(98.85,123.34) 98.85,122.96 99.09,122.72 CI12.2 ; PR103.2 84.95,10.69 v2(84.28,10.69) ; CA73.2 217.31,38.88 v2(217.07,38.64) ; RT300.2 17.38,108.74 17.29,108.83 v2(16.11,108.83) ; CH63.2 219.72,19.35 219.55,19.17 CH68.2 219.06,19.21 218.83,19.21 218.28,19.76 216.34,19.76 215.99,19.41 215.67,19.41 v2(215.66,19.43) ; RC139.2 74.14,69.8 v2(73.5,69.16) ; RH364.2 192.57,47.73 192.41,47.57 CC331.2 191.97,47.98 v2(191.49,48.46) ; CZ93.2 v2(346.85,109.28) ; CC330.2 v2(186.71,48.09) ; v2(224.48,21.13) 225.07,20.55 CH9.2 225.07,20.01 225.07,19.73 225.53,19.27 CH322.2 ; CA55.2 343.84,33.94 v2(343.96,34.06) ; v2(68.23,109.79) 67.93,109.49 67.93,108.56 67.85,108.48 PQ1207.4 ; PC1214.2 28.06,103.87 PQ1209.4 27.94,104.3 v2(27.44,104.8) ; CZ30.2 304.14,21.44 303.99,21.58 v2(303.99,22.22) ; CZ30.2 304.61,21.58 304.61,22.21 v2(304.62,22.22) ; CZ30.2 CZ31.2 ; CH270.2 237.03,5.1 v2(237.28,4.85) 237.41,4.72 CH321.2 ; QZ18.4 292.95,42.85 292.67,43.13 291.78,43.13 v2(291.65,43.26) QZ18.1 ; JDIMM1.171 72.72,20.49 v2(73.36,19.85) ; CZ82.2 313.1,21.43 312.84,21.7 v2(312.84,21.83) ; UZ35.3 146.28,85.42 146.47,85.61 v2(147.58,85.61) ; v2(26.53,106.58) 26.53,106.51 26.64,106.4 PQ1209.1 ; PQ1208.1 65.97,106.82 65.45,107.34 64.31,107.34 64.05,107.59 v2(64.05,107.85) 64.24,108.04 PQ1208.4 ; v2(218.57,37.05) 218.58,37.05 219.03,37.5 CA74.2 ; v2(310.94,39.65) 311.96,38.63 311.96,35.51 312.14,35.33 CE3.2 ; UC3.3 220,49.6 RH70.2 ; v2(23.39,86.26) RT81.2 ; v2(14.74,114.15) 14.58,114.31 DT39.3 ; CL21.2 326.51,107.35 v2(326.51,106.65) ; v2(313.36,42.06) 313.42,42 313.42,41.95 313.69,41.69 313.69,41.57 CE11.2 ; CH31.2 188.07,46.62 CC311.2 ; CL20.2 v2(329.5,106.63) ; CH30.2 219.53,44.63 220.06,45.16 v2(220.06,45.28) 219.99,45.28 219.65,45.63 RH609.1 ; v2(317.32,36.75) 317.98,36.09 CE19.2 ; CL17.2 v2(332.49,106.65) ; v2(355.9,69.75) 355.35,69.19 DI4.3 ; CI17.2 v2(354.63,66.9) ; RH630.2 182.7,33.12 CH345.2 182.29,33.81 v2(182.36,33.87) ; DI6.3 v2(85.23,124.8) ; CL16.2 v2(336.66,106.65) ; CN8.2 265.15,16.78 CN9.2 ; CA76.2 218.58,39.2 218.59,39.21 v2(218.59,39.35) 218.59,39.47 219.14,40.02 CA75.2 ; CC318.2 219.28,31.81 219.25,31.84 v2(219.12,31.84) ; CZ62.2 v2(309.78,11.86) ; UZ10.3 v2(346.76,112.18) ; UZ34.3 v2(151.38,50.26)
  BOTTOM w0.406: JDEG1.12 335.26,17.31 v2(334.84,17.31) ; JDEG1.11 328.9,17.41 v2(329.36,17.87)
  BOTTOM w0.432: v2(79.65,110.46) 78.93,111.19 PQ1210.1
  BOTTOM w0.457: UZ26.5 71.84,64.42 v2(71.56,64.7) ; v2(24.48,90.25) 24.47,90.24 24.47,90.12 24.48,90.11 RT100.2 ; v2(120.4,102.5) 120.4,102.58 120.02,102.96 CV22.2
  BOTTOM w0.508: v2(225.32,32.66) 225.38,32.73 225.38,33.35 ; QN1.4 267.59,18.4 267.28,18.1 v2(267.28,17.78) ; JRTC1.3 291.93,10.68 v2(291.93,10.98) ; RT130.2 24.76,105.32 v2(24.62,105.18) ; v2(187.91,47.57) CH31.2 ; v2(9.08,49.45) 9.55,49.92 JSD1.10 ; CMOS1.1 227.59,38.21 228,37.81 v2(228,37.46) ; RH322.1 RH326.1 211,11.63 v2(210.78,11.4) ; PR427.1 151.62,64.73 v2(151.68,64.79) ; v2(127.81,112.8) 129.31,114.3 JIR1.7 ; PC405.2 v2(154.15,60.93) ; RN19.2 253.46,16.85 253.73,17.12 v2(253.97,17.12) ; JEDP1.41 125.16,108.37 v2(124.68,107.9) ; v2(149.77,97.54) 150.1,97.21 QV19.3 ; v2(47.61,100.21) 47.71,100.21 47.87,100.05 47.9,100.05 48.18,99.77 PR1219.2 PC1206.2 49.2,99.08 49.25,99.03 PR1249.2 ; v2(356.35,40.66) JSIM1.14 ; v2(307.29,11.89) 307.21,11.81 CZ73.2 307.22,11.22 CZ63.2 ; CT70.2 v2(50.59,92.76) ; CD64.2 61.9,55.41 61.03,56.27 CC334.2 58.95,56.27 v2(58.73,56.49) ; RT414.2 v2(21.15,105.52) ; CV25.2 CV24.2 116.39,103.67 116.44,103.72 v2(116.44,104.28) ; v2(97.59,28.82) 97.59,29.74 97.13,30.2 JDIMM1.262 ; v2(49.7,70.13) PH1704.2 PR1770.2 ; CZ71.2 300.87,11.64 v2(301.12,11.89) ; v2(203.29,11.62) 203.7,11.2 RH317.1 ; v2(322.13,54.66) 323.04,54.66 323.55,54.15 JNGFF2.76 ; v2(155,94.68) CV632.2 154.1,94.66 RV624.2 ; v2(49.91,4.4) 49.91,4.27 49.28,3.64 PC207.2 ; v2(343.96,34.06) 343.96,34.1 343.34,34.72 CA53.2 ; PR506.2 v2(119.64,9.4) ; v2(369.11,40.6) 369.22,40.6 369.73,41.11 JSIM1.16 ; JSPI1.22 219.04,6.41 218.53,6.92 v2(218.53,6.92) ; PR927.2 8.66,44.82 9.2,44.82 v2(9.32,44.7) ; v2(357.68,85.75) 358.33,85.75 CV135.2 ; PR416.2 v2(150.67,64.79) ; JLED1.7 v2(326.34,4.7) ; v2(122.68,123.32) 122.07,123.32 UV2.2 ; v2(135.45,12.19) 135.23,12.19 134.72,11.68 CZ85.2 ; RH365.2 193.63,47.73 RH193.2 193.62,48.31 v2(193.4,48.53) ; PC409.2 152.49,64.59 v2(152.57,64.67) ; v2(353.61,101.12) 353.61,100.38 DV6.1 ; v2(24.38,125.55) 24.02,125.2 PR1227.2 ; PU503.4 73.32,5.8 73.24,5.87 ; v2(146.99,106.65) 146.74,106.9 CV17.2 ; RH70.2 220.93,48.67 v2(220.93,47.88) ; v2(44.5,84.35) 45.28,85.13 UT6.4 ; v2(346.73,19.74) 346.9,19.58 346.9,17.89 346.41,17.4 JSPK1.6 ; PC1213.2 PR1247.2 ; PR1247.2 PC1212.2 ; PR1247.2 38.03,101.69 37.92,101.8 v2(37.87,101.8) ; v2(300.05,5.73) 300.05,5.58 299.29,4.82 JUSH1.27 ; v2(233.82,32.34) 234.13,32.65 RH622.1 ; v2(94.85,123.63) 95.53,122.96 95.91,122.96 ; PC1217.2 88.18,112.42 88.69,112.93 v2(88.69,114.32) ; v2(75.53,63.5) 75.58,63.56 RC438.2 ; v2(120.54,127.99) 119.93,127.99 119.73,127.79 PR116.2 ; PR419.2 153.36,64.7 v2(153.38,64.72) ; CZ88.2 148.69,9.25 v2(148.46,9.02) ; v2(322.67,11.86) 322.98,11.86 323.77,11.07 RE86.2 ; v2(79.65,110.46) 79.13,109.94 PQ1216.3 ; CZ33.2 307.11,19.32 307.62,19.83 v2(307.62,20.08) ; CZ544.2 v2(143.32,85.86) ; DA2.1 v2(348.28,28.37) ; DI3.1 v2(79.9,121.02) ; CC305.2 v2(205.88,45.29) ; PC128.2 119.83,129 v2(119.83,129.52) ; v2(47.03,60.32) PC2008.2 ; CZ25.2 v2(321.7,64.25) ; PC513.2 70.15,5.15 v2(70.15,4.85) ; JEDP1.42 122.8,109.54 v2(122.3,109.04) ; UV4.2 v2(354.82,86.45) ; CI9.2 100.12,123.75 v2(100.4,124.03) 101.15,123.28 CI11.2 ; PC1211.2 PR1246.2 43.53,98.58 44.37,98.58 44.85,98.1 PQ1212.3 44.85,96.53 v2(45.41,95.96) ; v2(45.13,107.01) 46.1,106.04 PC1207.2 ; JIR1.3 132.21,114.41 132.89,115.09 v2(132.89,115.47) ; CA6.2 123.37,102.5 v2(123.62,102.26) ; RZ334.2 347.6,48.88 v2(347.95,49.22) ; PC221.2 42.16,12.11 v2(42.17,12.12) ; RT86.2 40.78,86.83 41.14,86.47 RT71.2 41.19,86.08 41.8,86.08 42.1,86.38 v2(42.14,86.38) ; CH4.1 215.76,12.2 v2(215.3,12.66) ; JSATA1.22 265,9.4 v2(264.9,9.3) ; v2(144.51,8.34) 144.7,8.15 144.7,7.39 145.47,6.63 JKBTP1.21 ; v2(11.38,80.87) 11.85,80.4 JSD1.25 ; RT103.2 38.46,94.43 v2(38.19,94.71) ; CE54.2 v2(313.03,38.12) ; RC114.2 73.8,66.36 73.54,66.36 v2(73.37,66.19) 72.98,66.58 RC441.2 ; v2(264.21,11.79) 264.31,11.89 264.5,11.89 265.9,13.28 JSATA1.21 ; v2(30.4,65.55) 32.02,65.55 JSD1.21 ; QZ17.4 296.21,43.21 297.51,44.51 QZ17.1 298.51,44.51 v2(298.66,44.67) ; v2(30.25,62.59) v2(31.01,62.59) 31.59,62.59 31.71,62.7 JSD1.3 ; QH6.3 198.22,5.47 v2(197.94,5.75) ; CZ37.2 v2(348.7,52.03) ; v2(212.14,47.57) 211.71,47.57 211.34,47.2 CC302.2 ; RN9.1 248.33,21.72 v2(248.41,21.79) ; JUSH1.28 313.23,4.82 v2(313.1,4.95) ; CV20.2 v2(110.85,103.09) ; PQ1210.4 77.63,113.95 78.05,114.38 v2(78.94,114.38) ; PC848.2 59.9,60.32 v2(59.51,59.94) ; v2(155.87,63.64) 155.88,63.64 155.88,63.65 156.2,63.33 PR420.2 ; v2(28.11,100.1) 28.11,100.04 28.38,99.77 CT92.2 ; v2(22.58,88.98) 22.86,89.26 RT82.2 ; v2(219.55,15.75) 219.62,15.68 CH5.1 ; CH40.1 211.91,12.24 RH323.1 211.89,11.89 212.12,11.66 v2(212.12,11.44) ; RH554.2 230.49,34.51 v2(230.91,34.92) ; CD32.2 68.11,61.34 v2(68.58,60.87) ; CV23.2 119.82,101.61 120.34,101.09 v2(120.34,101.07) ; DE1.2 v2(208.8,73.67) ; JIR1.8 133.67,115.37 v2(133.55,115.49) ; v2(72.21,74.83) 71.96,74.58 71.96,74.12 CC324.2 70.67,73.96 RC319.1 ; RN7.1 v2(249.35,21.79) ; v2(146.31,90.53) RV629.2 CV635.2 ; CT83.2 27.09,89.28 v2(26.11,89.28) ; JFAN1.6 207.49,64.25 v2(207.23,64.51) ; v2(247.4,21.79) 247.32,21.71 RN15.1 ; v2(21.51,88.92) 20.9,89.53 DI2.1 ; RA35.2 339.05,38.08 v2(339.36,37.77) ; v2(220.16,47.34) 220.16,47.75 220.06,47.85 RH612.1 ; DV5.1 v2(351.84,104.16) ; v2(325.08,65.18) 325.08,64.83 325.02,64.78 CZ18.2 ; v2(30.21,110.9) CT94.2 ; v2(136.29,12.19) 136.5,11.99 CZ86.2 ; CC320.2 227.71,29.36 228.25,29.91 v2(228.25,30.67) ; v2(362.7,41.11) JSIM1.15 ; CZ84.2 v2(129.97,8.58) ; CV133.2 360.77,98.91 v2(360.8,98.88) ; v2(180.58,1.55) PC2055.2 PC2036.2 ; CE40.2 326.75,35.6 327.21,35.6 v2(327.28,35.53) ; v2(130.09,56.48) 130.6,56.98 CC335.2 ; PR514.2 68.93,5.18 v2(69.39,4.72) ; RT99.2 41.23,88.86 41.68,89.32 41.68,91.9 v3(42.46,92.68) v2(45.08,95.3) ; 99.93,83.03 99.93,83.53 99.64,83.82 99.15,83.82 ; v2(319.32,5.1) 318.92,4.7 JLED1.8 ; CC304.2 204.96,52.91 v2(204.98,52.94) ; CZ41.2 349.51,53.84 v2(349.42,53.92) ; CH10.2 215.32,50.57 v2(214.78,50.02) ; v2(30.91,70) 31.11,69.8 31.77,69.8 JSD1.6 ; v2(26.08,88.57) 26.49,88.57 26.7,88.36 CT84.2 ; CZ21.2 v2(342.04,64.84) ; v2(293.28,20.11) 293.37,20.11 294.47,19.01 JNGFF1.77 ; v2(27.99,81.01) CT72.2 ; DA1.1 v2(353.11,28.12) ; CZ26.2 348.66,55.31 348.99,55.65 v2(348.99,56.48) ; CH324.2 196.31,14.93 v2(196.54,15.16) ; v2(37.63,103.58) 38.88,103.58 PC1201.1 ; CZ102.1 72.69,59.84 72.82,59.97 73.96,59.97 74.34,60.35 v2(74.34,60.6) ; CI44.2 v2(353.87,67.22) ; JSD1.26 13.7,50.48 v2(12.96,49.75) ; JSD1.24 27.13,51.22 27.13,51.22 30.65,51.22 v2(31.9,49.98) ; v2(236.17,16.42) 235.77,16.83 UC5.4 ; CV134.2 v2(358.87,97.23) ; CE47.2 323.9,33.33 324.38,33.81 v2(324.66,33.81) ; v2(8.3,42.82) 8.3,42.91 PQ909.3 ; RN13.1 v2(247.81,11.36) ; RV2.2 112.21,100.6 112.44,100.83 v2(112.44,101.12) 112.71,100.85 RV1.2 ; v2(156.41,61.19) 156.16,60.93 PC407.2 ; v2(37.47,102.95) 36.97,102.95 36.61,103.32 CT93.2 ; JNGFF3.77 v2(361.65,6.76) ; JSATA1.23 254.3,9.45 253.38,10.37 253.38,10.7 253.16,10.92 v2(253.16,11.65) ; v2(75.38,5.08) 75.64,5.33 PR516.2 ; CN8.2 265.48,17.56 265.45,17.59 v2(265.45,18.44) ; v2(155.05,92.8) 155.82,93.56 QV21.3 ; v2(303.64,18.02) 304.31,17.35 CZ34.2 ; 225.38,33.35 225.32,33.41 RC558.2 ; 225.38,33.35 225.73,33.69 RH618.1 ; DV4.1 126.5,102.22 v2(125.74,101.46) ; CV11.2 v2(117.14,101.31) ; CZ72.2 302.78,12.05 v2(302.56,11.84) ; v2(51.81,103.4) 51.16,103.4 50.28,102.51 PR1217.2 PC1205.2 ; CI43.2 v2(352.85,67.26) ; CZ103.2 v2(73.66,60.65) ; CZ23.2 v2(343.82,64.76) ; v2(189.43,46.13) CH20.2 ; CA12.2 350.82,40.66 351.58,40.66 v2(351.84,40.92) ; v2(206.15,53.04) 206.15,52.2 CC303.2 ; JNGFF2.77 344.25,56.26 344.47,56.48 v2(344.47,56.68) ; JSD1.22 34.56,53.55 v2(34.73,53.38) ; CZ69.2 304.83,12.05 v2(305.05,11.84) ; v2(347.2,27.34) 346.71,26.85 JSPK1.5 ; PC209.2 48.22,11.98 v2(48.88,12.64) ; v2(344.38,31.81) 343.73,31.17 CA56.2 ; JDIMM2.262 v2(176.4,26.95) ; CV634.2 142.63,94.59 v2(142.79,94.42) 142.93,94.29 CV636.2 143.5,94.87 RV626.2 143.53,95.27 CV633.2 ; v2(324.01,65.18) 324.01,64.93 324.13,64.81 CZ19.2 ; v2(164.32,9.32) PR609.2 ; PC1216.2 21.23,124.57 21.38,124.73 v2(21.38,125.37) ; CZ1200.2 124.73,98.44 v2(124.53,98.64) ; JIR1.2 131.41,114.88 v2(132,115.47) ; v2(254.4,11.65) 254.4,11.88 254.3,11.98 JSATA1.24 ; JRTC1.4 291.3,2.4 v2(292.02,1.68) ; RN11.1 v2(249.84,11.36) ; CZ17.2 v2(342.93,64.79) ; v2(142.11,58.33) 142.01,58.43 PC403.2 ; CZ24.2 323.24,64.69 323,64.93 v2(323,65.16) ; CN16.2 v2(250.36,21.79) ; JSD1.17 9.55,80.39 v2(10.03,80.87) ; CZ40.2 v2(349.51,49.61) ; UC6.4 v2(242.22,11.29) ; PC1215.2 v2(19.29,120.04) ; v2(34.98,81.56) 35.51,81.03 CT22.2 ; JFAN1.1 202.34,68.11 v2(202.03,68.43) ; v2(129.26,5.89) 128.81,5.44 PC506.2 ; v2(325.87,65.18) 325.91,65.13 CZ198.2 ; v2(190.4,14.94) 190.78,15.32 CH267.2 ; CT91.2 29.64,99.34 29.46,99.16 v2(29.42,99.16) ; CZ104.2 v2(154.96,53.9) ; RN21.2 v2(248.82,11.35) ; JNGFF1.76 297.48,39.71 297.48,39.71 v2(298.01,39.71) ; QN1.1 269.24,16.95 v2(269.24,17.78) ; v2(42.56,68.8) PC2021.1 ; v2(234.13,4.77) 233.4,4.77 233,5.17 JSPI1.21 ; RT63.2 RT100.2 ; v2(36.9,96.93) 36.74,96.76 CT86.2 36.76,96.28 37.48,96.28 37.51,96.31 CT85.2 ; RZ25.2 301.8,59.97 v2(301.22,60.54) ; JDIMM1.261 27.82,30.17 v2(30.38,30.17) ; v2(240.06,29.55) 240.06,28.25 RH65.2 ; v2(101.37,81.99) 100.73,81.99 99.93,82.79 RC141.2 ; PC1731.2 v2(50.64,78.17) ; JDIMM2.261 v2(106.69,30.2) ; v2(202.75,3.99) 203.3,3.99 205.65,6.34 CH340.2 ; v2(18.94,125.37) 18.41,124.84 PC1208.2 ; CT71.2 26.35,86.96 v2(26.31,86.99) ; CT82.2 v2(39.14,92.73) ; v2(311.92,43.59) 311.7,43.38 RE56.2 ; JLOM1.15 340.66,131.76 340.66,128.42 342.44,126.64 v3(343.07,126.64) v2(345.87,126.64) ; v2(231.79,33.39) 231.14,32.74 RH556.2 ; CH35.2 220.19,20.66 220.21,20.64 v2(220.21,20.11) 220.21,19.82 219.93,19.54 CH63.2 ; CV132.2 v2(359.58,86.77) ; v2(121.95,101.89) 121.7,102.15 CA5.2 ; CZ81.2 CZ80.2 155.09,8.33 v2(155.11,8.31) ; v2(133.95,5.91) 133.23,6.63 JKBTP1.22 ; PC1209.2 20.49,124.7 v2(20.49,125.37) ; v2(146.94,109.27) 146.47,108.8 RV3.1 ; v2(46.28,59.01) PR2003.2 ; v2(5.95,49.62) 6.25,49.92 JSD1.13 ; CZ89.2 v2(148.48,6.3) ; CT90.2 35.21,100.29 v2(34.72,100.79) 34.45,100.79 34.34,100.67 UT7.2 ; JESPI.12 269.99,26.19 v2(269.58,26.19) ; v2(26.31,93.83) 26.31,93.54 RT96.2 ; JSIM1.12 v2(351.52,53.48) ; v2(6.4,40.11) 6.24,40.26 PR925.2 ; JRTC1.2 294,6.2 v2(294.18,6.37) ; RN17.1 250.85,11.65 v2(251.18,11.33) ; JSD1.23 v2(25.95,80.54) ; v2(122.67,122.62) 122.67,122.32 122.82,122.17 CV39.2 ; CZ39.2 v2(348.57,46.19) ; JFAN1.5 v2(199.79,66.42) ; JSD1.20 33.22,77 v2(33.22,75.67) ; v2(40.41,11.41) PR209.2 ; v2(352.52,44.28) JSIM1.13
  vias: v2(0.43,24.11) v2(0.43,22.72) v2(0.43,21.45) v2(0.43,20.17) v2(0.43,18.9) v2(0.43,17.63) v2(0.43,16.36) v2(0.43,15.09) v2(0.43,13.75) v2(0.43,12.55) v2(0.43,11.28) v2(0.43,9.95) v2(0.5,106.92) v2(0.46,25.37) v2(0.83,80.46) v2(0.83,79.19) v2(0.83,77.92) v2(0.83,76.65) v2(0.83,75.38) v2(0.83,74.11) v2(0.83,72.84) v2(0.83,71.57) v2(0.83,70.3) v2(0.83,69.03) v2(0.83,67.76) v2(0.83,66.49) v2(0.83,65.22) v2(0.83,63.95) v2(0.83,62.68) v2(0.83,61.41) v2(0.83,60.14) v2(0.83,58.87) v2(0.83,57.6) v2(0.83,56.33) v2(0.83,55.06) v2(0.83,53.79) v2(0.89,52.52) v2(1,120.62) v2(1.13,8.98) v2(1.22,26.51) v2(1.59,125.47) v2(1.59,124.2) v2(1.59,122.93) v2(1.59,121.66) v2(1.59,105.6) v2(1.59,104.33) v2(1.59,103.06) v2(1.59,101.79) v2(1.66,126.74) v2(1.7,81.38) v2(1.93,8.18) v2(2.04,51.99) v2(2.23,45.18) v2(2.23,43.91) v2(2.23,42.64) v2(2.23,41.37) v2(2.23,40.1) v2(2.18,27.47) v2(2.23,7.04) v2(2.23,5.77) v2(2.23,4.5) v2(2.23,3.23) v2(2.23,1.96) v2(2.39,38.84) v2(2.51,100.28) v2(2.6,82.28) v2(2.77,127.81) v2(2.78,0.81) v2(3.05,46.16) v2(3.08,28.37) v2(3.23,37.88) v2(3.49,99.25) v2(3.5,83.18) v2(3.82,20.21) v2(3.82,16.99) v2(3.9,127.87) v2(3.9,108.62) v2(3.91,29.32) v2(4.05,46.93) v2(4.01,36.88) v2(3.99,0.43) v2(4.15,119) v2(4.16,50.73) v2(4.23,49.46) v2(4.23,48.19) v2(4.23,35.63) v2(4.23,34.36) v2(4.23,33.09) v2(4.23,31.82) v2(4.23,30.55) v2(4.39,122.8) v2(4.39,104.7) v2(5.17,127.87) v2(5.35,124.45) v2(5.35,121.15) v2(5.35,106.35) v2(5.35,103.05) v2(5.26,0.43) v2(6.44,127.87) v2(6.53,0.43) v2(6.6,21.81) v2(6.6,15.39) v2(7.25,124.45) v2(7.25,121.15) v2(7.25,106.35) v2(7.25,103.05) v2(7.71,127.87) v2(7.8,0.43) v2(8.2,122.8) v2(8.2,104.7) v2(8.38,98.59) v2(8.4,83.83) v2(8.39,48.13) v2(8.66,116.99) v2(8.69,34.93) v2(8.69,32.7) v2(8.98,127.87) v2(9.07,0.43) v2(9.38,20.21) v2(9.38,16.99) v2(9.39,10.41) v2(9.65,98.59) v2(9.67,83.83) v2(9.75,9.75) v2(9.81,33.81) v2(9.8,13.51) v2(10.16,10.44) v2(10.18,9.19) v2(10.25,127.87) v2(10.34,0.43) v2(10.61,9.78) v2(10.93,34.93) v2(10.93,32.7) v2(10.94,10.46) v2(11.02,9.17) v2(11.43,9.8) v2(11.51,127.68) v2(11.6,71.72) v2(11.61,0.43) v2(11.65,68.89) v2(11.76,10.49) v2(11.81,9.14) v2(12.01,125.34) v2(12.11,67.31) v2(12.09,65.23) v2(12.25,111.85) v2(12.19,9.8) v2(12.47,126.85) v2(12.48,107.66) v2(12.49,10.49) v2(12.62,125.33) v2(12.94,21.68) v2(12.94,21.07) v2(12.94,20.48) v2(12.94,19.9) v2(12.94,19.32) v2(12.94,18.73) v2(12.88,0.43) v2(13.18,85.51) v2(13.32,118.77) v2(13.28,10.49) v2(13.55,70.87) v2(13.52,21.65) v2(13.52,21.07) v2(13.52,20.48) v2(13.52,19.9) v2(13.52,19.32) v2(13.52,18.73) v2(13.65,126.38) v2(13.69,18.12) v2(14.15,0.43) v2(14.16,21.65) v2(14.16,21.07) v2(14.16,20.48) v2(14.16,19.9) v2(14.16,19.32) v2(14.16,18.73) v2(14.27,18.12) v2(14.58,63.34) v2(14.74,21.65) v2(14.74,21.07) v2(14.74,20.48) v2(14.74,19.9) v2(14.74,19.32) v2(14.74,18.73) v2(14.84,17.87) v2(14.92,126.37) v2(14.99,110.54) v2(15.19,63.35) v2(15.35,115.4) v2(15.42,0.43) v2(15.57,115.98) v2(15.68,117.46) v2(15.77,63.68) v2(15.93,83.34) v2(15.91,81.46) v2(15.97,38.82) v2(15.96,38.2) v2(15.97,37.57) v2(16.11,107.02) v2(16.19,126.37) v2(16.26,110.38) v2(16.71,69.05) v2(16.71,66.82) v2(16.71,40.39) v2(16.69,0.43) v2(17.46,126.37) v2(17.83,67.94) v2(17.85,101.14) v2(17.96,0.43) v2(18.21,102.84) v2(18.73,126.37) v2(18.72,99.4) v2(18.89,97.38) v2(18.94,69.05) v2(18.94,66.82) v2(18.97,1.8) v2(19.23,0.43) v2(19.29,99.39) v2(19.42,103.85) v2(19.4,2.18) v2(19.53,61.75) v2(19.6,97.33) v2(19.67,25.02) v2(19.67,24.33) v2(19.67,23.7) v2(20,126.37) v2(20.04,94.53) v2(19.96,63.19) v2(20.06,93.9) v2(20.06,93.29) v2(20.2,24.69) v2(20.2,24.05) v2(20.5,0.43) v2(20.85,28.94) v2(20.85,28.36) v2(20.84,27.75) v2(20.85,24.64) v2(20.85,24.03) v2(20.93,37.9) v2(20.93,37.2) v2(20.86,30.12) v2(20.86,29.54) v2(20.87,27.16) v2(20.9,26.55) v2(20.9,25.84) v2(20.91,25.25) v2(20.98,39.65) v2(20.95,38.95) v2(21.1,30.81) v2(21.27,126.37) v2(21.26,113.75) v2(21.26,112.58) v2(21.26,110.26) v2(21.34,69.96) v2(21.42,30.14) v2(21.42,29.43) v2(21.4,28.74) v2(21.4,28.05) v2(21.38,27.44) v2(21.46,26.89) v2(21.46,26.25) v2(21.7,30.78) v2(21.77,0.43) v2(21.95,43.46) v2(21.95,42.82) v2(21.95,42.19) v2(22.01,30.14) v2(22.01,29.4) v2(21.99,28.73) v2(22.27,115.51) v2(22.54,126.38) v2(22.58,113.75) v2(22.58,112.58) v2(22.58,111.42) v2(22.58,110.26) v2(22.59,102.51) v2(22.64,38.12) v2(22.65,87.93) v2(22.68,39.56) v2(22.73,38.8) v2(22.69,37.43) v2(23.04,0.43) v2(23.07,36.89) v2(23.34,37.43) v2(23.36,39.55) v2(23.36,38.81) v2(23.36,38.11) v2(23.36,36.36) v2(23.62,35.03) v2(23.63,34.43) v2(23.62,33.82) v2(23.62,33.17) v2(23.72,126.84) v2(23.9,113.75) v2(23.9,112.58) v2(23.9,109.1) v2(23.91,91.73) v2(24.18,63.37) v2(24.31,0.43) v2(24.36,102.77) v2(24.56,93.24) v2(24.56,91.34) v2(24.61,68.63) v2(24.68,127.68) v2(25.26,115.98) v2(25.38,117.56) v2(25.38,116.93) v2(25.57,2.18) v2(25.58,0.43) v2(25.94,127.87) v2(26.18,95.56) v2(26.21,2.18) v2(26.85,0.43) v2(27.21,127.87) v2(27.35,20.17) v2(27.56,16.28) v2(28.12,0.43) v2(28.48,127.87) v2(29.05,2.81) v2(29.05,2.17) v2(29.42,112.11) v2(29.39,0.43) v2(29.55,115.06) v2(29.52,110.93) v2(29.46,108.88) v2(29.46,108.06) v2(29.6,116.41) v2(29.75,127.87) v2(29.69,103.4) v2(29.71,102.79) v2(29.66,96.21) v2(29.65,2.83) v2(29.68,2.15) v2(29.84,113.07) v2(29.94,59.92) v2(30.03,60.81) v2(30.1,97.87) v2(30.27,2.84) v2(30.29,2.13) v2(30.66,0.43) v2(30.82,127.19) v2(30.85,125.92) v2(30.86,107.64) v2(30.86,106.98) v2(30.87,2.84) v2(30.87,2.15) v2(31.11,72.39) v2(31.06,71.18) v2(31.07,18.07) v2(31.31,98.09) v2(31.26,95) v2(31.35,89.69) v2(31.26,23.57) v2(31.37,124.76) v2(31.44,96.88) v2(31.47,2.84) v2(31.5,2.13) v2(31.59,107.59) v2(31.64,106.96) v2(31.75,96.27) v2(31.72,39.85) v2(31.93,0.43) v2(31.95,89.68) v2(32.08,2.83) v2(32.08,2.13) v2(32.4,124.02) v2(32.54,89.66) v2(32.51,23.72) v2(32.69,94.31) v2(32.67,2.83) v2(32.71,2.12) v2(33.07,84.61) v2(33.1,24.66) v2(33.2,17.72) v2(33.2,0.43) v2(33.27,2.44) v2(33.54,25.08) v2(33.66,123.87) v2(33.7,85.24) v2(33.7,84.61) v2(33.75,1.94) v2(34.28,87.92) v2(34.41,88.49) v2(34.41,87.35) v2(34.39,86.74) v2(34.47,0.43) v2(34.88,123.5) v2(34.92,122.24) v2(34.92,120.97) v2(34.92,119.7) v2(35.01,118.43) v2(35.1,60.1) v2(35.1,59.21) v2(35.1,58.09) v2(35.67,117.34) v2(35.74,0.43) v2(36.5,49.76) v2(36.79,116.73) v2(37.01,0.43) v2(37.17,10.01) v2(37.17,9.4) v2(37.17,8.74) v2(37.21,8.05) v2(37.21,7.39) v2(37.59,49.73) v2(37.78,9.99) v2(37.77,9.36) v2(37.75,8.74) v2(37.8,8.01) v2(38.05,116.67) v2(38.28,0.43) v2(38.85,18.18) v2(39.32,116.67) v2(39.42,12.72) v2(39.55,0.43) v2(40.51,9.63) v2(40.59,116.67) v2(40.82,0.43) v2(41.09,79.37) v2(41.14,8.59) v2(41.55,79.88) v2(41.86,116.67) v2(41.93,84.84) v2(41.93,84.2) v2(41.9,8.59) v2(41.96,82.7) v2(41.96,82.07) v2(41.96,81.43) v2(41.96,80.8) v2(41.99,18.56) v2(41.96,16.91) v2(42.09,0.43) v2(42.61,8.49) v2(42.71,64.17) v2(42.85,9.14) v2(43.02,9.75) v2(43.13,116.67) v2(43.12,7.98) v2(43.28,8.66) v2(43.36,0.43) v2(43.53,9.27) v2(43.71,8.16) v2(43.7,7.49) v2(43.66,4.9) v2(44.07,8.76) v2(44.25,18.51) v2(44.4,116.67) v2(44.63,0.43) v2(44.76,63.4) v2(44.78,7.75) v2(45.52,7.74) v2(45.68,116.69) v2(45.91,66.37) v2(45.91,65.07) v2(45.91,63.77) v2(45.94,11.48) v2(45.94,10.9) v2(45.9,0.43) v2(46.19,70.57) v2(46.19,69.81) v2(46.19,68.92) v2(46.19,68.15) v2(46.84,117.18) v2(46.76,66.92) v2(47.12,62.92) v2(47.17,0.43) v2(47.44,71.34) v2(47.47,66.37) v2(47.47,65.07) v2(47.47,63.77) v2(47.61,118.2) v2(47.78,123.26) v2(47.78,121.99) v2(47.78,120.72) v2(47.78,119.45) v2(47.8,70.51) v2(47.8,69.75) v2(47.8,68.86) v2(47.8,68.1) v2(48.05,72.92) v2(48.05,72.29) v2(48.05,71.65) v2(48.36,71.12) v2(48.44,0.43) v2(48.47,73.58) v2(48.69,72.92) v2(48.69,72.29) v2(48.69,71.65) v2(48.9,123.87) v2(48.97,74) v2(49.02,71.11) v2(49.32,72.92) v2(49.32,72.29) v2(49.32,71.65) v2(49.4,74.51) v2(49.59,73.9) v2(49.67,71.09) v2(49.71,0.43) v2(50.01,74.94) v2(50,74.32) v2(49.96,72.92) v2(49.96,72.29) v2(49.96,71.65) v2(50.17,123.87) v2(50.28,110.98) v2(50.98,0.43) v2(51.36,124.31) v2(51.66,125.54) v2(52.25,0.43) v2(52.75,18.89) v2(52.92,125.72) v2(53.52,0.43) v2(54.19,125.72) v2(54.46,19.12) v2(54.79,0.43) v2(55.21,84.51) v2(55.21,82.39) v2(55.21,80.27) v2(55.29,124.69) v2(55.46,125.72) v2(55.47,124.1) v2(56.06,17.44) v2(56.06,0.43) v2(56.5,127.74) v2(56.48,126.47) v2(57.33,84.51) v2(57.33,82.39) v2(57.33,80.27) v2(57.33,0.43) v2(57.6,128.37) v2(58.04,17.92) v2(58.04,16.35) v2(58.6,0.43) v2(58.87,128.37) v2(59.23,3.61) v2(59.45,84.51) v2(59.45,82.39) v2(59.45,80.27) v2(59.91,3.58) v2(59.87,0.43) v2(60.14,128.37) v2(60.46,18.72) v2(60.51,17.17) v2(60.58,3.61) v2(60.84,20.24) v2(61.14,0.43) v2(61.29,3.61) v2(61.41,128.37) v2(61.92,3.61) v2(62.04,17.52) v2(62.44,122.05) v2(62.41,0.43) v2(62.47,122.63) v2(62.58,3.58) v2(62.68,128.37) v2(63.38,20.87) v2(63.45,18.48) v2(63.54,17.79) v2(63.68,0.43) v2(63.95,128.43) v2(64.46,77.32) v2(64.58,80.37) v2(64.56,3.56) v2(64.82,113.44) v2(64.82,112.8) v2(64.82,112.17) v2(64.95,0.43) v2(65.07,129.03) v2(65.32,4.24) v2(65.27,3.56) v2(65.45,113.44) v2(65.45,112.8) v2(65.45,112.17) v2(65.45,88.67) v2(65.45,88.04) v2(65.45,87.4) v2(65.73,130.11) v2(65.83,137.73) v2(65.83,136.46) v2(65.83,135.19) v2(65.83,133.92) v2(65.83,132.65) v2(65.83,131.38) v2(65.99,114.81) v2(66.01,114.15) v2(65.96,4.22) v2(65.99,3.58) v2(66.09,113.44) v2(66.09,112.8) v2(66.09,112.17) v2(66.15,16.99) v2(66.22,18.52) v2(66.22,0.43) v2(66.4,91.63) v2(66.56,138.77) v2(66.59,96.16) v2(66.72,113.44) v2(66.72,112.8) v2(66.72,98.18) v2(66.95,91.07) v2(67.23,91.64) v2(67.49,0.43) v2(67.56,91.08) v2(67.83,138.77) v2(67.92,19.04) v2(67.92,17.32) v2(68.44,96.89) v2(68.6,134.2) v2(68.76,0.43) v2(68.91,99.25) v2(69.1,138.77) v2(69.29,98.11) v2(69.29,96.55) v2(69.5,135.76) v2(69.5,132.64) v2(69.47,101.36) v2(69.78,17.54) v2(70.03,0.43) v2(70.37,138.77) v2(70.59,98.11) v2(70.59,96.55) v2(71.04,115.59) v2(71.22,84.87) v2(71.3,135.76) v2(71.3,132.64) v2(71.27,18.29) v2(71.3,0.43) v2(71.52,23.55) v2(71.64,138.77) v2(71.67,115.59) v2(71.88,98.11) v2(71.88,96.55) v2(72.2,134.2) v2(72.31,8.41) v2(72.43,97.25) v2(72.57,0.43) v2(72.91,138.77) v2(73.05,8.38) v2(73.12,97) v2(73.29,97.64) v2(73.33,96.44) v2(73.62,95.92) v2(73.68,104.7) v2(73.71,97.08) v2(73.84,0.43) v2(74,97.68) v2(73.96,96.44) v2(74.13,105.14) v2(74.18,138.77) v2(74.34,97.08) v2(74.25,95.92) v2(74.63,97.68) v2(74.6,96.44) v2(74.89,95.92) v2(74.98,97.08) v2(75.07,83.95) v2(75.11,0.43) v2(75.27,97.68) v2(75.38,4.39) v2(75.45,138.77) v2(75.55,3.8) v2(76.22,98.07) v2(76.21,97.44) v2(76.38,0.43) v2(76.67,138.4) v2(76.65,103.61) v2(77.28,103.62) v2(77.47,137.41) v2(77.55,56.5) v2(77.65,0.43) v2(77.83,120.23) v2(77.85,54.79) v2(77.94,121.81) v2(77.91,97.08) v2(78.05,58.89) v2(78.26,53.92) v2(78.38,99.44) v2(78.46,52.85) v2(78.71,137.15) v2(78.72,133.34) v2(78.72,132.07) v2(78.72,130.8) v2(78.76,98.3) v2(78.76,96.73) v2(78.92,57.8) v2(78.92,0.43) v2(80,127.82) v2(80.05,98.3) v2(80.05,96.73) v2(80.08,6.98) v2(80.19,0.43) v2(80.56,7.44) v2(80.69,6.83) v2(80.87,8.03) v2(81.1,51) v2(81.2,7.47) v2(81.33,6.83) v2(81.35,98.3) v2(81.35,96.73) v2(81.53,8) v2(81.46,0.43) v2(81.81,7.44) v2(81.9,97.44) v2(81.96,6.83) v2(82.42,7.42) v2(82.47,52.2) v2(82.46,18.06) v2(82.57,6.81) v2(82.69,97.76) v2(82.67,96.74) v2(82.73,49.65) v2(82.73,0.43) v2(83.03,7.42) v2(83.21,104.93) v2(83.43,48.35) v2(83.55,105.52) v2(83.61,7.44) v2(83.68,122.83) v2(83.83,104.93) v2(83.87,51.1) v2(84,0.43) v2(84.06,121.69) v2(84.2,105.52) v2(84.32,49.97) v2(84.46,104.93) v2(84.49,18.04) v2(84.83,105.52) v2(85.12,118.33) v2(85.09,104.91) v2(85.27,0.43) v2(85.35,98.17) v2(85.45,105.5) v2(85.85,49.68) v2(86.45,50.68) v2(86.54,0.43) v2(87.09,118.34) v2(87.33,97.37) v2(87.27,49.25) v2(87.81,0.43) v2(88.03,71.62) v2(88.01,7.16) v2(88.06,66.57) v2(88.06,65.56) v2(88.17,118.33) v2(88.48,100.34) v2(88.48,99.04) v2(88.48,97.74) v2(88.48,50.58) v2(89.08,0.43) v2(89.33,100.89) v2(89.71,120.9) v2(89.75,103.86) v2(89.69,96.89) v2(89.85,101.64) v2(89.84,71.65) v2(90.01,102.23) v2(90.04,100.34) v2(90.04,99.04) v2(90.04,97.74) v2(90.29,120.88) v2(90.28,103.4) v2(90.35,0.43) v2(90.35,118.38) v2(90.41,7.24) v2(90.74,103.73) v2(90.66,101.74) v2(90.76,102.96) v2(90.75,102.34) v2(90.88,120.88) v2(90.85,66.57) v2(90.98,7.26) v2(91.14,101.36) v2(91.25,103.28) v2(91.22,101.98) v2(91.26,102.64) v2(91.54,120.88) v2(91.64,48.28) v2(91.61,7.26) v2(91.62,0.43) v2(91.91,101.09) v2(92.11,101.73) v2(92.17,52.35) v2(92.17,51.13) v2(92.2,49.33) v2(92.52,127.75) v2(92.6,62.47) v2(92.89,0.43) v2(93.02,51.93) v2(93.48,133.67) v2(93.48,132.4) v2(93.48,131.13) v2(93.77,94.13) v2(93.77,93.24) v2(93.92,137.4) v2(94.16,0.43) v2(94.28,49.53) v2(94.79,94.13) v2(94.79,93.24) v2(95.18,137.6) v2(95.27,51.56) v2(95.32,49.71) v2(95.43,0.43) v2(95.59,71.65) v2(95.93,131.83) v2(96.19,138.37) v2(96.31,128.27) v2(96.7,0.43) v2(96.97,97.48) v2(97.13,135) v2(97.46,138.37) v2(97.74,5.17) v2(98,73.17) v2(97.97,0.43) v2(98.12,100.45) v2(98.12,99.15) v2(98.12,97.86) v2(98.31,5.16) v2(98.55,132.79) v2(98.73,138.37) v2(98.69,101.98) v2(98.9,128.83) v2(98.97,101) v2(99.04,50.12) v2(99.06,52.01) v2(99.13,48) v2(99.08,46.08) v2(99.16,5.13) v2(99.24,0.43) v2(99.33,97.01) v2(99.52,66.38) v2(99.52,65.81) v2(99.52,65.25) v2(99.51,12.37) v2(99.55,64.6) v2(99.68,100.45) v2(99.68,99.15) v2(99.68,97.86) v2(99.79,23.89) v2(99.79,5.1) v2(100,138.37) v2(100.15,12.37) v2(100.29,51.28) v2(100.3,49.45) v2(100.3,47.54) v2(100.42,73.17) v2(100.38,5.08) v2(100.51,0.43) v2(100.73,101.97) v2(100.72,101.32) v2(100.73,12.34) v2(100.92,134.95) v2(100.92,133.68) v2(100.92,132.41) v2(100.92,103.37) v2(101.02,100.79) v2(101.04,5.1) v2(101.38,101.93) v2(101.43,101.29) v2(101.42,12.34) v2(101.75,105.74) v2(101.67,5.1) v2(101.76,100.76) v2(101.78,0.43) v2(102,64.06) v2(102.03,12.34) v2(102.05,101.9) v2(102.07,101.28) v2(102.24,63.44) v2(102.73,131.27) v2(102.66,115.82) v2(102.74,12.34) v2(102.84,51.38) v2(102.84,49.53) v2(102.82,47.75) v2(103.05,0.43) v2(103.24,58.71) v2(103.48,95.64) v2(103.46,95.01) v2(103.83,115.8) v2(104,131.27) v2(104.09,102.62) v2(104.32,0.43) v2(104.47,115.8) v2(104.5,105.37) v2(104.61,74.89) v2(104.91,90.92) v2(105.13,50.98) v2(105.27,131.27) v2(105.33,115.82) v2(105.29,101.41) v2(105.59,0.43) v2(105.74,107.87) v2(106.21,74.93) v2(106.37,104.32) v2(106.54,131.27) v2(106.79,104.93) v2(106.91,109.72) v2(107.04,101.36) v2(106.98,90.17) v2(107.13,115.87) v2(107.23,47.57) v2(107.51,107.85) v2(107.62,109.67) v2(107.81,131.27) v2(107.84,115.87) v2(107.79,104.29) v2(107.9,105.23) v2(108.12,93.14) v2(108.12,91.84) v2(108.12,90.55) v2(108.3,50.39) v2(108.36,109.74) v2(108.74,73.17) v2(108.88,86.29) v2(108.89,85.24) v2(108.98,93.69) v2(109.08,131.27) v2(109.18,96.74) v2(109.17,95.85) v2(109.19,95.2) v2(109.18,94.56) v2(109.34,89.7) v2(109.3,2.9) v2(109.35,73.17) v2(109.4,0.43) v2(109.47,115.98) v2(109.52,86.29) v2(109.52,85.24) v2(109.69,93.14) v2(109.69,91.84) v2(109.69,90.55) v2(109.94,105.37) v2(110.09,101.54) v2(110.16,124.38) v2(110.21,123.7) v2(110.2,4.46) v2(110.2,1.34) v2(110.35,131.27) v2(110.54,94.17) v2(110.57,105.37) v2(110.6,104.48) v2(110.67,0.43) v2(110.84,124.37) v2(110.89,123.7) v2(110.91,74.92) v2(111.13,94.17) v2(111.21,17.41) v2(111.25,51.13) v2(111.5,127.05) v2(111.62,131.27) v2(111.6,127.69) v2(111.69,94.54) v2(111.94,0.43) v2(112,4.46) v2(112,1.34) v2(112.06,109.58) v2(112.52,49.86) v2(112.89,131.27) v2(112.9,2.9) v2(113.21,0.43) v2(113.75,67.54) v2(113.75,66.89) v2(113.76,66.25) v2(113.76,65.62) v2(113.76,65.01) v2(113.87,62.18) v2(114.16,131.27) v2(114.28,51.1) v2(114.48,17.95) v2(115.43,131.27) v2(115.63,49.75) v2(116.23,5.33) v2(116.23,4.65) v2(116.49,1.96) v2(116.82,51.25) v2(117.28,137.92) v2(117.28,134.11) v2(117.28,132.84) v2(117.68,131.63) v2(117.68,2.42) v2(118.12,116.8) v2(118.34,115.45) v2(118.5,138.27) v2(118.48,81.15) v2(118.95,2.43) v2(119.17,129.44) v2(119.36,81.58) v2(119.77,138.27) v2(119.8,89.01) v2(119.89,115.48) v2(120,116.8) v2(120.22,2.43) v2(121.04,138.27) v2(121.55,58.4) v2(121.48,9.58) v2(121.49,2.43) v2(121.55,82.45) v2(121.57,76.16) v2(122.09,9.47) v2(122.31,138.27) v2(122.3,80.34) v2(122.8,83.65) v2(122.76,2.43) v2(123.24,91.59) v2(123.45,138.83) v2(123.47,75.09) v2(123.45,58.4) v2(123.66,76.16) v2(123.82,132.24) v2(123.89,129.84) v2(123.92,129.15) v2(123.9,95.45) v2(123.85,93.34) v2(123.9,92.62) v2(123.91,56.61) v2(123.96,71.82) v2(124.03,2.43) v2(124.18,139.87) v2(124.45,135.89) v2(124.46,135.3) v2(124.46,134.67) v2(124.54,74.84) v2(124.6,81.17) v2(124.68,82.91) v2(125.03,135.49) v2(125.03,134.86) v2(125.07,136.09) v2(125.14,9.52) v2(125.24,94.53) v2(125.23,92.39) v2(125.27,101.88) v2(125.25,54.85) v2(125.3,2.43) v2(125.45,139.87) v2(125.69,136.09) v2(125.67,135.49) v2(125.67,134.86) v2(125.65,76.1) v2(125.73,9.55) v2(125.76,56.61) v2(126.16,100.99) v2(126.28,136.11) v2(126.57,2.43) v2(126.72,139.87) v2(126.66,74.81) v2(127.03,135.97) v2(127.76,136.02) v2(127.78,76.09) v2(127.84,2.43) v2(127.99,139.87) v2(128.06,89.18) v2(128.39,136.02) v2(128.67,89.18) v2(129.11,2.43) v2(129.26,139.87) v2(129.49,136.02) v2(129.82,85.34) v2(130.12,136.02) v2(130.31,135.1) v2(130.34,134.48) v2(130.45,85.32) v2(130.38,2.43) v2(130.53,139.87) v2(130.87,135.89) v2(130.95,135.1) v2(131.59,71.85) v2(131.65,2.43) v2(131.8,139.87) v2(132.69,138.97) v2(132.92,2.43) v2(133.76,138.27) v2(134.19,2.43) v2(134.52,16.96) v2(134.67,18.48) v2(134.95,109.6) v2(135.03,138.27) v2(135.45,109.17) v2(135.46,2.43) v2(136.06,81.51) v2(136.3,138.27) v2(136.33,102.53) v2(136.38,101.31) v2(136.44,18.84) v2(136.44,17.31) v2(136.7,111.73) v2(136.72,111) v2(136.73,2.43) v2(137.45,138.81) v2(137.44,132.89) v2(137.46,132.08) v2(137.59,16.69) v2(137.99,132.66) v2(138,2.43) v2(138.17,132.08) v2(138.28,139.86) v2(138.61,19.55) v2(138.59,18.02) v2(138.73,131.7) v2(138.71,131.04) v2(138.68,130.43) v2(138.71,129.79) v2(138.71,129.18) v2(138.71,128.55) v2(138.73,108.61) v2(139.01,107.92) v2(139.32,129.51) v2(139.29,128.88) v2(139.27,2.43) v2(139.42,139.87) v2(139.49,98.7) v2(139.56,136.17) v2(140.04,97.12) v2(140.51,63.17) v2(140.53,62.59) v2(140.54,2.43) v2(140.56,61.82) v2(140.76,138.14) v2(140.83,133.76) v2(141.23,18.02) v2(141.81,2.43) v2(142.45,16.31) v2(143.08,18.1) v2(143.08,2.43) v2(143.16,20.46) v2(143.35,133.76) v2(143.52,138.15) v2(144.04,18.11) v2(144.35,2.43) v2(144.5,139.87) v2(144.62,136.07) v2(145.62,2.41) v2(145.77,139.87) v2(145.85,20.23) v2(145.85,18.69) v2(145.89,17.17) v2(146.73,125.44) v2(146.78,1.9) v2(147.04,139.87) v2(147.69,1.02) v2(148,54) v2(148.09,18.17) v2(148.31,139.87) v2(148.33,63.14) v2(148.76,53.97) v2(148.82,0.44) v2(148.97,63.14) v2(149.35,53.97) v2(149.27,51.65) v2(149.58,139.87) v2(149.59,129.82) v2(149.59,129.12) v2(149.6,65.46) v2(149.6,64.79) v2(149.84,51.08) v2(149.78,17.1) v2(149.91,51.65) v2(149.98,57.35) v2(149.98,56.77) v2(149.98,56.18) v2(149.98,55.6) v2(149.96,19.94) v2(149.99,18.41) v2(150.09,0.43) v2(150.54,24.15) v2(150.57,57.35) v2(150.57,56.77) v2(150.57,56.18) v2(150.57,55.6) v2(150.85,139.87) v2(150.91,60.34) v2(150.92,59.23) v2(151.15,57.35) v2(151.15,56.77) v2(151.15,56.18) v2(151.15,55.6) v2(151.36,0.43) v2(151.48,59.78) v2(151.51,17.4) v2(151.56,19.13) v2(152.05,60.35) v2(152.12,139.87) v2(152.05,59.23) v2(152.63,0.43) v2(153.39,139.87) v2(153.9,0.43) v2(154.66,139.87) v2(155.17,0.43) v2(155.4,17.72) v2(155.93,139.87) v2(156.44,0.43) v2(157.05,18.25) v2(157.2,139.87) v2(157.71,0.43) v2(158.47,139.87) v2(158.95,0.73) v2(159.03,3.26) v2(159.02,1.99) v2(159.26,18.53) v2(159.74,139.87) v2(159.76,4.31) v2(161.01,139.87) v2(161.03,4.36) v2(161.84,3.38) v2(161.88,2.11) v2(161.9,0.84) v2(162.28,139.87) v2(163.13,8.46) v2(163.13,7.82) v2(163.13,7.19) v2(163.13,6.55) v2(163.11,0.43) v2(163.55,139.87) v2(163.76,8.46) v2(163.76,7.82) v2(163.76,7.19) v2(163.76,6.55) v2(164.4,8.46) v2(164.4,7.82) v2(164.4,7.19) v2(164.4,6.55) v2(164.38,0.43) v2(164.82,139.87) v2(165.03,8.46) v2(165.03,7.82) v2(165.03,7.19) v2(165.03,6.55) v2(165.11,76.11) v2(165.15,74.19) v2(165.65,0.43) v2(165.67,8.46) v2(165.67,7.82) v2(165.67,7.19) v2(165.67,6.55) v2(166.09,139.87) v2(166.5,17.67) v2(166.92,0.43) v2(167.36,139.87) v2(167.46,24.74) v2(167.62,3.72) v2(167.64,3.15) v2(168.25,6.45) v2(168.19,0.43) v2(168.63,139.87) v2(168.97,90.77) v2(169.46,0.43) v2(169.74,25.07) v2(169.9,139.87) v2(170.09,86.19) v2(170.4,24.31) v2(170.4,23.65) v2(170.54,17.69) v2(170.73,0.43) v2(171.01,25.25) v2(170.95,6.22) v2(171.1,95.55) v2(171.17,139.87) v2(171.61,92.65) v2(171.88,82.07) v2(172,0.43) v2(172.26,46.38) v2(172.44,139.87) v2(172.7,66.41) v2(173.27,0.43) v2(173.4,8.9) v2(173.4,8.27) v2(173.4,7.63) v2(173.4,7) v2(173.71,139.87) v2(174.11,0.43) v2(174.22,18.49) v2(174.98,139.87) v2(174.95,0.44) v2(175.5,9.02) v2(175.5,8.38) v2(175.5,7.75) v2(175.5,7.11) v2(175.69,0.44) v2(176.25,139.87) v2(177.08,0.43) v2(177.52,139.87) v2(177.52,46.35) v2(177.85,22.3) v2(177.85,21.72) v2(178.35,0.43) v2(178.79,139.87) v2(179.62,0.43) v2(180.06,139.87) v2(180.49,50.39) v2(180.6,46.84) v2(180.89,0.43) v2(181.19,51.5) v2(181.33,139.87) v2(182.16,0.43) v2(182.6,139.87) v2(183.21,48.34) v2(183.19,3.95) v2(183.55,50.06) v2(183.8,28.94) v2(183.87,139.87) v2(183.98,24.59) v2(184.65,6.47) v2(184.65,1.43) v2(185.14,139.87) v2(186.27,33.36) v2(186.41,139.87) v2(187.51,31.13) v2(187.55,6.47) v2(187.55,1.43) v2(187.68,139.87) v2(188.03,33.03) v2(188.2,26.85) v2(188.2,23.13) v2(188.95,139.87) v2(188.92,39.13) v2(189.05,30.58) v2(189.01,3.95) v2(189.06,34.54) v2(189.23,31.76) v2(190.22,139.87) v2(190.81,23.76) v2(191.05,0.43) v2(191.49,139.87) v2(191.73,35.18) v2(192.24,21.74) v2(192.32,0.43) v2(192.49,66.08) v2(192.72,24.85) v2(192.76,139.87) v2(193.1,138.2) v2(193.59,0.43) v2(193.82,8.66) v2(194,136.64) v2(194.33,49.4) v2(194.86,0.43) v2(195.03,4.9) v2(195.09,53.3) v2(195.46,9.18) v2(195.8,136.64) v2(196.13,0.43) v2(196.19,8.83) v2(196.7,138.2) v2(196.8,48.92) v2(196.87,51.08) v2(197.4,0.43) v2(197.49,139.87) v2(198.67,139.38) v2(198.67,0.43) v2(199.34,138.3) v2(199.94,0.43) v2(200.31,15.48) v2(200.61,138.27) v2(201.21,0.43) v2(201.88,138.27) v2(202.16,30.68) v2(202.15,29.91) v2(202.48,0.43) v2(203.14,138.44) v2(203.53,139.65) v2(203.75,0.43) v2(204.78,139.87) v2(205.02,0.43) v2(206.05,139.87) v2(206.29,0.43) v2(206.64,35.82) v2(207.17,48.54) v2(207.32,139.87) v2(207.56,0.43) v2(208.59,139.87) v2(208.83,0.43) v2(209.86,139.87) v2(210.1,0.43) v2(211.13,139.86) v2(211.37,0.43) v2(211.67,138.95) v2(211.67,137.68) v2(211.67,136.41) v2(211.67,135.14) v2(211.67,133.87) v2(211.67,132.6) v2(211.67,131.33) v2(211.67,130.06) v2(211.67,128.79) v2(211.67,127.52) v2(211.67,126.25) v2(211.67,124.98) v2(211.67,123.71) v2(211.67,122.44) v2(211.67,121.17) v2(211.67,119.96) v2(211.82,118.62) v2(212.05,117.26) v2(212.26,116.01) v2(212.47,114.75) v2(212.64,0.43) v2(212.67,113.5) v2(212.88,112.25) v2(213.09,111) v2(213.3,109.74) v2(213.51,108.49) v2(213.72,107.24) v2(213.93,105.99) v2(213.91,0.43) v2(214.14,104.73) v2(214.35,103.48) v2(214.56,102.23) v2(214.77,100.98) v2(214.98,99.72) v2(215.19,98.47) v2(215.18,0.43) v2(215.4,97.22) v2(215.61,95.97) v2(215.82,94.71) v2(216.03,93.46) v2(216.24,92.21) v2(216.4,47.51) v2(216.45,0.43) v2(216.45,90.96) v2(216.66,89.7) v2(216.87,88.45) v2(217.08,87.2) v2(217.29,85.95) v2(217.41,41.97) v2(217.5,84.69) v2(217.71,83.44) v2(217.72,0.43) v2(217.92,82.19) v2(218.13,80.94) v2(218.34,79.68) v2(218.55,78.43) v2(218.76,77.18) v2(218.78,47.26) v2(218.97,75.93) v2(218.99,0.43) v2(219.18,74.67) v2(219.42,73.43) v2(219.69,72.19) v2(220,70.95) v2(220.26,0.43) v2(220.35,69.73) v2(220.74,68.52) v2(221.16,67.33) v2(221.28,24.79) v2(221.53,0.43) v2(221.62,66.14) v2(221.92,24.79) v2(222.11,64.97) v2(222.64,63.82) v2(222.8,0.43) v2(223.2,62.68) v2(223.72,52.65) v2(223.8,61.56) v2(224.07,0.43) v2(224.16,4.5) v2(224.43,60.45) v2(225.09,59.37) v2(225.24,51.27) v2(225.34,0.43) v2(225.79,58.31) v2(226.52,57.27) v2(226.61,0.43) v2(226.95,12.84) v2(227.27,56.25) v2(227.88,0.43) v2(228.06,55.25) v2(228.88,54.28) v2(229.15,0.43) v2(229.73,53.34) v2(230.42,0.43) v2(230.61,52.42) v2(230.74,18.73) v2(231.51,51.52) v2(231.69,0.43) v2(232.44,50.66) v2(232.96,0.43) v2(233.39,49.82) v2(234.23,0.43) v2(234.37,49.01) v2(235.38,48.24) v2(235.5,0.43) v2(236.4,47.49) v2(236.77,0.43) v2(237.45,46.77) v2(237.68,11.65) v2(238.04,0.43) v2(238.52,46.09) v2(239.23,20.4) v2(239.31,0.43) v2(239.61,45.44) v2(240.65,29.56) v2(240.58,0.43) v2(240.72,44.82) v2(240.66,15.44) v2(241.21,29.56) v2(241.85,44.23) v2(241.85,0.43) v2(242.59,15.44) v2(242.99,43.67) v2(243.12,0.43) v2(244.15,43.15) v2(244.39,0.43) v2(245.32,42.66) v2(245.73,36.32) v2(245.66,30.25) v2(245.66,0.43) v2(245.8,40.61) v2(246.31,36.32) v2(246.5,42.21) v2(246.93,0.43) v2(247.19,31.77) v2(247.19,30.25) v2(247.19,28.73) v2(247.7,41.79) v2(247.81,16.84) v2(248.18,35.7) v2(248.2,0.43) v2(248.71,30.25) v2(248.71,28.73) v2(248.76,35.7) v2(248.91,41.4) v2(249.46,16.84) v2(249.47,0.43) v2(250.13,41.05) v2(250.74,0.43) v2(251.36,40.74) v2(252.01,0.43) v2(252.6,40.46) v2(253.28,0.43) v2(253.85,40.21) v2(254.55,0.43) v2(255.1,40.01) v2(255.82,0.43) v2(256.36,39.84) v2(257.09,0.43) v2(257.62,39.7) v2(258.36,0.43) v2(258.89,39.73) v2(259.63,0.43) v2(260.16,39.85) v2(260.9,0.43) v2(261.42,40) v2(262.17,0.43) v2(262.68,40.19) v2(263.44,0.43) v2(263.71,32.6) v2(263.92,40.41) v2(264.05,7.41) v2(264.71,0.43) v2(265.17,40.68) v2(265.98,0.43) v2(266.4,40.99) v2(267.25,0.43) v2(267.62,41.33) v2(268.52,0.43) v2(268.83,41.71) v2(269.79,0.43) v2(270.03,42.13) v2(271.22,42.58) v2(272.39,43.08) v2(273.13,37.87) v2(273.13,36.24) v2(273.13,34.61) v2(273.54,43.6) v2(274.68,44.17) v2(274.75,37.87) v2(274.75,36.24) v2(274.75,34.61) v2(274.87,0.43) v2(275.8,44.77) v2(275.75,41.4) v2(276.14,0.43) v2(276.38,37.87) v2(276.38,36.24) v2(276.38,34.61) v2(276.9,45.4) v2(277.41,0.43) v2(277.98,46.07) v2(278.41,29.86) v2(278.68,0.43) v2(279.04,46.76) v2(279.95,0.43) v2(280.08,47.5) v2(281.1,48.26) v2(281.22,0.43) v2(282.09,49.06) v2(282.49,0.43) v2(283.05,49.88) v2(283.23,25.53) v2(283.76,0.43) v2(283.99,50.74) v2(284.9,51.62) v2(285.03,0.43) v2(285.15,11.05) v2(285.79,52.53) v2(285.84,25.53) v2(286.3,0.43) v2(286.47,31.35) v2(286.65,53.47) v2(286.9,11.07) v2(287.47,54.43) v2(287.5,11.07) v2(287.61,25.54) v2(287.57,0.43) v2(288.06,11.07) v2(288.27,55.42) v2(288.36,30.14) v2(288.62,11.03) v2(288.84,0.43) v2(289.03,56.43) v2(289.38,25.55) v2(289.77,57.47) v2(289.81,41.63) v2(290.11,0.43) v2(290.43,20.11) v2(290.47,58.53) v2(291.14,59.61) v2(291.07,36.49) v2(291.13,25.54) v2(291.38,0.43) v2(291.81,113.9) v2(291.81,112.63) v2(291.77,60.71) v2(292.04,111.39) v2(292.27,110.14) v2(292.4,115.03) v2(292.37,61.83) v2(292.49,108.89) v2(292.65,0.43) v2(292.72,107.64) v2(292.95,106.39) v2(292.94,62.97) v2(293.17,105.14) v2(293.4,103.89) v2(293.44,25.24) v2(293.46,115.72) v2(293.47,64.12) v2(293.53,19) v2(293.63,102.64) v2(293.85,101.39) v2(293.92,0.43) v2(293.96,65.29) v2(294.08,100.14) v2(294.3,98.89) v2(294.42,66.48) v2(294.5,112.9) v2(294.53,97.64) v2(294.72,115.87) v2(294.76,96.39) v2(294.84,67.67) v2(294.98,95.14) v2(295.21,93.89) v2(295.22,68.89) v2(295.19,0.43) v2(295.44,92.64) v2(295.65,91.48) v2(295.57,70.11) v2(295.88,90.23) v2(295.87,71.34) v2(295.99,115.87) v2(296.1,88.98) v2(296.14,72.58) v2(296.33,87.73) v2(296.34,23.52) v2(296.4,113.61) v2(296.37,73.83) v2(296.53,86.48) v2(296.46,0.43) v2(296.56,75.09) v2(296.69,85.22) v2(296.72,76.35) v2(296.81,83.95) v2(296.83,77.61) v2(296.89,82.69) v2(296.94,81.42) v2(296.94,80.15) v2(296.91,78.88) v2(297.26,115.87) v2(297.73,0.43) v2(297.81,56.29) v2(297.95,29.77) v2(298.53,115.87) v2(299,0.43) v2(299.8,115.88) v2(300.27,0.43) v2(300.85,116.6) v2(300.86,113.91) v2(301.03,126.75) v2(301.03,125.48) v2(301.03,124.21) v2(301.03,122.94) v2(301.03,121.67) v2(301.03,120.4) v2(301.03,119.13) v2(301.03,117.86) v2(301.3,32.8) v2(301.54,0.43) v2(301.62,127.87) v2(302.8,122.9) v2(302.81,0.43) v2(302.9,127.87) v2(303.16,55.54) v2(303.7,124.46) v2(303.7,121.34) v2(303.74,117.5) v2(303.95,114.25) v2(304.08,0.43) v2(304.17,127.87) v2(305.35,0.43) v2(305.44,127.87) v2(305.42,115.71) v2(305.41,54.98) v2(305.5,124.46) v2(305.5,121.34) v2(306,40.95) v2(306.02,40.28) v2(306.02,39.52) v2(306.03,38.71) v2(306.02,37.87) v2(306.4,122.9) v2(306.57,64.63) v2(306.62,0.43) v2(306.71,127.87) v2(306.93,65.48) v2(307.15,119.04) v2(307.81,116.26) v2(307.89,0.43) v2(307.98,127.87) v2(308.49,6.35) v2(309.14,114.08) v2(309.25,127.87) v2(309.16,0.43) v2(309.82,71.86) v2(309.75,70.69) v2(309.79,69.39) v2(309.8,68.61) v2(309.95,117.91) v2(310.13,122.05) v2(310.05,119.56) v2(310.43,0.43) v2(310.52,127.87) v2(310.92,124.28) v2(311.32,32.66) v2(311.36,116.34) v2(311.7,0.43) v2(311.79,127.87) v2(312.34,123.29) v2(312.97,0.43) v2(313.06,127.87) v2(313.08,118.52) v2(313.28,120.32) v2(313.46,53.73) v2(314.12,70.51) v2(314.24,0.43) v2(314.33,127.87) v2(314.83,125.02) v2(315.11,122.66) v2(315.51,0.43) v2(315.6,127.87) v2(315.85,121.21) v2(316.51,124.09) v2(316.78,0.43) v2(316.87,127.87) v2(316.9,4.34) v2(318.05,0.43) v2(318.1,128.18) v2(318.31,79.06) v2(319,129.07) v2(319.33,136.65) v2(319.33,135.38) v2(319.33,134.11) v2(319.33,132.84) v2(319.33,131.57) v2(319.33,130.3) v2(319.32,0.43) v2(319.45,73.68) v2(319.45,71.78) v2(319.6,67.82) v2(319.98,87.57) v2(319.98,86.3) v2(319.98,85.03) v2(320.15,137.62) v2(320.19,78.99) v2(320.32,69.49) v2(320.59,0.43) v2(320.7,79.46) v2(320.9,69.14) v2(321.27,137.01) v2(321.27,135.74) v2(321.25,87.57) v2(321.25,86.3) v2(321.25,85.03) v2(321.82,78.08) v2(321.86,0.43) v2(322.29,79.45) v2(322.52,87.57) v2(322.52,86.3) v2(322.52,85.03) v2(323.13,0.43) v2(323.92,78.46) v2(324.4,78.87) v2(324.4,0.43) v2(325.67,0.43) v2(326.21,71.94) v2(326.21,69.71) v2(326.34,55.41) v2(326.79,23.74) v2(326.94,0.43) v2(327.33,70.83) v2(327.33,54.89) v2(328.06,46.91) v2(328.21,0.43) v2(328.44,71.94) v2(328.44,69.71) v2(328.7,101.31) v2(329.09,104.76) v2(329.28,84.56) v2(329.28,83.95) v2(329.48,0.43) v2(330.02,41.91) v2(330.74,0.49) v2(331,47.63) v2(331.07,1.72) v2(331.22,59.08) v2(331.35,2.95) v2(331.63,22.64) v2(332.26,104.61) v2(332.39,3.69) v2(333.24,24.18) v2(333.21,19.76) v2(333.65,3.51) v2(334.21,63.57) v2(334.45,2.52) v2(334.53,1.25) v2(334.8,63.57) v2(334.92,28.57) v2(335.44,26.87) v2(335.45,63.57) v2(335.5,0.43) v2(335.61,23.76) v2(335.94,106.01) v2(336.07,63.54) v2(336.2,31.78) v2(336.5,33.26) v2(336.77,0.43) v2(337.35,33.23) v2(337.3,31.61) v2(338.04,0.43) v2(338.64,56.78) v2(339.31,0.43) v2(339.39,111.84) v2(339.39,64.08) v2(339.36,39.74) v2(339.36,35.8) v2(339.63,68.95) v2(339.84,50.38) v2(340.23,75.46) v2(340.3,111.84) v2(340.25,69.57) v2(340.25,68.33) v2(340.58,0.43) v2(340.81,19.05) v2(340.87,68.95) v2(341.22,64.11) v2(341.32,39.74) v2(341.32,37.77) v2(341.32,35.8) v2(341.53,10.66) v2(341.85,0.43) v2(342.05,8.06) v2(342.2,17.98) v2(342.23,10.69) v2(342.75,8.01) v2(342.87,10.69) v2(342.91,6.08) v2(343.12,0.43) v2(343.29,39.74) v2(343.29,37.77) v2(343.29,35.8) v2(343.79,5.72) v2(344.18,127.87) v2(344.39,0.43) v2(345.45,127.87) v2(345.66,0.43) v2(346.15,14.86) v2(346.72,127.87) v2(346.73,16.38) v2(346.93,0.43) v2(347.99,127.87) v2(348.07,13.89) v2(348.2,0.43) v2(348.81,68.35) v2(348.79,66.32) v2(349.26,127.87) v2(349.49,62.6) v2(349.49,61.79) v2(349.47,61) v2(349.47,0.43) v2(349.55,63.65) v2(349.87,13.96) v2(350.21,45.06) v2(350.53,127.87) v2(350.45,15.14) v2(350.59,71.12) v2(350.74,0.43) v2(350.87,44.47) v2(351.01,71.6) v2(351.44,93.2) v2(351.72,49.87) v2(351.8,127.87) v2(352.01,0.43) v2(352.19,71.57) v2(352.21,16.46) v2(352.34,51.66) v2(353.02,95.94) v2(353.02,90.46) v2(353.07,127.87) v2(353.28,0.43) v2(353.49,38.89) v2(353.69,54.19) v2(353.75,49.85) v2(353.87,38.38) v2(353.92,15.37) v2(354.08,16.45) v2(354.33,127.69) v2(354.38,37.87) v2(354.55,0.43) v2(355.12,126.69) v2(355.17,125.42) v2(355.17,124.15) v2(355.17,122.88) v2(355.17,121.61) v2(355.17,120.34) v2(355.17,119.07) v2(355.17,117.8) v2(355.17,116.53) v2(355.33,115.27) v2(355.32,78.9) v2(355.28,16.48) v2(355.49,82.43) v2(355.82,0.43) v2(355.92,114.15) v2(356.18,95.94) v2(356.18,90.46) v2(356.28,7.14) v2(356.56,111.41) v2(356.76,14.12) v2(356.89,113.32) v2(356.92,109.15) v2(357.09,16.42) v2(357.09,0.43) v2(357.35,7.62) v2(357.76,93.2) v2(358.09,112.91) v2(358.09,7.59) v2(358.36,0.43) v2(358.54,89.32) v2(358.59,14.19) v2(358.74,79.17) v2(358.81,63.28) v2(358.82,7.62) v2(358.87,82.29) v2(359,59.17) v2(358.96,48.8) v2(359.36,112.87) v2(359.63,0.43) v2(359.9,44.07) v2(360.63,112.87) v2(360.7,14.53) v2(360.9,0.43) v2(361.07,83.78) v2(361.12,82.51) v2(361.52,61.82) v2(361.51,57.46) v2(361.5,48.8) v2(361.9,112.87) v2(361.96,84.7) v2(362.06,81.66) v2(362.06,79.07) v2(362.23,76.58) v2(362.17,0.43) v2(362.53,108.99) v2(362.79,61.82) v2(362.82,20.21) v2(362.82,16.99) v2(362.87,46.49) v2(363.02,89.65) v2(363.17,112.87) v2(363.22,84.83) v2(363.33,81.57) v2(363.44,0.43) v2(363.48,86.33) v2(363.5,76.58) v2(363.65,59.07) v2(364.06,61.82) v2(364.44,112.87) v2(364.49,84.83) v2(364.62,111.54) v2(364.6,81.57) v2(364.72,105.89) v2(364.71,0.43) v2(364.81,89.54) v2(364.77,76.58) v2(365.22,104.72) v2(365.22,92.02) v2(365.18,90.76) v2(365.53,106.87) v2(365.51,79.24) v2(365.6,21.81) v2(365.6,15.39) v2(365.71,112.8) v2(365.76,84.83) v2(365.87,81.57) v2(365.97,89.02) v2(365.98,0.46) v2(366.67,111.97) v2(366.82,110.71) v2(366.82,109.44) v2(366.82,108.17) v2(366.79,106.9) v2(366.82,88.07) v2(366.82,86.8) v2(366.82,85.53) v2(366.82,80.73) v2(367.03,1.17) v2(367.31,79.56) v2(367.27,12.58) v2(367.27,11.31) v2(367.27,10.04) v2(367.27,8.77) v2(367.27,7.5) v2(367.27,6.23) v2(367.27,4.96) v2(367.27,3.69) v2(367.27,2.42) v2(367.38,13.62) v2(367.87,61.82) v2(368.2,78.65) v2(368.3,77.39) v2(368.38,20.21) v2(368.38,16.99) v2(368.76,58.91) v2(368.91,57.58) v2(369.14,61.82) v2(369.11,22.71) v2(369.3,54.16) v2(369.79,16.09) v2(369.86,21.69) v2(369.97,20.8) v2(370.41,61.82) v2(370.63,54.37) v2(370.97,60.68) v2(370.97,59.41) v2(370.97,58.14) v2(370.97,56.87) v2(370.97,55.6) v3(12.39,20.75) v3(15.67,121.69) v3(15.67,106.51) v3(16.82,118.47) v3(21.17,31.69) v3(24.08,37.97) v3(24.76,31.23) v3(32.43,1.42) v3(32.69,30.89) v3(48.88,68.15) v3(65.68,63.93) v3(66.52,4.46) v3(69.12,94.14) v3(73.25,113.72) v3(75.32,105.43) v3(75.9,5.84) v3(80.18,8.03) v3(81.28,105.79) v3(94.66,28.37) v3(98.66,127.6) v3(105.61,86.11) v3(120.19,87.15) v3(125.23,88.71) v3(148.54,52.5) v3(152.71,56.16) v3(167.31,7.06) v3(174.44,7.67) v3(323.77,84.86) v3(335.21,24.78) v3(354.63,80.67) v3(355.65,39.01) v3(356.41,84.1)
