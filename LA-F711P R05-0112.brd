# Allegro board LA-F711P R05-0112.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCIE_PTX_DRX_P6: length 241.8
  TOP w0.097: CR11.1 12.51,68.91 12.44,68.91 v2(12.23,69.11)
  IN3 w0.102: v2(12.23,69.11) 12.39,68.95 14.81,68.95 15.54,69.68 15.54,73.05 18.86,76.37 31.25,76.37 42.71,87.83 42.71,91.74 49.74,98.78 62.17,98.78 66.27,102.89 73.39,102.89 78.48,107.97 91.14,107.97 94.36,104.75 99.18,104.75 99.56,105.13 103.63,105.13 105,103.76 111.06,103.76 114.45,100.37 118.03,100.37 120.78,97.63 123.78,97.63 125.27,96.13 125.69,96.13 128.59,93.23 131.62,93.23 138.13,86.73 143.76,86.73 173.1,57.38 173.1,45.6 180.3,38.41 183.7,38.41 188.38,33.73 188.95,33.73 v2(189.12,33.91)
  BOTTOM w0.089: UH1.C21 193.79,33.69 193.88,33.6 193.88,33.51 193.79,33.42 193.08,33.42 192.87,33.22 191.45,33.22 191.41,33.26 190.28,33.26 190.02,33.51 189.5,33.51 189.12,33.89 v2(189.12,33.91)
PCIE_PTX_DRX_P7: length 156.8
  IN3 w0.102: v2(285.73,11.07) 286.1,10.7 286.1,10.53 284.9,9.33 269.76,9.33 269.55,9.12 269.11,9.12 266.99,7 257.83,7 257.46,6.63 240.56,6.63 239.47,5.54 226.5,5.54 225.21,6.83 220.78,6.83 219.93,5.99 217.68,5.99 216.58,7.1 216.58,7.1 216.53,7.15 216.53,7.15 215.46,8.22 211.19,8.22 209.51,9.9 203.55,9.9 202.42,11.03 199.02,11.03 196.55,13.5 195.85,13.5 189.17,20.18 188.38,20.18 185.37,23.19 185.37,24.28 185.14,24.51 184.85,24.51 184.49,24.87 v2(184.49,24.87)
  BOTTOM w0.089: 188,33.86 188.08,33.78 188.08,33.78 188.14,33.71 188.14,33.71 188.18,33.67 188.18,33.67 188.94,32.91 191.26,32.91 191.45,32.72 193.48,32.72 193.56,32.8 193.56,32.89 193.48,32.98 UH1.B23
  BOTTOM w0.097: v2(184.49,24.87) 184.49,24.86 184.88,24.48 185.01,24.48 185.38,24.84 185.38,29.9 185.06,30.21 185.06,33.35 185.7,33.99 187.87,33.99 188,33.86 ; v2(285.73,11.07) 285.95,11.29 285.95,14.43 288.93,17.41 288.93,21.77 291.56,24.39 291.56,28.24 290.45,29.35 290.45,30.84 290.65,31.05 290.95,31.05 CZ12.1
PCIE_PTX_DRX_P9: length 197.9
  IN3 w0.102: v2(357.42,14.21) 357.44,14.23 357.44,14.55 357.34,14.66 356.27,14.66 353.05,11.43 340.12,11.43 339.26,10.57 333.85,10.57 333.49,10.21 331.21,10.21 330.79,9.8 323.98,9.8 323.23,9.05 316.26,9.05 314.41,10.91 309.68,10.91 308.27,12.32 297.78,12.32 297.29,11.84 284.96,11.84 284.18,11.06 284.18,10.43 283.48,9.74 269.59,9.74 269.38,9.53 268.94,9.53 267.24,7.82 257.75,7.82 257.71,7.86 251.33,7.86 250.77,8.42 244.38,8.42 243.38,7.42 240.77,7.42 239.3,5.95 227.02,5.95 225.64,7.33 216.97,7.33 215.67,8.63 214.81,8.63 213.83,9.61 210.62,9.61 209.93,10.3 203.72,10.3 202.59,11.43 199.19,11.43 196.71,13.91 196.02,13.91 189.34,20.59 188.68,20.59 186.91,22.35 186.91,25.71 187.38,26.17 v2(188.2,26.17)
  BOTTOM w0.089: UH1.D34 194.35,27.44 193.82,27.44 193.76,27.38 189.93,27.38 188.52,25.97 188.4,25.97 v2(188.2,26.17)
  BOTTOM w0.097: CN66.2 357.61,13.58 357.61,14.01 357.53,14.09 357.53,14.1 v2(357.42,14.21)
PCIE_PTX_DRX_P10: length 190.9
  IN3 w0.102: v2(353.88,13.91) 353.64,14.14 352.74,14.14 350.65,12.05 337.32,12.05 336.75,11.48 330.59,11.48 329.64,10.54 315.73,10.54 313.96,12.31 311.49,12.31 310.85,12.94 297.52,12.94 297.03,12.46 284.54,12.46 283.56,11.48 283.56,10.8 283.11,10.36 269.33,10.36 269.14,10.17 268.7,10.17 266.99,8.46 261.65,8.46 261.02,9.09 244.03,9.09 242.99,8.04 240.2,8.04 238.76,6.6 227.6,6.6 226.25,7.95 217.22,7.95 215.93,9.25 215.21,9.25 214.22,10.24 212.83,10.24 212.29,10.78 210.45,10.78 210.3,10.93 204.68,10.93 203.55,12.06 199.45,12.06 196.97,14.53 196.28,14.53 189.42,21.4 188.89,21.4 187.54,22.75 187.54,24.59 187.77,24.82 188.01,24.82 188.19,24.99 v2(188.21,24.99)
  BOTTOM w0.089: UH1.B35 193.48,26.94 193.39,27.03 191.33,27.03 188.93,24.63 188.14,24.63 188.05,24.73 188.05,24.9 188.13,24.99 188.21,24.99 v2(188.21,24.99)
  BOTTOM w0.097: CN68.2 354.45,13.72 354.45,14.15 354.24,14.36 354.02,14.36 353.88,14.21 v2(353.88,13.91)
PCIE_PTX_DRX_P11: length 181.7
  IN3 w0.102: v2(189.86,24.43) 189.86,22.6 191.22,21.25 191.56,21.25 192.66,20.14 192.66,19.04 196.13,15.56 196.83,15.56 199.71,12.68 203.81,12.68 204.64,11.85 213.49,11.85 215.47,9.88 216.19,9.88 217.48,8.58 228.24,8.58 228.32,8.49 237.48,8.49 238.7,9.71 267.36,9.71 268.48,10.83 268.92,10.83 269.56,11.47 280.09,11.47 280.15,11.53 281.42,11.53 281.86,11.97 283.17,11.97 284.28,13.09 296.78,13.09 297.26,13.57 297.61,13.57 306.92,13.57 313.59,13.57 315.38,11.77 321.48,11.77 322.02,11.24 329.46,11.24 330.33,12.11 336.39,12.11 336.96,12.68 349.52,12.68 350.53,13.69 350.53,14.34 350.59,14.4 350.77,14.4 v2(350.95,14.21)
  BOTTOM w0.089: UH1.C36 193.78,26.2 193.54,26.43 193.29,26.43 193.11,26.61 191.51,26.61 190.05,25.14 190.05,24.63 v2(189.86,24.43)
  BOTTOM w0.097: CN70.2 351.04,13.25 351.49,13.7 351.49,14.32 351.34,14.46 351.2,14.46 v2(350.95,14.21)
PCIE_PTX_DRX_P12: length 176
  IN3 w0.102: v2(348.68,13.94) 348.68,14.37 348.51,14.54 348.05,14.54 346.82,13.3 336.7,13.3 336.24,12.84 330.18,12.84 329.73,12.39 326.13,12.39 325.85,12.67 315.4,12.67 313.88,14.19 297,14.19 296.52,13.71 284.02,13.71 282.91,12.6 281.6,12.6 281.2,12.19 279.37,12.19 279.28,12.1 269.3,12.1 268.77,11.57 267.97,11.57 266.77,10.37 237.28,10.37 236.77,9.87 220.21,9.87 219.76,9.42 217.53,9.42 216.44,10.5 215.72,10.5 213.75,12.48 204.9,12.48 204.07,13.31 201.34,13.31 200.8,13.84 199.43,13.84 197.08,16.19 196.39,16.19 193.64,18.94 193.64,21.55 191.26,23.94 191.26,24.86 191.04,25.08 191.04,25.7 191.27,25.93 v2(191.81,25.93)
  BOTTOM w0.089: UH1.E37 194.63,25.79 194.41,26.01 194.08,26.01 193.99,25.92 193.52,25.92 193.49,25.95 193.41,25.95 193.41,25.95 193.19,25.95 193.01,26.13 192.57,26.13 192.28,25.83 191.91,25.83 v2(191.81,25.93)
  BOTTOM w0.097: CN72.2 348.84,13.57 348.84,13.78 v2(348.68,13.94)
PCIE_PTX_DRX_P17: length 196.7
  IN1 w0.099: v2(191.77,22.15) 191.41,22.5 191.27,22.5 191.17,22.41 191.17,21.88 192.31,20.74 192.58,20.74 193.96,19.36 193.96,18.06 195.82,16.2 199.01,16.2 200.14,15.08 212.05,15.08 212.23,14.89 214.92,14.89 215.1,14.71 226.06,14.71 226.43,15.09 228.66,15.09 229.96,13.79 235.91,13.79 236.61,13.08 244,13.08 244.94,14.02 278.03,14.02 278.85,14.85 281.49,14.85 281.63,14.71 295.22,14.71 296.64,16.13 303.62,16.13 304.78,14.97 310.62,14.97 312.39,13.2 322.33,13.2 323.65,14.52 325.14,14.52 326.93,16.31 326.93,18.84 333.69,25.6 333.69,32.21 331.88,34.02 331.88,37.24 331.27,37.85 331.27,46.35 334.21,49.29 336.53,49.29 336.96,49.72 339.82,49.72 340.17,50.08 340.71,50.08 340.81,50.17 340.81,50.37 340.71,50.47 v2(340.65,50.47)
  BOTTOM w0.097: v2(340.65,50.47) 340.71,50.41 340.71,50.2 340.55,50.04 340.09,50.04 339.81,49.76 339.81,49.1 339.44,48.73 338.99,48.73 338.89,48.83 338.89,48.96 CZ11.1
  BOTTOM w0.102: v2(191.77,22.15) 191.85,22.22 192.24,22.22 193.26,23.25 UH1.B42
PCIE_PTX_DRX_P18: length 217.9
  TOP w0.097: v2(351.1,50.12) 351.12,50.14 351.12,50.15 351.26,50.29 354.34,50.29 354.87,49.75 v4(354.87,48.5) 354.87,46.96 357.79,44.04 358.43,44.04 358.75,44.35 358.75,44.62 CZ152.1
  IN1 w0.099: v2(351.1,50.12) 351.08,50.13 349.59,50.13 348.92,50.8 341.65,50.8 341.53,50.92 340.24,50.92 340.13,50.8 337.97,50.8 337.71,50.55 337.21,50.55 336.42,49.75 333.17,49.75 331.62,48.2 331.62,47.38 330.86,46.62 330.86,37.68 331.48,37.07 331.48,33.85 333.29,32.04 333.29,25.84 326.52,19.08 326.52,16.62 324.83,14.92 323.48,14.92 322.17,13.6 312.56,13.6 310.79,15.37 304.94,15.37 303.75,16.57 296.51,16.57 295.05,15.11 281.8,15.11 281.66,15.25 278.69,15.25 277.86,14.43 244.77,14.43 243.83,13.49 236.78,13.49 236.08,14.19 230.12,14.19 228.82,15.49 226.26,15.49 225.89,15.12 215.29,15.12 215.09,15.31 212.53,15.31 212.24,15.6 204.5,15.6 204.1,16.01 200.11,16.01 198.71,17.4 195.19,17.4 194.36,18.23 194.36,20 192.81,21.55 192.81,22.26 191.57,23.5 191.57,24.01 191.81,24.25 192.22,24.25 v2(192.32,24.35)
  BOTTOM w0.089: v2(192.32,24.35) 192.48,24.18 192.63,24.18 192.83,23.98 192.94,23.98 193.16,23.76 193.91,23.76 194.14,23.53 194.14,23.5 UH1.D42
PCIE_PTX_L_DRX_N18: length 1.5
  TOP w0.097: RI29.2 333.15,51.68 LI17.2 333.32,52.25 333.46,52.39 333.46,52.57 333.2,52.83 RZ1.1
PCIE_PTX_L_DRX_P18: length 1.5
  TOP w0.097: RZ2.1 333.95,52.83 333.64,52.52 333.64,52.37 333.82,52.19 LI17.3 333.99,51.68 RI30.2
PCIE_PTX_SW_DRX_N18: length 30.8
  TOP w0.097: UZ29.8 358.98,50.48 359.13,50.64 359.13,50.98 358.87,51.24 v4(356.55,51.24) 355.34,51.24 354.53,52.06 353.16,52.06 v2(352.96,51.86) ; v2(335.67,51.42) 335.47,51.62 335,51.62 334.84,51.46 334.84,50.39 334.22,49.78 333.67,49.78 333.47,49.98 333.47,50.09 333.32,50.23 LI17.1 333.15,50.76 RI29.1
  IN1 w0.099: v2(335.67,51.42) 335.84,51.6 336.16,51.6 336.52,51.95 336.52,52.31 336.94,52.74 344.11,52.74 344.22,52.63 350.36,52.63 350.91,52.07 352.75,52.07 v2(352.96,51.86)
PCIE_PTX_SW_DRX_P18: length 30.8
  TOP w0.097: RI30.1 333.99,50.76 LI17.4 333.82,50.35 333.65,50.18 333.65,50.09 333.65,50.06 333.75,49.96 334.15,49.96 334.65,50.47 334.65,51.54 334.92,51.81 335.47,51.81 v2(335.67,52) ; UZ29.7 359.48,50.53 359.32,50.68 359.32,51.06 358.95,51.43 356.88,51.43 356.84,51.47 356.26,51.47 356.22,51.43 355.42,51.43 354.61,52.24 353.16,52.24 v2(352.96,52.44)
  IN1 w0.099: v2(352.96,52.44) 352.81,52.29 351,52.29 350.44,52.84 344.3,52.84 344.19,52.95 336.86,52.95 336.3,52.4 336.3,52.04 336.08,51.81 335.86,51.81 v2(335.67,52)
PCIE_WAKE#: length 151.9
  TOP w0.102: RE274.1 309.21,30.38 309.03,30.56 308.1,30.56 307.04,31.62 305.95,31.62 304.15,33.43 301.35,33.43 300.4,32.48 300.4,31.21 300.63,30.99 300.63,27.13 299.45,25.95 299.45,24.06 v2(299.16,23.77) ; v2(319.88,5.92) 319.88,6.08 320.05,6.25 v1(320.05,9.02) 320.05,10.97 318.72,12.31 v2(318.72,16.15) 318.72,17.51 319.39,18.19 319.39,20.09 319.96,20.66 323.01,20.66 324.13,21.78 324.13,23.19 324.33,23.39 324.33,24.64 RE275.1 324.46,24.71 325.04,25.3 v2(325.04,25.55)
  IN1 w0.099: v2(318.72,16.15) 318.54,16.15 317.45,17.24 313.82,17.24 311.78,19.29 311.78,22.7 310.63,23.84 299.23,23.84 v2(299.16,23.77)
  IN3 w0.102: v2(337.64,57.12) 337.64,50.88 332.02,45.26 332.02,42.18 332.6,41.59 332.6,39.3 331.16,37.86 331.16,28.15 329.45,26.44 325.93,26.44 v2(325.04,25.55)
  BOTTOM w0.102: JNGFF1.55 295.76,25.11 296.48,24.4 298.47,24.4 299.1,23.77 v2(299.16,23.77) ; JNGFF2.54 337.9,59.94 337.36,59.4 337.36,57.4 v2(337.64,57.12) ; v2(319.88,5.92) 319.88,5.86 322.41,3.33 329.17,3.33 330.56,4.72 335.77,4.72 336.72,3.77 337.68,3.77 340.53,6.63 344.72,6.63 346.39,4.96 346.39,3.83 347.3,2.92 JNGFF3.54
PCIE_WAKE#_R: length 6
  TOP w0.102: 323.32,28.1 323.13,27.91 323.13,27.22 v1(323.82,26.54) 324.4,25.95 RE275.2
  TOP w0.104: 323.32,28.1 RE35.1 323.32,28.74 UE1.N13
PCIECOMP: length 3.3
  BOTTOM w0.089: UH1.A13 192.74,37.88 190.75,37.88 v1(190.61,37.74) 189.81,37.74 RH192.1
PCIECOMP#: length 3.8
  BOTTOM w0.089: RH192.2 190,38.08 192.92,38.08 192.95,38.05 UH1.B12
PD1_GPIO2: length 8.2
  BOTTOM w0.076: 36.83,86.96 36.36,87.43 35.49,87.43 35.48,87.43 35.28,87.43 35.28,87.43 35.21,87.43 34.97,87.19 UT5.D10
  BOTTOM w0.102: v1(42.24,85.76) 42.12,85.65 40.71,85.65 RT71.1
  BOTTOM w0.104: RT71.1 40.05,86.31 37.48,86.31 36.83,86.96
PD1_GPIO6: length 4
  BOTTOM w0.076: 36.42,88.92 35.5,88.92 35.48,88.93 35.18,88.93 34.94,88.69 UT5.G10
  BOTTOM w0.104: 36.42,88.92 v1(36.81,89.31) 37.31,89.81 37.31,90.34 RT75.1
PD1_GPIO7: length 2.9
  TOP w0.102: v1(34.24,84.9) 34.13,85 34.13,85.88 RT339.1 33.65,86.26 v2(33.13,86.78)
  BOTTOM w0.076: UT5.D7 33.38,87.03 v2(33.13,86.78)
PD1_GPIO8: length 4
  TOP w0.102: 32.3,90.58 RT76.1 RT377.1 v1(32.05,92.49)
  TOP w0.104: 32.3,90.58 33.14,89.75 v2(33.14,89.71)
  BOTTOM w0.076: v2(33.14,89.71) 33.14,89.44 UT5.H6
PD#: length 12.3
  TOP w0.102: UA1.47 337.81,35.97 337.58,35.74 337.58,34.22 v1(337.19,33.83) 336.93,33.57 336.93,33.06 336.66,32.79 336.51,32.79 CA31.1 336.63,32.04 336.63,31.74 336.83,31.54 336.83,30.36 336.8,30.33 RA48.2 336.8,29.16 337.49,28.47 338.03,28.47 DA8.2 338.08,28.13 RA18.1 RA50.2
PECI_EC_R: length 4.1
  TOP w0.102: 324.68,32.7 324.37,32.7 323.92,33.15
  TOP w0.104: 324.68,32.7 325.24,33.26 325.24,34.34 RE60.1 ; UE1.K13 323.92,33.15
PEG_COMP: length 10.1
  TOP w0.127: RC2.2 121.13,47.01 v2(120.89,46.77)
  BOTTOM w0.076: 118.37,51.12 118.37,51.5 117.04,52.83 UC1.G2
  BOTTOM w0.127: v2(120.89,46.77) 120.89,48.04 121.08,48.23 121.08,48.79 119.93,49.94 119.55,49.94 118.37,51.12
PG_1.8VALW: length 53.6
  TOP w0.102: v2(119.02,9.05) v1(118.45,9.05)
  IN1 w0.099: v2(119.02,9.05) 119.02,9.52 119.6,10.11 130.3,10.11 131.16,9.25 142.16,9.25 142.44,9.52 147.11,9.52 148.12,10.53 160.56,10.53 v2(160.84,10.81)
  IN1 w0.254: v2(121.13,6.58) 121.13,7.04 119.12,9.05 v2(119.02,9.05)
  BOTTOM w0.102: PR2011.1 159.7,8.33 159.37,8.66 159.37,9.34 v2(160.84,10.81)
  BOTTOM w0.254: v2(121.13,6.58) 121.13,6.17 120.5,5.54 PU501.5 ; PR517.1 119.02,9.04 v2(119.02,9.05)
PG_+1VALWP: length 7.9
  BOTTOM w0.102: PU301.9 166.27,6.9 166.08,7.1 166.08,7.48 166.27,7.67 166.27,8.53 165.93,8.86 163.8,8.86 v1(163.69,8.98) 163.57,8.86 162.44,8.86 PR2013.2 PR2012.1
PGOOD_3V: length 4.9
  BOTTOM w0.102: v1(84.18,9.93) 84.45,9.66 84.45,8.45 84.25,8.25 84.21,8.25 PR119.1
  BOTTOM w0.254: PU100.9 86.04,7.61 85.66,7.99 PR107.2 84.05,7.99 PR119.1
PGOOD_5V: length 282.8
  TOP w0.102: v2(167.81,109.37) 167.5,109.05 167.5,94.97 166.67,94.14 166.67,76.38 169.55,73.5 169.55,63.69 168.3,62.43 168.3,54.51 169.67,53.14 169.67,44.49 173.85,40.31 175.77,40.31 v2(181.85,34.22) ; v2(122.26,136.07) v1(122.26,136.66)
  TOP w0.254: v2(122.26,136.07) 122.26,135.31 PR113.2 122.69,135.12 123.37,134.44 PU102.9
  IN1 w0.099: v2(122.26,136.07) 120.76,134.57 120.76,132.12 121.31,131.56 121.31,126.98 123.61,124.67 126.25,124.67 127.86,123.06 153.35,123.06 166.86,109.56 167.63,109.56 v2(167.81,109.37) ; v2(181.85,34.22) 181.85,34.09 181.09,33.33 181.09,18.43 179.24,16.59 177.86,16.59 175.6,14.33 148.07,14.33 146.99,13.24 137.83,13.24 137,12.42 137,12.17 136.57,11.73 132.25,11.73 131.65,12.33 112.76,12.33 111.78,13.31 108.63,13.31 105.38,16.56 104.44,16.56 104.39,16.51 104.38,16.51 104.02,16.15 104.02,15.02 105.89,13.16 105.89,12.04 105.48,11.63 99.59,11.63 98.75,12.47 91.89,12.47 91.26,11.84 89.18,11.84 88.54,11.2 85.82,11.2 84.07,9.45 81.99,9.45 81.53,8.99 81.53,8.66 81.84,8.35 v2(82.23,8.35)
  BOTTOM w0.104: PR120.1 82.54,8.04 v2(82.23,8.35)
PLTRST_CPU#: length 177
  TOP w0.102: v2(83.49,83.24) v3(83.49,83.9)
  IN3 w0.102: v2(166.75,55.33) 166.75,55.83 166.32,56.26 166.32,59.24 148.01,77.55 147,77.55 142.46,82.08 137.45,82.08 132.38,87.15 121.95,87.15 118.63,83.82 117.91,83.82 116.17,82.08 103.76,82.08 103.33,82.51 100.96,82.51 99.89,83.58 83.83,83.58 v2(83.49,83.24)
  BOTTOM w0.076: UC1.BP35 81.32,77.4 80.98,77.4 80.76,77.18 79.13,77.18 78.18,78.13
  BOTTOM w0.089: UH1.AG5 205.68,41.94 205.65,41.97 205.65,42.16 205.52,42.29 205.52,43.18 205.29,43.42 205.29,47.17 205.89,47.78 205.89,49.43 204.92,50.41 203.84,50.41 203.47,50.77 203.47,51.43 203.25,51.65 203.25,52.31 202.34,53.22 202.1,53.22
  BOTTOM w0.102: 202.1,53.22 198.6,56.72 194.09,56.72 187.42,63.38 174.97,63.38 166.91,55.33 v2(166.75,55.33) ; 78.18,78.13 76.06,78.13 75.68,78.51 75.68,79.53 76.07,79.92 79.75,79.92 81.21,81.38 81.21,82.45 82,83.24 v2(83.49,83.24)
PLTRST_LAN#: length 122.4
  TOP w0.102: UL1.36 317.66,84.1 317.38,83.82 317.38,83.56 314.23,80.42 v1(311.62,80.42) 309.42,80.42 301.67,72.67 301.67,67.63 288.25,54.21 288.25,41.54 284.6,37.9 284.6,33.84 277.78,27.01 263.24,27.01 v2(262.62,26.39)
  BOTTOM w0.102: v2(262.62,26.39) 262.58,26.43 258.12,26.43 256.22,24.52 246.04,24.52 245.19,23.67 235.67,23.67 RH62.1
PLTRST_TPM#: length 8.1
  TOP w0.102: v2(243.95,27.26) 245.34,27.26 245.44,27.36 UZ12.17
  BOTTOM w0.102: v2(243.95,27.26) 243.95,26.78 243.84,26.68 v1(243.23,26.68) 242.44,26.68 241.55,25.79 RH60.2 239.49,25.82 RH187.1
PM_LANPHY_ENABLE: length 171
  TOP w0.102: v2(278.66,17.97) 278.66,19.69 280.82,21.86 280.82,22.2 278.76,24.26 278.76,27.1 285.24,33.57 285.24,36.67 288.6,40.04 290.6,40.04 290.83,40.28 290.83,41.82 288.95,43.71 288.95,54.33 301.59,66.98 304.06,66.98 307.75,70.67 307.75,75.25 309.38,76.89 317.45,76.89 318.03,76.31 323.98,76.31 325.29,77.62 327.96,77.62 329.36,79.02 v1(329.36,79.91) 329.36,81.3 328.45,82.21 RL7.1
  IN3 w0.089: v2(219.29,23.49) 219.34,23.54 219.46,23.54 220.15,24.23 220.83,24.23
  IN3 w0.102: 220.83,24.23 222.74,24.23 224.13,22.84 229.47,22.84 230.41,21.9 230.79,21.9 231.55,21.15 232.74,21.15 235.98,17.91 250.22,17.91 250.52,18.2 255.72,18.2 256.02,17.91 258.39,17.91 258.81,18.33 262.8,18.33 263.09,18.03 265.95,18.03 266.32,18.4 269.28,18.4 269.38,18.3 270.33,18.3 271.08,17.55 278.24,17.55 v2(278.66,17.97)
  BOTTOM w0.089: UH1.BF41 214.96,24 215.09,24.13 215.7,24.13 215.89,23.94 217.96,23.94 218.36,23.54 219.23,23.54 v2(219.29,23.49)
PME#: length 4.2
  BOTTOM w0.089: UH1.BE36 214.38,26.2 214.61,26.42 214.88,26.42 215.14,26.68 216.79,26.68 216.91,26.57 T178.1
POA_WAKE#: length 40.1
  TOP w0.104: UE1.E4 v2(315.72,37.55)
  IN3 w0.102: v2(317.91,25.32) 317.77,25.32 317.45,25.64 317.45,26.04 316.91,26.57 316.91,27.76 313.13,31.55 313.13,35.5 314.76,37.13 315.16,37.13 315.57,37.55 v2(315.72,37.55)
  BOTTOM w0.102: v2(315.72,37.55) 315.72,37.57 316.14,37.99 316.14,38.62 316.1,38.66 316.1,39.13 315.45,39.79 315.45,42.17 RE324.1 ; v2(317.91,25.32) 317.81,25.22 317.81,14.94 v1(315.92,13.06) 314.09,11.23 313.25,11.23 313.04,11.43 312.22,11.43 RZ364.1
POA_WAKE#_R: length 2.9
  BOTTOM w0.102: RZ364.2 v1(310.78,10.03) 310.78,9.65 310.9,9.53 310.9,8.95 310.83,8.88 JUSH1.4
POWER_SW#_MB: length 266.2
  TOP w0.102: JAPS1.11 177.82,45.08 178.46,45.73 v3(178.46,49.46) 178.46,50.97 179.16,51.66 179.16,53.85 181.49,56.18 182,56.18 182.74,56.92 v2(183.62,56.92) ; v2(290.27,52.18) 289.61,51.52 289.61,45.62 v2(289.35,45.36) ; v2(308.7,53.61) 308.7,52.46 311.7,49.45 CE10.1 312.74,49.45 313.2,48.99 RE33.2 ; v2(328.98,77.49) 329.87,77.49 346.06,93.69 SW3.2 SW3.4
  IN2 w0.102: v2(289.35,45.36) 284.6,45.36 281.71,42.48 275.94,42.48 273.34,39.88 272.03,39.88 271.48,39.33 268.93,39.33 268.21,38.61 266.07,38.61 265.14,37.68 252.92,37.68 252.65,37.95 250.27,37.95 249.24,38.98 245,38.98 243.82,40.15 240.38,40.15 236.49,44.05 235.27,44.05 223.25,56.07 218.85,56.07 213.26,61.66 184.41,61.66 183.62,60.87 v2(183.62,56.92)
  IN3 w0.102: v2(328.98,77.49) 328.6,77.11 320.85,77.11 317.17,73.43 310.18,73.43 308.7,71.95 v2(308.7,53.61)
  BOTTOM w0.102: v2(290.27,52.18) 290.62,52.53 297.21,52.53 298.3,53.62 308.69,53.62 v2(308.7,53.61)
POWER_SW_IN#: length 14.8
  TOP w0.102: RE31.2 314.61,48 RE33.1
  TOP w0.104: UE1.D5 v2(317.32,37.55) ; v2(315.74,47.01) 315.68,46.95 CE12.1 314.61,47.94 RE31.2
  BOTTOM w0.102: 317.72,44.74 317.72,44.04 318.05,43.72 318.05,41.96 317.29,41.2 317.29,39.72 317.7,39.31 317.7,37.93 v2(317.32,37.55)
  BOTTOM w0.104: v2(315.74,47.01) 315.74,46.72 317.72,44.74
PROCHOT#: length 446.4
  TOP w0.102: v2(72.94,74.95) 72.63,75.27 69.15,75.27 69.01,75.41 65.37,75.41 64.22,76.56 PR1704.2 63.45,76.58 v2(62.76,77.27) 62.66,77.37 PR1712.2 ; PR926.1 8.3,39.6 8.3,41.55 7.67,42.19 7.67,45.77 7.77,45.87 7.92,45.87 8.81,46.76 8.81,47.42 9.34,47.95 v1(10.52,47.95) 12.66,47.95 v2(12.73,48.01) ; v2(327.32,37.1) 327.12,36.9 RE288.2
  IN2 w0.102: v2(308.33,46.68) 308.94,46.07 308.94,42.3 310.17,41.07 311.95,41.07 314.28,38.73 318.44,38.73 319.24,37.93 323.33,37.93 324.01,37.25 326.97,37.25 327.12,37.1 v2(327.32,37.1) ; v2(62.76,77.27) 55.08,69.58 55.08,62.28 48.59,55.8 43.82,55.8 42.52,54.5 42.52,54.48 40.26,52.23 39.11,52.23 38.72,51.84 v2(38.72,51.82)
  BOTTOM w0.102: v2(12.73,48.01) 12.73,48.9 13.83,50 14.31,50 15.76,51.45 23.72,51.45 25.36,49.81 30.85,49.81 31.3,49.37 34.66,49.37 37.11,51.82 38.72,51.82 v2(38.72,51.82) 38.72,51.82 38.9,51.82 39.26,52.18 42.28,52.18 43.58,53.49 43.58,53.91 45.45,55.78 55.13,55.78 55.46,56.11 57.17,56.11 57.91,55.37 57.91,48.47 62.24,44.15 137.09,44.15 138.72,45.77 151.46,45.77 158.85,53.16 158.85,55.16 162.91,59.22 162.91,60.89 169.85,67.83 169.85,68.6 171.47,70.23 197.63,70.23 200.96,66.9 200.96,66.74 203.35,64.35 203.67,64.35 203.67,64.35 203.97,64.35 212.69,55.63 219.39,55.63 229.84,45.17 229.84,41.48 231.05,40.28 238.06,40.28 242.09,36.25 244.38,36.25 246.25,34.38 266.44,34.38 267.05,33.77 269.27,33.77 269.99,33.04 280.6,33.04 285.48,37.93 285.48,44.55 290.5,49.58 302.46,49.58 303.82,48.21 306.8,48.21 v2(308.33,46.68) ; v2(72.94,74.95) 72.72,74.73 CC324.1 72.72,73.16 RC83.2 73.31,72.57 RC84.1
PROCHOT#_ISL88738: length 149
  TOP w0.203: PU901.23 8.81,36.35
  TOP w0.254: PR926.2 7.79,38.18 7.79,36.98 v2(7.98,36.79) 8.11,36.66 8.49,36.66 8.81,36.35
  IN1 w0.099: v2(77.97,108.92) 77.2,108.92 72.24,103.96 65.19,103.96 62.7,101.47 60.4,101.47 60.22,101.65 54.08,101.65 51.54,99.11 40.65,99.11 34.89,93.35 29.18,93.35 26.56,95.97 20.16,95.97 19.35,95.16 19.35,86.14 17.36,84.15 17.36,79.4 15.88,77.93 5.79,77.93 2.15,74.3 2.15,57.22 5.4,53.98 5.4,46.3 9.88,41.82 9.88,39.91 7.95,37.97 7.95,36.83 v2(7.98,36.79)
  BOTTOM w0.102: v1(74.79,108.04) PQ1216.1 77.08,108.04 v2(77.97,108.92)
PROCHOT#_R1: length 3.4
  TOP w0.102: RE288.1 325.42,36.9 323.93,35.41 323.93,35.36
  TOP w0.104: UE1.H13 323.93,35.36
PS8802_ADDR: length 4.6
  TOP w0.102: RT136.1 26.64,110.5 v1(27.61,111.47) ; RT136.1 26.21,110.45 25.76,110.9 v2(25.76,111.28) ; RT136.1 RT135.1
  BOTTOM w0.102: UT9.19 25.73,111.25 v2(25.76,111.28)
PS8802_CEQ: length 12.4
  TOP w0.102: v1(17.64,121.06) RT139.1 RT140.1 18.64,119.93 19.03,119.53 19.35,119.53 v2(19.48,119.4)
  IN2 w0.102: v2(18.65,112.99) 18.8,113.14 18.8,114.76 19.49,115.44 19.49,117.61 18.91,118.2 18.91,119.09 19.22,119.4 v2(19.48,119.4)
  BOTTOM w0.102: v2(18.65,112.99) 19.03,112.61 19.6,112.61 19.64,112.65 UT9.48
PS8802_CSCL: length 15.9
  TOP w0.102: RT305.1 25.37,107.58 25,107.21 v2(24.56,107.21) ; v2(26.97,97.94) 26.97,97.56 27.86,96.67 RT375.1
  BOTTOM w0.102: v2(26.97,97.94) 26.67,98.25 26.67,99.9 v1(25.86,100.7) 25.04,101.52 25.04,104.33 26.06,105.35 26.06,106.61 25.61,107.06 25.6,107.06 25.45,107.21 v2(24.56,107.21) 24.3,107.21 23.8,107.72 UT9.28
PS8802_CSDA: length 15.6
  TOP w0.102: RT376.1 26.97,96.88 26.34,97.51 v2(26.34,97.94) ; RT304.1 24.37,106.58 v2(24.24,106.7)
  BOTTOM w0.102: UT9.29 23.45,107.62 23.67,107.4 23.67,107.21 24.18,106.7 v2(24.24,106.7) 24.75,106.7 24.88,106.83 25.51,106.83 25.83,106.51 25.83,105.5 24.81,104.48 24.81,101.26 26.34,99.73 v1(26.34,98.67) v2(26.34,97.94)
PS8802_DPEQ: length 4.1
  TOP w0.102: v2(25.83,110.17) 25.62,110.17 RT138.1 25.13,109.24 v1(25.64,108.74) 25.9,108.74 26.03,108.61 RT137.1
  BOTTOM w0.102: v2(25.83,110.17) 24.9,110.17 UT9.22
PS8802_HPD: length 1.7
  TOP w0.102: RT380.2 19.15,109.77 v2(19.26,109.88)
  BOTTOM w0.102: UT9.40 19.38,109.85 19.35,109.88 v2(19.26,109.88)
PS8802_REXT: length 2.1
  BOTTOM w0.102: UT9.39 19.08,109.5 18.78,109.19 RT300.1
PS8802_RST#: length 6
  TOP w0.102: v1(18.53,111.53) 18.78,111.28 v2(18.78,110.9) 19.46,110.9 CT122.1 19.47,110.72 19.86,110.32 20.68,110.32 21.21,110.85 21.7,110.85 RT246.2
  BOTTOM w0.102: UT9.43 v2(18.78,110.9)
PS8802_SBU1_R: length 4.7
  BOTTOM w0.089: UT9.33 22.05,107.52 21.97,107.44 21.97,107.15 21.71,106.9 20.13,106.9 19.96,106.73 19.96,106.54 RT414.1 20.3,106.2 RT132.1
PS8802_SBU2_R: length 4.7
  BOTTOM w0.089: RT133.1 RT415.1 19.77,106.62 19.77,106.81 20.05,107.09 21.64,107.09 21.78,107.23 21.78,107.44 21.7,107.52 UT9.34
PS8802_SSEQ: length 8
  TOP w0.102: v2(18.7,112.23) 18.72,112.22 18.72,111.98 19.03,111.66 20.56,111.66 20.94,112.04 v1(21.95,112.04) 22.81,112.04 23.2,111.65 RT142.1 RT141.1
  BOTTOM w0.102: v2(18.7,112.23) 18.72,112.23 18.72,112.04 18.84,111.92 19.06,111.92 19.13,111.85 19.54,111.85 19.64,111.95 UT9.46
PS_ID: length 352.1
  TOP w0.102: v2(69.9,128.02) v1(69.9,128.57)
  TOP w0.104: UE1.J8 v2(319.72,33.55)
  TOP w0.254: PR4.1 70.38,126.61 PR5.2 v2(69.9,128.02)
  IN3 w0.102: v2(326.09,57.67) 326.09,57.24 328.47,54.86 328.47,48.78 327.33,47.64 327.33,46.32 327.73,45.92 327.73,43.47 326.62,42.36 326.62,41.64 324.18,39.2 324.18,36.66 322.88,35.37 321.08,35.37 320.8,35.09 320.54,35.09 320.15,34.7 320.15,34.04 319.72,33.6 v2(319.72,33.55)
  BOTTOM w0.102: v2(69.9,128.02) 69.9,127.2 79.41,117.69 98.66,117.69 100.68,119.71 124.18,119.71 126.36,121.89 146.97,121.89 176.16,92.71 196.52,92.71 212.34,76.88 212.34,63.21 217.19,58.37 222.15,58.37 236.4,44.12 238.43,44.12 240.41,42.14 241.59,42.14 244.51,39.22 249.05,39.22 250.17,38.1 265.95,38.1 265.96,38.11 268.72,38.11 269.48,38.87 272.34,38.87 272.36,38.89 278.91,38.89 279.13,38.67 280.37,38.67 281.5,39.8 281.5,45.6 289.8,53.9 296.64,53.9 299.88,57.14 310.4,57.14 311.04,57.78 320.33,57.78 321.11,58.56 321.45,58.56 322.86,57.15 325.57,57.15 v2(326.09,57.67)
PWM1_1PH/ICCMAX1: length 76.2
  TOP w0.203: PU1700.44 61.34,81.59 61.86,81.07 v2(61.95,81.07)
  IN3 w0.254: v2(105.15,89.08) 104.61,89.08 104.28,89.41 104.28,91.6 103.32,92.56 97.37,92.56 97.14,92.33 92.53,92.33 92.05,92.81 62.19,92.81 61.29,93.71 56.21,93.71 54.44,91.95 54.44,89.28 55.25,88.47 55.25,86.27 56.46,85.06 60.63,85.06 60.94,84.75 60.94,81.44 61.34,81.05 61.93,81.05 v2(61.95,81.07)
  BOTTOM w0.102: PR1722.1 v1(61.03,79.88)
  BOTTOM w0.203: PR1722.1 61.8,80.92 v2(61.95,81.07) ; v2(105.15,89.08) 105.54,89.47 PU2001.1
PWM1_2PH/ICCMAX2: length 29.8
  TOP w0.203: v2(51.27,76.13) 50.54,75.39 50.54,65.49 47.26,62.2 v1(44.6,62.2) v2(42.8,62.2) ; v2(52.71,80.37) 52.89,80.37 53.71,81.19 PU1700.23
  IN3 w0.254: v2(51.27,76.13) 52.08,76.93 52.08,80 52.45,80.37 v2(52.71,80.37)
  BOTTOM w0.203: PR1756.1 53.35,80.37 v2(52.71,80.37)
  BOTTOM w0.254: v2(42.8,62.2) 43.29,62.7 PU2000.1
PWM1_4PH/ICCMAX4: length 32.3
  TOP w0.203: PU1700.18 53.1,83.19 v2(52.75,82.84)
  IN2 w0.254: v2(52.75,82.84) 52.42,82.84 51.97,83.29 51.97,88.35 53.04,89.43 53.04,91.59 56.18,94.73 60.65,94.73 66.05,100.14 67,100.14 v2(67.23,100.37)
  BOTTOM w0.102: v1(52.21,83.59) 52.21,83.34 52.71,82.84 v2(52.75,82.84)
  BOTTOM w0.203: v2(52.75,82.84) 53.02,83.11 PR1758.1
  BOTTOM w0.254: PU1800.1 67.39,100.52 v2(67.23,100.37)
PWM2_2PH/ROSC1: length 5.1
  TOP w0.102: PR1762.1 v1(51.54,78.16)
  TOP w0.203: PU1700.22 53.63,81.59 52.87,80.83 52.52,80.83 52.06,80.38 52.06,79.71 PR1762.1
PWM2_4PH/ADDR: length 47
  TOP w0.203: v2(52.67,82.26) 52.84,82.26 53.37,82.79 PU1700.19
  IN2 w0.254: v2(52.67,82.26) 52.46,82.26 51.19,83.53 50.03,83.53 49.42,84.14 49.42,86.86 50.84,88.28 51.33,88.28 52.66,89.61 52.66,91.75 56.03,95.11 59.83,95.11 67.19,102.48 75.03,102.48 75.45,102.89 75.93,102.89 76.83,102 v2(76.83,101.28)
  BOTTOM w0.203: PR1759.1 52.71,82.22 v2(52.67,82.26)
  BOTTOM w0.254: PU1801.1 77.4,100.71 v2(76.83,101.28)
PWM3_4PH/VBOOT: length 63.2
  TOP w0.203: PU1700.20 53.5,82.39 52.86,81.75 51.94,81.75 PR1760.1 51.25,81.63 v2(51.25,81.99)
  IN2 w0.254: v2(51.25,81.99) 51.03,81.99 49.04,83.98 49.04,87.02 50.68,88.66 51.17,88.66 52.28,89.77 52.28,91.9 55.87,95.49 59.67,95.49 67.26,103.09 74.35,103.09 75.42,104.15 83,104.15 84.31,102.84 84.31,96.8 84.79,96.32 85.56,96.32 v2(85.72,96.15)
  BOTTOM w0.102: v1(50.81,82.4) 51.21,81.99 v2(51.25,81.99)
  BOTTOM w0.254: PU1900.1 85.96,96.67 85.72,96.43 v2(85.72,96.15)
PWM4_4PH/ROSCM: length 76
  TOP w0.203: v2(51.1,80.75) 51.1,80.52 PR1761.1 51.69,80.22 51.69,80.6 52.3,81.21 v1(52.62,81.21) 52.79,81.21 53.57,81.99 PU1700.21
  IN2 w0.254: v2(95.48,96.21) 95.48,100.22 88.55,107.15 79.42,107.15 77.57,105.3 75.49,105.3 73.74,103.56 67,103.56 59.31,95.87 55.71,95.87 51.9,92.06 51.9,89.93 51.01,89.04 50.53,89.04 48.66,87.18 48.66,83.82 51.1,81.39 v2(51.1,80.75)
  BOTTOM w0.254: v2(95.48,96.21) 95.48,96.63 95.63,96.78 PU1901.1
PWM_FAN1: length 190.6
  TOP w0.102: v2(203.54,68.36) 203.61,68.29 RE48.2
  TOP w0.104: UE1.L10 v2(320.52,31.95)
  IN3 w0.102: v2(320.52,31.95) 320.52,32 320.94,32.42 320.94,32.91 321.2,33.17 321.48,33.17 321.7,33.39 321.7,33.67 321.96,33.93 323.92,33.93 324.43,34.44 324.58,34.44 325.51,35.37 325.51,36.85 329.49,40.83 329.49,46.69 331.56,48.77 331.89,48.77 332.91,49.79 332.91,52.28 328.19,57.01 v2(328.19,57.58)
  BOTTOM w0.102: v2(203.54,68.36) 203.59,68.31 JFAN1.2 203.59,65.69 213.2,56.08 221.11,56.08 235.97,41.21 238.1,41.21 242.38,36.93 248.1,36.93 249.97,35.06 266.72,35.06 267.33,34.45 271.98,34.45 272.36,34.07 279.83,34.07 284.8,39.04 284.8,44.84 290.8,50.85 302.62,50.85 303.49,49.97 311.84,49.97 313.62,51.75 314.47,51.75 318.9,56.18 320.16,56.18 320.49,55.85 324.27,55.85 324.57,56.16 327.21,56.16 328.19,57.14 v2(328.19,57.58)
RED: length 11.4
  TOP w0.107: v2(358.69,105.69) LV16.2 358.78,105 CV129.1 v1(361.1,105) 362.33,105 JCRT1.1
  BOTTOM w0.107: v2(358.69,105.69) 358.14,105.13 DV5.2
RED_CRT: length 48.3
  TOP w0.107: v2(355.59,104.09) RV116.1 CV126.1 358.61,104.09 LV16.1 ; v2(330.63,72.8) 330.63,72.41 330.04,71.83 UV6.23
  IN1 w0.099: v2(355.59,104.09) 354.39,102.89 352.87,102.89 329.71,79.74 329.71,73.71 v2(330.63,72.8)
REFCLK_CNV: length 138
  TOP w0.089: v1(200.58,39.8) RH110.1 199.59,39.91 199.22,40.28 199.22,40.86 v2(199.27,40.91)
  IN1 w0.089: 208.75,21.06 211.26,21.06 211.91,20.41 ; v2(199.27,40.91) 199.27,40.7 198.8,40.23
  IN1 w0.099: 208.75,21.06 208.11,21.06 207.95,21.22 206.21,21.22 203.22,24.2 201.38,24.2 200.76,24.83 200.76,26.85 200.24,27.37 198.08,27.37 197.9,27.55 197.9,28.05 197.62,28.34 197.62,39.69 198.12,40.19 198.76,40.19 198.8,40.23 ; 211.91,20.41 212.09,20.23 214.31,20.23 214.69,20.61 222.38,20.61 222.7,20.29 226.81,20.29 227.92,19.18 238.1,19.18 239.53,17.76 240.29,17.76 240.8,17.24 249.86,17.24 250.43,16.67 254.1,16.67 255.18,17.76 257.91,17.76 258.53,18.38 262.79,18.38 263.41,17.76 265.66,17.76 266.28,18.38 285.13,18.38 286.51,16.99 293.74,16.99 295.33,18.58 296.09,18.58 296.82,19.31 297.12,19.31 298.57,20.76 301.83,20.76 302.9,19.68 306.76,19.68 307.01,19.94 v2(307.01,20.12)
  BOTTOM w0.089: v2(199.27,40.91) 199.69,40.91 UH1.R6
  BOTTOM w0.107: v2(307.01,20.12) 307.01,20.29 306.76,20.54 RZ371.1
REM_DIODE1_N: length 295.3
  TOP w0.127: QE3.3 94.78,64.23 CE35.1 94.56,63.5 v2(94.39,63.33) ; v2(288.36,29.49) 288.54,29.31 288.89,29.31 289.61,30.03 289.61,33.79 291.52,35.7 291.52,36.6 295.2,40.28 295.2,46.2 295.46,46.46 295.46,53.14 301.46,59.13 v4(306.26,59.13) 310.16,59.13 311.29,58 318.2,58 320.58,55.62 320.58,45.11 320.7,44.99 320.7,43.44 320.61,43.35 320.61,42.98 CE24.1 320.37,42.55 320.37,42.34 319.92,41.9 319.41,41.9 319.05,41.53 319.05,40.62 UE1.A8
  IN1 w0.127: v2(288.36,29.49) 288.19,29.33 288.01,29.33 287.98,29.36 274.28,29.36 271.88,31.76 252.1,31.76 251.17,32.69 249.7,32.69 249.34,33.06 244.71,33.06 244.6,33.17 242.56,33.17 238.02,37.71 236.52,37.71 227.55,46.68 227,46.68 221,52.68 212.88,52.68 210.93,54.63 197.85,54.63 197.65,54.42 194.73,54.42 192.87,52.56 188.18,52.56 183.19,47.57 174.89,47.57 172.84,49.62 156.58,49.62 153.97,52.23 153.97,54.11 153.03,55.04 143.91,55.04 139.32,59.64 139.32,62.12 136.97,64.46 121.9,64.46 121.9,64.47 121.34,64.47 121.34,64.46 121.31,64.46 120.94,64.84 119.09,64.84 119.03,64.9 115.08,64.9 113.92,63.73 113.92,63.14 113.22,62.45 113.22,61.68 113.1,61.55 102.87,61.55 101.42,63 96.34,63 96.01,62.67 94.6,62.67 94.39,62.88 v2(94.39,63.33)
REM_DIODE1_P: length 297.8
  TOP w0.127: UE1.A7 318.83,40.66 318.83,41.62 319.32,42.11 319.83,42.11 320.11,42.39 320.11,42.57 CE24.2 320.45,43.55 320.45,44.89 320.33,45.01 320.33,55.51 318.1,57.75 311.19,57.75 310.06,58.88 301.56,58.88 295.72,53.03 295.72,46.35 295.46,46.09 295.46,40.17 291.78,36.5 291.78,35.6 289.86,33.68 289.86,29.92 289,29.06 288.53,29.06 v2(288.35,28.89) ; v2(93.81,63.32) 93.81,63.42 93.65,63.59 CE35.2 93.48,64.17 QE3.2 94.13,65.77 QE3.1
  IN1 w0.127: v2(288.35,28.89) 288.35,28.92 288.2,29.08 287.91,29.08 287.88,29.11 274.18,29.11 271.77,31.51 252,31.51 251.07,32.44 249.6,32.44 249.24,32.8 244.61,32.8 244.5,32.91 242.45,32.91 237.91,37.45 236.41,37.45 227.44,46.43 226.89,46.43 220.89,52.43 212.77,52.43 210.82,54.37 197.96,54.37 197.76,54.17 194.83,54.17 192.97,52.31 188.29,52.31 183.3,47.32 174.78,47.32 172.74,49.36 156.47,49.36 153.72,52.12 153.72,54 152.93,54.79 143.81,54.79 139.06,59.53 139.06,62.01 136.86,64.21 121.79,64.21 121.79,64.21 121.45,64.21 121.44,64.21 121.2,64.21 120.83,64.58 118.99,64.58 118.93,64.64 115.19,64.64 114.17,63.63 114.17,63.03 113.48,62.34 113.48,61.57 113.2,61.3 102.77,61.3 101.31,62.75 96.44,62.75 96.11,62.42 94.49,62.42 93.81,63.1 v2(93.81,63.32)
REM_DIODE2_N: length 595
  TOP w0.127: v2(322.3,45) 322.11,45 321.89,44.78 321.89,44.53 CE26.1 321.69,43.71 321.69,42.54 321.42,42.27 321.42,42.1 320.58,41.26 320.58,40.69 UE1.A10 ; v2(165.44,74.86) 166.34,73.96 166.34,67.59 167.17,66.77 167.17,54.08 167.88,53.37 167.88,44.72 169.62,42.98 169.62,39.62 170.34,38.9 175.36,38.9 182.27,31.99 182.27,31.38 181.96,31.08 181.96,28.86 180.86,27.76 180.86,24.72 182.62,22.96 182.62,21.12 185.61,18.13 185.61,16.5 186.61,15.5 186.61,15.37 v2(186.33,15.09)
  IN1 w0.127: v2(104.64,15.89) 104.77,15.76 104.77,15.29 107.74,12.32 109.31,12.32 110.28,11.35 130.88,11.35 132.14,10.1 141.39,10.1 141.65,10.36 146.76,10.36 147.77,11.38 157.02,11.38 157.65,12 170.47,12 171.1,12.63 176.32,12.63 178.07,14.38 179.71,14.38 181.12,15.79 186.33,15.79 186.52,15.6 186.52,15.28 v2(186.33,15.09) 186.56,14.86 186.56,14.16 187.13,13.59 188.49,13.59 191.22,10.86 191.22,9.74 194.67,6.29 209.57,6.29 210.27,5.58 211.32,5.58 213.26,3.65 215.51,3.65 216.99,2.17 255.91,2.17 256.55,2.8 258.27,2.8 258.89,2.18 265.63,2.18 269.69,6.25 275.89,6.25 278.13,4.02 278.13,2.62 278.67,2.07 290.87,2.07 291.71,2.91 295.81,2.91 296.48,2.23 315.21,2.23 316.43,3.45 316.43,4.77 v2(316.61,4.95) ; v2(322.2,19.96) 322.32,19.84 322.85,19.84 326.28,23.27 327.73,23.27 331.17,26.71 331.17,30.58 329.46,32.29 327.63,32.29 326.33,33.6 326.33,43.19 327.46,44.31 327.46,45.53 326.95,46.04 324.35,46.04 323.47,45.16 322.46,45.16 v2(322.3,45) ; v2(15.23,104.07) 15.23,104.07 15.49,104.32 15.8,104.32 17.58,106.1 18.89,106.1 21.53,103.47 22.59,103.47 23.99,104.86 23.99,105.24 25.57,106.83 25.57,108.74 24.99,109.32 24.99,112.43 25.49,112.93 26.34,112.93 27.42,114.01 29.85,114.01 30.34,113.52 30.34,111.57 32.53,109.37 39.19,109.37 39.45,109.11 57.75,109.11 58.06,109.42 65.88,109.42 67.48,111.03 71.21,111.03 75.58,115.39 77.03,115.39 77.49,115.85 99.64,115.85 103.02,119.23 111.69,119.23 117.01,113.9 121.38,113.9 123.68,116.2 135.22,116.2 139.67,111.76 139.67,103.81 141.7,101.78 141.7,97.71 164.36,75.05 165.25,75.05 v2(165.44,74.86)
  BOTTOM w0.127: QE7.1 78.96,11.48 QE7.2 81.24,11.48 CE46.2 81.75,10.97 83.05,10.97 83.83,11.76 85.08,11.76 85.62,12.3 97.41,12.3 98.91,13.8 103.38,13.8 104.87,15.29 104.87,15.65 104.81,15.72 104.81,15.73 v2(104.64,15.89) ; QE5.3 14.41,103.95 CE37.2 v2(15.23,104.07) ; v2(322.2,19.96) 322.68,19.48 322.68,18.18 322.34,17.85 322.34,14.26 317.92,9.83 317.92,7.12 316.43,5.64 316.43,5.13 v2(316.61,4.95)
REM_DIODE2_P: length 596.5
  TOP w0.127: UE1.A9 320.33,40.56 320.33,41.36 321.17,42.2 321.17,42.38 321.43,42.65 321.43,44.07 CE26.2 321.28,44.57 322.27,45.56 v2(322.27,45.58) ; v2(165.53,75.59) 166.59,74.52 166.59,67.7 167.42,66.87 167.42,54.18 168.13,53.47 168.13,44.82 169.87,43.08 169.87,39.73 170.44,39.15 175.47,39.15 182.52,32.1 182.52,31.28 182.22,30.97 182.22,28.76 181.11,27.65 181.11,24.83 182.88,23.07 182.88,21.22 185.86,18.24 185.86,16.61 186.86,15.6 186.86,15.37 v2(187.14,15.09)
  IN1 w0.127: v2(315.92,4.98) 316.18,4.72 316.18,3.56 315.1,2.49 296.59,2.49 295.91,3.16 291.6,3.16 290.76,2.32 278.78,2.32 278.38,2.72 278.38,4.12 276,6.5 269.58,6.5 265.52,2.44 259,2.44 258.38,3.06 256.44,3.06 255.81,2.42 217.1,2.42 215.62,3.9 213.37,3.9 211.43,5.84 210.38,5.84 209.67,6.54 194.78,6.54 191.47,9.85 191.47,10.96 188.59,13.84 187.24,13.84 186.81,14.26 186.81,14.77 187.13,15.09 v2(187.14,15.09) 186.78,15.46 186.78,15.7 186.44,16.04 181.01,16.04 179.6,14.63 177.96,14.63 176.22,12.89 171,12.89 170.37,12.25 157.54,12.25 156.92,11.63 147.66,11.63 146.65,10.62 141.55,10.62 141.28,10.35 132.25,10.35 130.99,11.61 110.38,11.61 109.42,12.57 107.84,12.57 105.03,15.39 105.03,15.69 v2(105.23,15.89) ; v2(322.27,45.58) 322.43,45.41 323.37,45.41 324.24,46.29 327.05,46.29 327.71,45.63 327.71,44.21 326.58,43.08 326.58,33.7 327.74,32.55 329.56,32.55 331.43,30.68 331.43,26.61 327.83,23.01 326.39,23.01 322.96,19.58 322.42,19.58 v2(322.14,19.31) ; v2(15.21,104.7) 15.23,104.7 15.36,104.57 15.7,104.57 17.48,106.36 19,106.36 21.64,103.72 22.48,103.72 23.73,104.97 23.73,105.35 25.32,106.94 25.32,108.63 24.74,109.22 24.74,112.53 25.38,113.18 26.23,113.18 27.31,114.26 29.96,114.26 30.59,113.63 30.59,111.67 32.64,109.63 39.29,109.63 39.56,109.36 57.64,109.36 57.96,109.68 65.77,109.68 67.37,111.28 71.11,111.28 75.47,115.65 76.93,115.65 77.39,116.1 77.6,116.1 77.6,116.1 99.53,116.1 102.91,119.48 111.79,119.48 117.11,114.16 121.27,114.16 123.57,116.46 135.33,116.46 139.93,111.86 139.93,111.65 139.92,111.65 139.92,103.91 141.95,101.88 141.95,97.82 164.47,75.31 165.24,75.31 v2(165.53,75.59)
  BOTTOM w0.127: QE7.3 81.09,10.18 CE46.1 81.63,10.72 83.15,10.72 83.94,11.51 85.19,11.51 85.73,12.05 97.51,12.05 99.01,13.54 103.48,13.54 105.12,15.19 105.12,15.79 v2(105.23,15.89) ; QE5.1 12.13,105.25 QE5.2 14.25,105.25 CE37.1 14.93,104.98 v2(15.21,104.7) ; v2(322.14,19.31) 322.23,19.31 322.42,19.11 322.42,18.29 322.09,17.95 322.09,14.36 317.66,9.93 317.66,7.23 316.18,5.74 316.18,5.23 v2(315.92,4.98)
REM_DIODE4_N: length 291.8
  TOP w0.127: v2(297.58,57.29) 297.85,57.29 298.27,57.71 298.78,57.71 301.09,60.02 310.53,60.02 311.43,59.12 318.47,59.12 321.47,56.12 321.47,48.17 323.18,46.47 323.18,42.96 CE27.1 322.86,42.5 322.86,41.96 322.17,41.27 321.96,41.27 321.72,41.03 UE1.A11
  IN1 w0.127: v2(119.39,116.79) 119.22,116.62 119.22,116.43 119.35,116.31 120.34,116.31 122.53,118.49 136.89,118.49 137.21,118.49 145.61,110.09 145.61,106.58 172.91,79.29 173.49,79.29 176.83,75.95 183.8,75.95 186.16,73.58 194.26,73.58 204,63.84 212.42,63.84 218.27,57.99 223.76,57.99 233.62,48.12 242.46,42.33 254.85,38.74 261.14,38.76 272.19,41.48 282.58,47.56 282.77,47.74 282.79,47.85 289.2,54.25 294.67,54.25 297.58,57.17 v2(297.58,57.29)
  BOTTOM w0.127: v2(119.39,116.79) 119.22,116.62 119.22,116.28 118.87,115.92 115.95,115.92 111.76,111.73 101.65,111.73 100.91,111 100.91,106.73 100.58,106.4 100.58,105.63 CE39.1 100.71,105.4 100.12,104.81 100.12,104.53 100.38,104.26 QE6.3
REM_DIODE4_P: length 295.5
  TOP w0.127: v2(297.99,56.88) 297.99,57.07 298.37,57.45 298.88,57.45 301.19,59.77 310.43,59.77 311.33,58.87 318.37,58.87 321.22,56.02 321.22,48.07 322.92,46.36 322.92,43.48 CE27.2 322.6,42.62 322.6,42.06 322.07,41.53 321.86,41.53 321.34,41.01 321.34,39.97 UE1.B10
  IN1 w0.127: v2(297.99,56.88) 297.65,56.88 294.77,54 289.31,54 283.05,47.74 283.05,47.67 282.74,47.35 272.28,41.24 261.17,38.51 254.82,38.48 242.35,42.1 233.46,47.92 223.65,57.73 218.17,57.73 212.31,63.59 203.89,63.59 194.15,73.33 186.05,73.33 183.69,75.69 176.73,75.69 173.39,79.03 172.8,79.03 145.36,106.47 145.36,109.98 137.11,118.24 137,118.24 122.63,118.24 120.45,116.05 119.25,116.05 118.97,116.33 118.97,116.62 v2(118.8,116.79)
  BOTTOM w0.127: QE6.1 99.73,102.36 99.34,102.75 99.25,102.75 99.11,102.9 99.11,102.94 99.08,102.97 QE6.2 99.56,104.18 99.83,104.45 99.83,105.33 CE39.2 100.3,105.8 100.3,106.48 100.66,106.84 100.66,111.1 101.54,111.99 111.65,111.99 115.84,116.18 118.76,116.18 118.97,116.38 118.97,116.62 v2(118.8,116.79)
RES_BIAS: length 3.5
  TOP w0.102: UL1.12 324.74,88.5 325.15,88.91 325.15,89.84 v1(325.51,90.2) 325.57,90.26 RL13.1
RESET_IN#: length 6.8
  TOP w0.102: UE1.C1 312.97,39.5 312.97,39.52 ; 311.26,41.58 311.01,41.83 310.8,41.83 v1(310.54,42.1) 309.81,42.82 RE362.1
  TOP w0.104: 312.97,39.52 312.62,39.86 312.62,40.22 311.26,41.58 311.26,41.58
RESET_OUT: length 8.5
  TOP w0.104: UE1.G4 v2(315.72,35.95)
  BOTTOM w0.102: RE548.2 311.26,40.8 v1(312.23,39.82) 313.31,39.82 314.3,38.84 314.3,37.76 314.5,37.55 314.5,37.31 314.68,37.13 315.16,37.13 315.31,36.98 315.31,36.36 v2(315.72,35.95)
RING2:
  vias: v1(346.21,36.64) v2(347.59,36.39) v2(348.19,36.37)
RING2_R: length 13.4
  TOP w1.27: JHP1.3 365.04,37.11 357.93,37.11 355.36,34.54
  vias: v1(353.73,34.16) v2(352.54,34.72) v2(353.14,34.99)
RJ45_MDIN0: length 9.3
  BOTTOM w0.305: TL1.14 326.08,119.62 325.51,120.19 325.51,121.65 327.09,123.23 327.09,124.28 326.51,124.86 326.51,125.25 326.92,125.65 327.18,125.65 JLOM1.2
RJ45_MDIN1: length 10.1
  IN1 w0.279: v2(332.06,120.74) 331.87,120.93 331.87,121.79 330.91,122.75 330.25,122.75 329.6,123.4 329.6,124.22 329.84,124.46 330.93,124.46 331.53,125.06 JLOM1.6
  BOTTOM w0.305: v2(332.06,120.74) 331.8,120.48 331.8,119.94 332.08,119.66 TL1.20
RJ45_MDIN2: length 8.8
  BOTTOM w0.305: TL1.17 329.08,122.48 330.6,124 330.6,125.3 330.6,125.3 330.6,126.39 JLOM1.5
RJ45_MDIN3: length 8.6
  BOTTOM w0.305: TL1.23 335.08,119.68 334.51,120.25 334.51,120.82 334.72,121.03 334.72,121.7 334.51,121.91 334.51,122.58 332.92,124.18 332.92,125.15 333.15,125.38 JLOM1.8
RJ45_MDIP0: length 9.2
  BOTTOM w0.305: TL1.13 325.08,121.83 326.66,123.41 326.66,124.1 326.03,124.73 326.03,126.08 JLOM1.1
RJ45_MDIP1: length 10.1
  IN1 w0.279: JLOM1.3 328.47,125.04 329.15,124.36 329.15,123.21 330.07,122.3 330.73,122.3 331.43,121.6 331.43,121 v2(331.17,120.74)
  BOTTOM w0.305: TL1.19 331.08,119.63 331.36,119.91 331.36,120.55 v2(331.17,120.74)
RJ45_MDIP2: length 8.7
  BOTTOM w0.305: JLOM1.4 329.91,125.38 330.17,125.12 330.17,124.18 328.65,122.66 328.65,121.89 328.38,121.63 328.38,121.18 328.64,120.92 328.64,120.64 328.65,120.64 328.65,120.27 328.08,119.7 TL1.16
RJ45_MDIP3: length 8.8
  BOTTOM w0.305: TL1.22 334.08,122.4 332.48,124 332.48,126.41 JLOM1.7
RTCRST_ON: length 24.7
  TOP w0.102: RE565.2 318.71,53.82 318.71,51.8 317.87,50.96 317.53,50.96 317.2,50.63 317.2,49.45 318.19,48.47 QE12.2 318.19,47.4 RE93.1 318.87,46.39 318.46,45.99 v1(317.89,45.99) v2(317.3,45.99) ; UE1.F11 v2(321.32,35.95)
  BOTTOM w0.102: v2(321.32,35.95) 321.21,35.95 320.72,35.46 319.58,35.46 319.32,35.71 319.32,36.64 318.92,37.05 318.92,38.79 318.58,39.13 318.58,40.28 318.28,40.59 318.28,43.82 317.97,44.13 317.97,45.33 v2(317.3,45.99)
RTCRST_ON_R: length 0.7
  TOP w0.102: v1(318.38,52.83) 318.01,53.2 317.84,53.2
RTCRST_ON_R1: length 8.9
  TOP w0.102: QE15.2 312.79,55.95 CE64.1 313.36,55.38 RE541.2 314.31,55.89 314.68,56.26 DE2.1 317.31,56.26 v1(317.81,55.76) 317.85,55.72 RE543.2 RE565.1
RTD3_CIO_PWR_EN: length 1.2
  TOP w0.089: v2(209.64,34.29) 209.16,34.29 T259.1
  BOTTOM w0.089: UH1.AP21 209.63,34.29 v2(209.64,34.29)
RTD3_SELECT_EC: length 2.8
  TOP w0.102: T264.1 325.22,37.88 323.69,36.35 UE1.F13
RUN_ON: length 433
  TOP w0.102: v2(182.13,73.97) 181.53,74.57 181.53,79.97 178.74,82.77 178.74,86.77 174.53,90.97 174.53,100.12 171.3,103.36 171.3,115.67 161.34,125.63 PR2010.1 ; RE292.1 338.24,48.07 v2(337.81,48.49) 337.81,48.53 338.23,48.96 UE5.4 339.23,48.96 339.78,48.4 RE280.2 ; RZ345.1 329.52,51.75 329.71,51.94 330.12,51.94 v2(330.15,51.97) ; v2(154.99,54.51) 154.75,54.74 PR402.1 ; UZ4.3 286.33,4.98 286.18,4.83 286.18,4.47 285.78,4.07 282.83,4.07 282.62,4.28 282.62,5.76 283.2,6.34 284.14,6.34 284.5,6.7 v2(284.5,6.86) ; v2(282.33,11.05) 282.24,11.14 282.24,11.64 289.55,18.95 289.55,21.75 292.8,25.01 292.8,25.98 294.05,27.23 294.05,33.28 297.3,36.53 297.3,37.49 298.91,39.09 298.91,39.94 v1(301.72,42.74) 303.83,44.85 QE2.2 303.83,45.49 303.96,45.62 304.57,45.62 304.91,45.96 304.91,47.33 304.82,47.42 304.82,48.77 304.85,48.79 v2(304.85,49.43) ; v2(195.8,3.03) 195.8,3.15 195.43,3.52 UZ3.5
  IN2 w0.102: v2(337.81,48.49) 337.72,48.4 336.43,48.4 332.71,52.12 330.3,52.12 v2(330.15,51.97) 330.12,51.94 330.12,51.72 326.69,48.28 319.66,48.28 318.64,49.3 309.72,49.3 309.42,49 308.73,49 308.3,49.43 v2(304.85,49.43) ; v2(154.99,54.51) 157.35,54.51 161.41,50.45 161.42,50.45 169.59,42.27 169.59,36.54 179.36,26.77 v2(181.82,26.77) ; v2(284.5,6.86) 284,6.36 276.75,6.36 275.36,7.76 268.94,7.76 266.72,5.54 261.18,5.54 260.53,4.89 260.53,2.42 259.37,1.26 204.52,1.26 203.88,1.89 v2(203.88,2.75)
  IN3 w0.102: v2(195.8,3.03) 195.8,3.29 193.83,5.26 192.82,5.26 192.32,5.75 192.32,8.76 v2(192.83,9.27)
  BOTTOM w0.102: 143.3,72.29 143.56,72.03 149.34,72.03 154.03,76.73 168.51,76.73 174.35,70.89 181.72,70.89 182.13,71.3 v2(182.13,73.97) ; 143.3,72.29 139.32,68.3 139.32,61.01 140.66,59.66 140.66,58.03 143.55,55.14 154.35,55.14 v2(154.99,54.51) ; 143.3,72.29 143.3,75.84 144.95,77.49 144.95,81.27 RZ320.1 145.63,81.94 UZ35.2 ; v2(192.83,9.27) 192.83,10.67 182.43,21.07 182.43,26.16 v2(181.82,26.77) ; v2(203.88,2.75) 202.61,2.75 202.28,2.43 196.44,2.43 195.84,3.03 v2(195.8,3.03) ; v2(284.5,6.86) 283.89,7.48 283.89,8.55 282.9,9.54 282.9,10.48 v2(282.33,11.05)
RUN_ON#: length 7.7
  TOP w0.102: QE2.6 RE68.1 ; RE68.1 303.83,47.57 QE2.5 ; RE68.1 302.5,47.55 301.06,47.55 300.64,47.13 QZ4.2 v1(300.64,45.22)
RUN_ON_1.8V: length 3.7
  TOP w0.102: CZ197.1 v1(331.53,50.26)
  TOP w0.104: UZ8.3 330.75,49.43 330.41,49.78 CZ197.1 RZ345.2
RUN_ON_EC: length 38.6
  TOP w0.102: RPE10.2 v1(324.66,47.16) 323.47,47.16 v2(321.89,48.74) ; RE292.2 337.32,47.85 337.32,47.86 337.32,49.37 337.08,49.61 UE5.2 336.19,49.61 335.75,50.05 v2(335.75,50.37)
  TOP w0.104: UE1.E8 v2(319.72,37.55)
  IN2 w0.102: v2(335.75,50.37) 335.75,50.42 335.65,50.52 334.84,50.52 332.76,52.6 329.95,52.6 328.72,51.37 328.72,50.79 326.63,48.69 321.94,48.69 v2(321.89,48.74)
  BOTTOM w0.102: v2(319.72,37.55) 320.14,37.97 320.14,40.34 320.32,40.51 320.32,44.12 320.47,44.27 320.47,47.32 v2(321.89,48.74)
RUNPWROK: length 22.5
  TOP w0.102: v1(303.22,43.74) 303.39,43.91 RE67.1 304.45,45.02 QE2.3 304.66,45.05 305.32,45.71 v2(305.32,47.01)
  TOP w0.104: UE1.G3 v2(314.92,35.95)
  BOTTOM w0.102: 310.76,40.73 311.41,40.08 312.62,38.87 312.62,36.89 312.78,36.73 313.86,36.73 314.64,35.95 v2(314.92,35.95)
  BOTTOM w0.104: 310.76,40.73 310.76,43.69 308.69,45.77 306.57,45.77 v2(305.32,47.01)
SA_SW: length 1.5
  BOTTOM w0.102: PC2019.1 v1(118.41,94.31)
SATA_PRX_C_DTX_N2: length 4
  BOTTOM w0.094: 258.2,15.25 258.11,15.16 257.69,15.16 257.51,14.98 257.51,14.4 257.35,14.24 ; CN6.1 257.82,16.23 257.82,16.12 258.03,15.92 258.11,15.92 258.2,15.82
  BOTTOM w0.097: JSATA1.5 257.35,14.24 ; 258.2,15.25 v4(258.2,15.56) 258.2,15.82
SATA_PRX_C_DTX_P2: length 4
  BOTTOM w0.094: 258.19,16.1 258.1,16.1 258.01,16.2 258.01,16.26 CN7.1
  BOTTOM w0.097: 258.19,16.1 258.43,15.86 258.43,15.21 258.19,14.97 257.79,14.97 257.73,14.91 257.73,14.5 257.85,14.38 JSATA1.6
SATA_PRX_C_RD_DTX_N2: length 2.6
  BOTTOM w0.097: UN7.4 246,17.34 245.84,17.5 245.59,17.5 245.39,17.7 244.74,17.7 CN14.2
SATA_PRX_C_RD_DTX_P2: length 2.6
  BOTTOM w0.097: CN15.2 244.77,17.89 245.46,17.89 245.67,17.68 245.84,17.68 246,17.84 UN7.5
SATA_PRX_DTX_N2: length 54.4
  IN1 w0.099: v2(239.98,15.47) 239.8,15.65 239.8,15.94 239.61,16.12 237.58,16.12 236.66,17.04 235.49,17.04 235.28,16.83 230.16,16.83 229.45,17.54 222.49,17.54 222.28,17.75 214.82,17.75 214.7,17.63 212.46,17.63 211.74,18.35 208,18.35 207.74,18.1 206.35,18.1 204.94,19.51 203.38,19.51 201.73,21.16 196.01,21.16 194.93,22.24 194.86,22.32 v2(194.9,22.7)
  BOTTOM w0.089: UH1.F44 194.91,22.7 v2(194.9,22.7)
  BOTTOM w0.097: CN14.1 243.14,17.71 242.71,17.71 240.85,15.85 239.95,15.85 239.84,15.74 239.84,15.61 v2(239.98,15.47)
SATA_PRX_DTX_P2: length 54.7
  IN1 w0.099: v2(239.4,15.47) 239.59,15.65 239.59,15.85 239.52,15.91 237.49,15.91 236.57,16.83 235.57,16.83 235.37,16.62 230.07,16.62 229.36,17.33 222.4,17.33 222.19,17.54 214.9,17.54 214.79,17.42 212.38,17.42 211.65,18.14 208.09,18.14 207.83,17.89 206.27,17.89 204.85,19.3 203.29,19.3 201.65,20.95 195.93,20.95 194.78,22.1 194.68,22.21 v2(194.34,22.25)
  BOTTOM w0.089: v2(194.34,22.25) 194.59,22.25 194.68,22.15 UH1.E45
  BOTTOM w0.097: v2(239.4,15.47) 239.42,15.47 239.66,15.71 239.66,15.82 239.87,16.03 240.77,16.03 242.63,17.89 243.13,17.89 CN15.1
SATA_PRX_RD_DTX_N2: length 10.3
  BOTTOM w0.097: UN7.12 251.28,17.34 251.44,17.5 251.61,17.5 251.82,17.7 251.82,18.25 252.08,18.51 252.14,18.51 252.55,18.92 252.55,18.98 253,19.42 v4(256.51,19.42) 257.05,19.42 258.16,18.31 258.16,18.17 257.5,17.52 CN6.2
SATA_PRX_RD_DTX_P2: length 10.3
  BOTTOM w0.097: CN7.2 258.35,17.52 258.35,18.39 257.13,19.61 256.84,19.61 256.8,19.65 256.22,19.65 256.18,19.61 252.92,19.61 v4(252.19,18.88) 251.63,18.32 251.63,17.78 251.53,17.68 251.44,17.68 251.28,17.84 UN7.11
SATA_PTX_C_DRX_N2: length 4.1
  BOTTOM w0.094: 256.21,16.16 256.21,16.25 CN5.1
  BOTTOM w0.097: JSATA1.3 256.35,14.22 255.83,14.74 255.83,14.94 255.93,15.04 256.34,15.04 256.54,15.24 256.54,15.24 256.57,15.27 v4(256.57,15.52) 256.57,15.8 256.21,16.16
SATA_PTX_C_DRX_P2: length 4.1
  BOTTOM w0.094: 256.03,16.08 256.03,16.25 CN4.1
  BOTTOM w0.097: JSATA1.2 255.85,14.2 255.92,14.27 255.92,14.39 255.65,14.66 255.65,15.08 255.79,15.22 256.26,15.22 256.35,15.32 256.35,15.76 256.03,16.08
SATA_PTX_C_RD_DRX_N2: length 2.5
  BOTTOM w0.097: UN7.2 246,16.34 245.84,16.18 245.31,16.18 245.22,16.09 244.79,16.09 CN13.2
SATA_PTX_C_RD_DRX_P2: length 2.5
  BOTTOM w0.097: CN12.2 244.72,15.9 245.29,15.9 245.39,16 245.84,16 246,15.84 UN7.1
SATA_PTX_DRX_N2: length 60
  IN1 w0.099: v2(241.29,15.45) 241.67,15.07 241.67,14.93 241.57,14.83 237.18,14.83 236.15,15.86 232.52,15.86 232.12,15.46 230.65,15.46 229.19,16.92 222.23,16.92 222.02,17.13 215.07,17.13 214.96,17.02 211.96,17.02 211.24,17.74 208.43,17.74 208.18,17.48 206.1,17.48 205.16,18.42 202.3,18.42 201.78,18.95 201.78,19.92 201.24,20.47 195.06,20.47 193.89,21.64 193.89,24.46 193.66,24.68 193.31,24.68 193.21,24.78 193.21,24.94 193.33,25.06 v2(193.33,25.06)
  BOTTOM w0.089: UH1.B40 193.24,24.66 193.12,24.79 193.12,24.85 v2(193.33,25.06)
  BOTTOM w0.097: CN13.1 243.3,16.28 242.77,16.28 242.54,16.05 241.73,16.05 241.52,15.84 241.52,15.68 v2(241.29,15.45)
SATA_PTX_DRX_P2: length 60.2
  IN1 w0.099: v2(193.1,24.33) 193.24,24.47 193.58,24.47 193.68,24.37 193.68,21.55 194.97,20.26 201.15,20.26 201.57,19.84 201.57,18.86 202.22,18.21 205.07,18.21 206.01,17.27 208.26,17.27 208.52,17.53 211.15,17.53 211.87,16.81 215.04,16.81 215.16,16.92 221.94,16.92 222.14,16.71 229.1,16.71 230.56,15.25 232.21,15.25 232.61,15.65 236.06,15.65 237.09,14.62 241.66,14.62 241.88,14.84 241.88,15.35 v2(241.97,15.45)
  BOTTOM w0.089: UH1.C40 193.69,24.5 193.6,24.41 193.18,24.41 v2(193.1,24.33)
  BOTTOM w0.097: v2(241.97,15.45) 241.78,15.45 241.7,15.52 241.7,15.77 241.8,15.87 242.62,15.87 242.85,16.1 243.04,16.1 243.49,15.65 CN12.1
SATA_PTX_RD_DRX_N2: length 8.6
  BOTTOM w0.097: UN7.14 251.93,16.34 252.31,15.96 253.07,15.96 253.11,16 253.69,16 253.73,15.96 254.11,15.96 254.66,16.51 v4(254.66,17.23) 254.66,18.09 254.92,18.35 256.07,18.35 256.27,18.15 256.27,17.81 CN5.2
