# Allegro board LA-F711P R05-0112.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N18292433: length 1.4
  TOP w0.381: T219.1 RT84.2
N18292435: length 1.1
  TOP w0.102: RT85.2 29.52,88.93 T220.1
N18292515: length 2.5
  TOP w0.102: v2(33.72,89.7) 33.45,89.98 CT87.1 v1(34.44,90.45)
  BOTTOM w0.076: UT5.H7 33.38,89.37 v2(33.72,89.7)
N18292570: length 3.3
  TOP w0.102: v1(33.21,88.11) 33.21,87.54 32.48,86.81 v2(32.48,86.72) ; 32.16,86.4 31.92,86.16 RT101.1
  TOP w0.104: v2(32.48,86.72) 32.16,86.4
  BOTTOM w0.076: v2(32.48,86.72) 32.88,87.12 UT5.D6
N18394104: length 2.6
  TOP w0.102: QV4.2 v1(96,124.1)
  TOP w0.508: QV4.2 95.11,122.85 RV18.2
N18394878: length 8.7
  TOP w0.102: RE57.1 RE58.1
  TOP w0.104: UE1.B1 313.6,39.67 313.6,39.72 313.04,40.28 313.04,40.5 311.1,42.44 311.1,43.12 v1(310.43,43.79) 310.04,44.17 309.27,44.17 RE58.1
N18394936: length 3.6
  TOP w0.104: UE1.G2 314.19,35.22 312.89,35.22 311.92,36.22 RE318.1
N18398370: length 3.8
  TOP w0.102: v1(320.09,18.26) 320.09,18.19 320.66,17.61 320.73,17.61 RE90.2 321.09,17.21 RE70.1 322.38,16.35 QE11.3
N18398380: length 2.3
  TOP w0.102: RE70.2 v1(320.17,15.39) 320.17,15.19 320.4,14.96 QE4.2
N18601091: length 5.4
  BOTTOM w0.076: UT5.F1 29.11,88.19 29.05,88.13
  BOTTOM w0.104: 29.05,88.13 28.65,87.72 26.42,87.72 26.11,88.04 25.65,88.04 RT63.1
N18676202: length 3
  TOP w0.102: v1(324.34,67.05) RV124.2 325.93,67.57 UV6.9
N18676204: length 4.2
  TOP w0.102: v1(326.35,65.01) 326.35,65.33 325.88,65.8 325.88,66.5 326.42,67.04 RV123.2 326.33,67.14 UV6.10
N18739564: length 2.6
  TOP w0.102: RA17.2 341.32,29.28 CA33.1 342.29,29.06 v1(342.53,28.82)
N18739670: length 1.8
  TOP w0.102: UZ5.10 333.61,22.14 CZ127.1
N18739690: length 1.8
  TOP w0.102: CZ126.1 332.74,22.16 332.74,21.39 332.81,21.32 332.81,20.76 UZ5.12
N18739867: length 6
  TOP w0.203: UA1.27 342.72,41.74 343.32,42.33 v2(343.32,42.52)
  BOTTOM w0.102: CA51.1 v1(345.35,43.42)
  BOTTOM w0.254: CA51.1 343.66,43.69 343.61,43.69 343.57,43.73 RA44.1 342.85,43.73 342.85,42.99 v2(343.32,42.52)
N18739871: length 4.5
  TOP w0.203: UA1.7 341.52,33.57 341.6,33.5 v2(341.6,32.5)
  BOTTOM w0.203: v2(341.6,32.5) v1(341.6,33.25) 341.6,33.5 341.51,33.58 CA53.1
N18739873: length 2.8
  TOP w0.203: UA1.39 v1(337.14,39.17) 336.78,39.53 336.78,40.61 CA52.1
N18739919: length 7.2
  TOP w0.203: UA1.20 345.61,38.37 346.25,39.01
  TOP w0.381: RA53.1 350.06,39.78 RA54.1 v1(348.67,39.78) 348.03,39.78 347.48,39.23 346.47,39.23 346.25,39.01
N18739929: length 3.6
  TOP w0.203: UA1.35 339.52,41.67 v2(339.67,41.82)
  BOTTOM w0.102: CA29.1 339.71,39.94 v1(340.13,39.52)
  BOTTOM w0.254: v2(339.67,41.82) 339.67,41.79 339.71,41.75 CA29.1
N18739934: length 3.1
  TOP w0.203: UA1.37 337.89,39.97 337.74,40.12 337.74,41.02 338.31,41.6 v2(338.31,41.62)
  BOTTOM w0.254: v2(338.31,41.62) CA29.2
N18739944: length 3.9
  TOP w0.203: CA35.1 343.45,43.26 343.1,43.26 v1(342.6,42.76) 342.6,42.23 342.32,41.95 UA1.28
N18739946: length 4.1
  TOP w0.102: v1(339.9,44.22) 339.42,43.74 CA49.1
  TOP w0.203: UA1.34 339.92,41.35 340.1,41.53 340.1,42.1 339.61,42.6 CA49.1
N18739956:
  vias: v1(345.58,37.96)
N18877135: length 5.7
  BOTTOM w0.102: RE375.1 268.48,20.81 268.07,21.22 v1(266.35,21.22) ; RE375.1 RE560.1 ; RE375.1 268.78,21.27 268.78,21.27 268.78,22.28 268.58,22.48 JESPI.8
N18964580: length 1.8
  TOP w0.102: CZ109.1 311.77,70.19 311.93,70.03 312.5,70.03 312.57,70.11 UZ2.12
N18964619: length 1.8
  TOP w0.102: CZ113.1 194.43,7.42 194.43,6.86 194.63,6.66 UZ3.12
N18964663: length 3.6
  TOP w0.102: UZ3.3 194.63,3.16 v2(194.54,3.07)
  BOTTOM w0.102: RZ64.2 194.24,3.38 v2(194.54,3.07) 194.79,2.83 RZ65.2 v1(193.72,2.31)
N18964738: length 1.5
  TOP w0.254: CZ121.1 330.75,45.18 UZ8.6
N18965068: length 1.8
  TOP w0.102: UZ2.10 312.45,70.91 312.39,70.96 311.56,70.96 CZ110.1
N18965149: length 2.2
  TOP w0.102: CZ117.1 286.67,9.03 v1(286.26,8.62) 286.26,8.21 286.33,8.15 UZ4.12
N18965206: length 1.7
  TOP w0.102: UZ3.10 195.43,5.9 195.43,6.47 195.5,6.55 195.5,7.57 CZ114.1
N18965394: length 2.2
  TOP w0.102: UZ4.10 287.13,8.17 v1(287.56,8.61) CZ118.1
N19191267: length 2.1
  TOP w0.102: v2(70.31,12.77) 70.35,12.72 T50.1
  BOTTOM w0.102: JDIMM1.162 70.47,13.26 70.26,13.05
  BOTTOM w0.104: v2(70.31,12.77) 70.26,12.82 70.26,13.05
N19196687: length 2.2
  TOP w0.102: T52.1 151.23,16.14 v2(151.23,15.29)
  BOTTOM w0.102: 151.47,15.05 v2(151.23,15.29)
  BOTTOM w0.104: JDIMM2.162 151.47,15.05
N19209026: length 2.6
  BOTTOM w0.508: TL1.10 v2(327.08,108.23) CL21.1
N19209032: length 2.6
  BOTTOM w0.508: CL17.1 333.08,108.27 333.08,108.27 v2(333.08,108.32) TL1.4
N19209034: length 2.6
  BOTTOM w0.508: TL1.7 v2(330.08,108.31) 330.08,108.3 330.08,107.84 CL20.1
N19209038: length 2.6
  BOTTOM w0.508: TL1.1 336.08,108.38 336.08,108.38 v2(336.08,108.37) CL16.1
N19529559: length 8.2
  BOTTOM w0.076: UT5.D1 29.57,87.19 29.07,86.69
  BOTTOM w0.102: v1(23.44,85.27) 23.88,85.71 24.98,85.71 25.4,85.29 RT378.1 25.88,85.24 26.84,86.21 28.59,86.21 29.07,86.69
N19529561: length 6.8
  BOTTOM w0.076: UT5.D2 30.88,87.19 30.64,86.95 29.82,86.95 29.59,86.72 29.42,86.72 29.07,86.36
  BOTTOM w0.102: RT379.1 25.9,84.73 26.01,84.73 v1(26.35,85.07) 26.64,85.36 26.64,85.55 27.07,85.98 28.69,85.98 29.07,86.36
N20151644: length 2.4
  TOP w0.254: PR909.1 11.58,53.92 11.86,54.2 11.86,55.31 11.63,55.54 PR901.2
N20163924: length 3.8
  BOTTOM w0.102: QZ3.1 302.18,58.57 RZ25.1 v1(300.68,58.95)
N20816752: length 1.7
  BOTTOM w0.102: v1(41.35,67.69) 42.27,66.76 PC2007.2
N20816771: length 1.4
  BOTTOM w0.102: PC2007.1 39.88,66.38 v1(39.58,66.67)
N20816775: length 4.7
  BOTTOM w0.254: PC2000.2 41.86,62.77 42.79,63.7 PU2000.3
  BOTTOM w0.381: PC2000.2 v1(41.86,61.52) 41.86,60.9 PR2000.2
N20816793: length 6.3
  BOTTOM w0.102: PR2002.1 55.11,68.83 v1(55.66,69.38)
  BOTTOM w0.203: PL2000.3 55.66,64.14 55.11,64.7 PR2002.1
N20816800: length 1.5
  BOTTOM w0.102: PR2003.1 v1(51.56,59.01)
N20816832: length 1.7
  BOTTOM w0.102: PR2004.2 104.8,87.78 v1(105.6,87.78)
N20816888: length 1.7
  BOTTOM w0.102: PR2006.1 v1(115.61,98.3)
N20820556: length 2.8
  TOP w0.102: PR1802.1 v1(76.88,88.02)
  TOP w0.254: v2(76.06,88.77) 76.36,89.08 PR1802.1
  BOTTOM w0.254: PL1802.3 76,88.71 v2(76.06,88.77)
N20820665: length 9.4
  TOP w0.102: v1(88.44,93.27) 88.16,92.99 PR1806.1
  TOP w0.254: PR1806.1 87.25,92.48 87.73,92 v2(87.8,92)
  BOTTOM w0.254: v2(87.8,92) 86.61,90.81 84.86,90.81 83.52,89.46 PL1803.3
N20820729: length 2.7
  TOP w0.102: PR1902.1 v1(91.91,88.07)
  TOP w0.254: PR1902.1 91.07,89.05 v2(91.05,89.03)
  BOTTOM w0.254: PL1900.3 91.05,88.17 v2(91.05,89.03)
N20820776: length 2.5
  TOP w0.102: PR1906.1 v1(97.72,88.08)
  TOP w0.254: PR1906.1 v2(98.37,89.07)
  BOTTOM w0.254: PL1901.3 98.57,88.7 98.37,88.9 v2(98.37,89.07)
N20872874: length 2.1
  TOP w0.102: v1(242.4,24.71) CZ56.1 RZ63.1
N20873025: length 2.3
  TOP w0.102: UZ12.27 250.35,29.5 250.68,29.17 v1(250.88,29.17) 251.49,29.17 RZ62.1
N20875020: length 3.2
  TOP w0.102: RZ132.2 338.38,58.87 v2(338.25,59) v1(338.25,59.56)
  BOTTOM w0.102: v2(338.25,59) 338.9,59.66 JNGFF2.58
N21350915: length 4.1
  TOP w0.102: v1(63.74,105.04) 64.39,105.04 64.74,104.69 PR1225.1
  TOP w0.254: PQ1205.2 65.61,106.36 64.91,105.66 PR1225.1
N21350917: length 7.6
  TOP w0.254: PQ1205.1 64.42,106.91 PR1226.2 v1(62.04,106.91) 61.41,106.91 60.61,106.1 60.61,102.97 PR1215.1
N21350923: length 5.3
  TOP w0.102: v1(69.83,108.98) 69.83,108.24 PR1224.1
  TOP w0.254: PQ1205.3 66.67,107.42 67.23,107.42 PR1221.2 67.79,108.28 68.12,108.61 69.01,108.61 69.31,108.31 69.31,108.23 PR1224.1
N21351080: length 2.2
  TOP w0.102: PU1200.4 55.56,102.74 v1(55.53,102.77)
  TOP w0.254: PU1200.4 56.67,103.11 56.38,103.39 PR1216.2
N21351086: length 2.3
  TOP w0.102: v1(58.57,100.35) PU1200.1
  TOP w0.254: PU1200.1 59.23,101.44 PR1211.2
N21351092: length 2.6
  TOP w0.102: v1(60.2,103.87) 60.2,103.61 59.58,103 PR1215.2
  TOP w0.254: PR1215.2 59.58,102.83 59.15,102.4 59.1,102.4 58.8,102.09 PU1200.2
N21351261: length 3.3
  TOP w0.102: PR1262.1 58.14,103.78 v1(59.13,104.77)
  TOP w0.254: PQ1201.2 57.3,104.63 PR1216.1 PR1262.1
N21352487: length 4.6
  TOP w0.254: PR1251.2 PR1252.1 40.94,107.01 v1(41.37,106.58) 41.81,106.58 42.5,107.27 PQ1215.2
N21352493: length 31
  TOP w0.254: v2(40.99,109.8) 40.43,109.24 PR1252.2 ; PQ1214.6 62.42,100.62 62.78,100.99 62.78,101.88 63.17,102.26 63.17,102.41 v1(62.33,103.24) 61.83,103.75 v2(61.83,104.44)
  BOTTOM w0.254: v2(40.99,109.8) 41.3,109.5 45.94,109.5 48.33,107.11 53.84,107.11 54.07,107.34 54.58,107.34 54.94,106.98 54.94,106.55 55.51,105.98 60.47,105.98 61.83,104.62 v2(61.83,104.44)
N22120291: length 6
  TOP w0.203: PU901.27 7.23,34.41 6.57,35.08 6.46,35.08 5.86,35.68 5.86,35.97 5.4,36.42 5.4,36.78 5.19,36.99 v1(5.19,37.5) 5.19,37.62 4.36,38.44 PR932.1
N22878895: length 49.8
  TOP w0.102: v2(25.73,4.01) 25.73,3.34 v1(26.23,2.83)
  TOP w0.254: PR917.3 24.8,4.41 25.33,4.41 v2(25.73,4.01)
  IN3 w0.152: v2(25.73,4.01) 25.68,4.01 25.14,4.55 25.14,5.9 25.54,6.3 25.54,8 23.6,9.94 21,9.94 19.99,10.95 7.25,10.95 1.68,16.52 1.68,20.69 3.3,22.31 3.3,25.58 3.1,25.79 v2(2.79,25.79)
  BOTTOM w0.203: v2(2.79,25.79) 3.43,25.79 3.92,26.28 6.59,26.28 6.97,26.65 6.97,26.94 PR938.2
N23124850: length 2.1
  BOTTOM w0.102: v1(316.94,36.28) 316.94,35.65 317.34,35.24 RE350.2 CE57.1
N23239263: length 2.3
  TOP w0.102: v1(362.97,51.38) RZ360.1 361.98,51.37 UZ29.2
N23456819: length 4.6
  TOP w0.102: UV6.11 326.73,67.66 327.01,67.38 327.01,66.93 327.56,66.38 327.56,66.21 328.03,65.74 RV620.2 v1(328.03,64.69)
N23602829: length 3.2
  TOP w0.102: RE94.1 319.68,50.8 318.84,49.96 QE12.1 318.32,49.55 317.66,50.22 v1(317.66,50.38)
N23766683: length 4.4
  BOTTOM w0.102: UC1.A33 121.09,76.94 121.89,76.94 122.12,77.16 123.39,77.16 124.38,76.17 T194.1
N23770309: length 6.1
  BOTTOM w0.102: T199.1 76.86,60.98 77.77,60.98 78.48,61.69 79.29,61.69 79.37,61.62 81.24,61.62 UC1.BP13
N23792182: length 7.7
  BOTTOM w0.254: RC114.1 75.61,66.7 76.25,67.33 76.25,68.1 v1(77.01,68.86) 77.01,69.24 78.42,70.65 UC1.BT25
N23795295: length 1.2
  TOP w0.102: v2(117.43,61.06) 117.24,60.87 T42.1
  BOTTOM w0.102: UC1.G13 117.08,61.41 v2(117.43,61.06)
N23795364: length 3.8
  BOTTOM w0.076: 123.47,74.68 123.45,74.68 123.44,74.67 121.37,74.67 121.31,74.72 120.43,74.72 UC1.B30
  BOTTOM w0.102: 123.47,74.68 123.65,74.68 T18.1
N23795366: length 8.8
  TOP w0.102: T19.1 127.15,75.62 120.44,75.62 v2(120,75.17)
  BOTTOM w0.076: v2(120,75.17) 119.68,74.86 UC1.C30
N23795368: length 5.8
  TOP w0.104: T21.1 118.66,52.13 v2(116.64,54.15)
  BOTTOM w0.076: v2(116.64,54.15) 116.66,54.15 116.66,54.17 116.97,54.48 UC1.G3
N23795370: length 7.5
  TOP w0.102: v2(116.62,54.85) 117.3,54.85 118.03,54.12 118.03,53.62 120.06,51.59 T20.1
  BOTTOM w0.076: UC1.J3 116.25,54.48 v2(116.62,54.85)
N23795372: length 8.1
  TOP w0.102: T24.1 76.88,72.39 77.05,72.56 79.55,72.56 v2(81.99,75)
  BOTTOM w0.076: UC1.BR31 81.14,75.37 81.52,75 v2(81.99,75)
N23795374: length 12.3
  TOP w0.102: T22.1 81.14,80.03 82.48,78.68 84.72,78.68 85.31,78.08 85.31,75.29 85.01,74.98 v2(84.92,74.98)
  BOTTOM w0.076: UC1.BH30 85.31,74.59 v2(84.92,74.98)
N23795376: length 5.7
  BOTTOM w0.076: 79.04,77.97 79.67,77.35 80.64,77.35 UC1.BR35
  BOTTOM w0.102: 79.04,77.97 78.12,78.89 T23.1
N23795378: length 15.1
  BOTTOM w0.102: UC1.D1 119.2,53.18 120.14,52.23 127.11,52.23 127.64,52.76 127.64,58.25 T1.1
N23795380: length 16.5
  BOTTOM w0.102: T2.1 128.1,57.41 128.1,52.57 127.18,51.66 119.72,51.66 UC1.E1
N23795385: length 17.8
  BOTTOM w0.076: 119.43,52.47 119.25,52.47 118.68,53.04 118.68,53.66 UC1.E2
  BOTTOM w0.102: 119.43,52.47 119.96,51.95 127.15,51.95 127.87,52.67 127.87,58.64 T4.1
N23795387: length 4.8
  TOP w0.104: T5.1 78.89,50.07 79.7,50.88 79.7,52.51 79.65,52.56 v2(79.65,52.86)
  BOTTOM w0.076: v2(79.65,52.86) 80.22,52.86 80.53,53.18 UC1.BR1
N23795389: length 7.8
  TOP w0.102: 80.05,53.31 79.5,53.31 78.53,52.35 77.9,52.35 T6.1
  TOP w0.104: 80.05,53.31 80.05,53.3 v2(80.06,53.3)
  BOTTOM w0.076: UC1.BT2 80.36,53.6 v2(80.06,53.3)
N23795391: length 8.1
  TOP w0.102: T7.1 79.9,82.02 79.9,79.78 81.98,77.71 v2(81.98,77.34)
  BOTTOM w0.076: v2(81.98,77.34) 82.31,77.67 UC1.BN35
N23795393: length 8.9
  TOP w0.102: T8.1 79.79,82.94 80.48,82.26 80.48,80.36 82.36,78.47 83.46,78.47 84.13,77.81 v2(84.13,77.55)
  BOTTOM w0.076: v2(84.13,77.55) 83.78,77.2 UC1.BL34
N23795395: length 9.6
  TOP w0.102: T11.1 75.64,73.62 76.12,73.62 77.07,74.57 80.95,74.57 81.83,75.46 82.33,75.46 v2(82.63,75.77)
  BOTTOM w0.076: v2(82.63,75.77) 82.31,76.09 UC1.BN33
N23795397: length 1.3
  TOP w0.102: v2(115.13,69.96) 114.75,70.33 T9.1
  BOTTOM w0.076: 115.44,70.09 115.26,70.09 v2(115.13,69.96)
  BOTTOM w0.102: UC1.J24 115.44,70.09
N23795399: length 1.1
  TOP w0.102: v2(116.74,69.68) 117.04,69.98 T10.1
  BOTTOM w0.102: UC1.H24 116.38,70.04 v2(116.74,69.68)
N23795401: length 1.2
  TOP w0.102: T12.1 106.94,61.48 v2(106.94,62)
  BOTTOM w0.076: UC1.AA14 106.74,61.95 106.88,61.95 v2(106.94,62)
N23795403: length 12.6
  IN3 w0.102: v2(103.82,74.94) 102.75,74.94 100.88,76.81 100.64,76.81 99.88,77.57 99.64,77.57 98.51,78.7 98.31,78.7 96.82,80.19 v2(96.76,80.19)
  BOTTOM w0.076: UC1.AE29 103.82,74.3 v2(103.82,74.94) ; v2(96.76,80.19) 96.76,80.33 97.35,80.93 97.35,81.51 T15.1
N23795405: length 11.2
  TOP w0.102: v2(112.5,74.92) 112.74,74.92 113.22,75.4 113.22,80.48 T14.1
  BOTTOM w0.076: UC1.N29 112.5,74.27 v2(112.5,74.92)
N23795407: length 1.2
  TOP w0.102: T13.1 111.26,61.75 v2(111.46,61.95)
  BOTTOM w0.076: UC1.R14 111.16,61.64 v2(111.46,61.95)
N23795412: length 1.8
  TOP w0.102: T28.1 95.53,73.11 v2(95.59,73.05)
  BOTTOM w0.076: UC1.AP29 96.33,73.79 v2(95.59,73.05)
N23795414: length 1.4
  TOP w0.102: v2(96.58,62.33) 96.36,62.56 T27.1
  BOTTOM w0.076: UC1.AP14 96.38,62.13 v2(96.58,62.33)
N23795416: length 8.6
  TOP w0.102: T29.1 77.36,71.6 77.78,72.02 79.97,72.02 81.99,74.04 83.49,74.04 84.02,73.5 v2(84.03,73.5)
  BOTTOM w0.102: v2(84.03,73.5) 84.26,73.28 UC1.BK28
N23795418: length 10
  TOP w0.102: v2(85.39,72.56) 84.64,72.56 83.54,71.45 80.82,71.45 79.73,70.36 77.05,70.36 T30.1
  BOTTOM w0.076: UC1.BJ28 84.94,73.01 v2(85.39,72.56)
N23795436: length 2.7
  TOP w0.102: v2(99.64,57.41) 100.05,57.81 100.05,59 100.12,59.08 T41.1
  BOTTOM w0.076: UC1.AJ8 99.97,57.74 v2(99.64,57.41)
N23795438: length 10.3
  TOP w0.102: T44.1 76.03,71.09 77.19,72.25 79.82,72.25 82.11,74.54 83.71,74.54 84.07,74.9 v2(84.16,74.9)
  BOTTOM w0.102: v2(84.16,74.9) 83.8,75.25 UC1.BL31
N23795440: length 12.2
  BOTTOM w0.102: T43.1 126.04,58.04 126.95,57.12 126.95,53.46 126.54,53.05 121.11,53.05 UC1.B2
N23795442: length 5.9
  BOTTOM w0.102: UC1.B38 120.55,79.92 121.8,79.92 122.68,79.04 125.4,79.04 T45.1
N23795444: length 6.7
  TOP w0.102: T46.1 77.84,50.8
  TOP w0.104: 77.84,50.8 77.85,50.81 78.3,50.81 78.79,51.31 78.79,52.05 v2(78.8,52.05)
  BOTTOM w0.076: v2(78.8,52.05) 78.79,52.05 78.79,52.06 78.79,52.06 78.79,52.06 80.65,52.06 81.65,53.06 UC1.BP1
N23795446: length 7.3
  TOP w0.102: T47.1 77.89,49.66
  TOP w0.104: 77.89,49.66 79.25,51.02 79.25,52.43 v2(79.22,52.46)
  BOTTOM w0.076: UC1.BR2 81.29,53.65 81.29,53.07 80.92,52.71 80.68,52.71 80.44,52.47 79.21,52.47 79.21,52.46 v2(79.22,52.46)
N23795448: length 15.2
  BOTTOM w0.102: UC1.C1 120.06,53.18 120.7,52.54 126.68,52.54 127.41,53.27 127.41,57.62 126.98,58.05 126.98,59.46 T48.1
N23795450: length 6.5
  BOTTOM w0.102: UC1.C38 119.91,79.8 120.25,80.15 121.85,80.15 122.73,79.27 124.15,79.27 T49.1
N23797472: length 1.3
  TOP w0.102: T25.1 92.27,60.8 v2(92.27,60.7)
  BOTTOM w0.076: v2(92.27,60.7) 92.55,60.99 UC1.AW13
N23797474: length 1.2
  TOP w0.102: T26.1 95.31,60.95 v2(95.02,60.66)
  BOTTOM w0.076: v2(95.02,60.66) 94.69,60.99 UC1.AT13
N23797500: length 1.2
  TOP w0.102: T32.1 91.34,60.7 v2(91.35,60.7)
  BOTTOM w0.076: v2(91.35,60.7) 91.64,60.99 UC1.AY13
N23797502: length 1.1
  TOP w0.102: T31.1 93.43,60.9 v2(93.2,60.67)
  BOTTOM w0.076: v2(93.2,60.67) 93.52,60.99 UC1.AU13
N23807582: length 100.8
  IN1 w0.099: v2(150.82,53.44) 150.77,53.49 145.54,53.49 144.86,54.17 143.55,54.17 138.22,59.49 138.22,61.87 136.85,63.25 118.14,63.25 117.6,63.79 116.4,63.79 115.9,64.29 115.13,64.29 114.74,63.89 114.74,62.81 114.88,62.68 114.88,61.56 114.36,61.04 102.41,61.04 101.69,61.77 87.5,61.77 87.16,62.11 87.1,62.11 85.33,63.88 84.88,63.88 84.48,64.29 83.05,64.29 82.85,64.49 81.61,64.49 81.05,63.93 v2(80.67,63.93)
  BOTTOM w0.076: v2(80.67,63.93) 80.72,63.98 80.72,64.58 80.53,64.76 79.49,64.76 78.96,64.24 77.44,64.24 77.37,64.17
  BOTTOM w0.102: v2(150.82,53.44) 150.82,53.77 151.05,54 RZ120.2 151.41,52.96 UZ34.4 ; 77.37,64.17 75.76,62.56 75.76,61.15 75.35,60.73 75.09,60.73 74.67,61.15 74.67,62 v1(73.48,63.19) 72.83,63.84 72.83,64.17 71.8,65.2 71.07,65.2 70.53,64.67 69.41,64.67 69.14,64.4 UZ26.4
N23944525: length 1.2
  TOP w0.089: T34.1 201.51,26.63 v2(201.56,26.58)
  BOTTOM w0.089: v2(201.56,26.58) 201.98,27 UH1.Y35
N23944527: length 1.4
  TOP w0.089: v2(201.54,25.99) 201.1,25.55 T33.1
  BOTTOM w0.089: v2(201.54,25.99) 201.84,25.99 UH1.Y36
N23944529: length 9
  BOTTOM w0.089: 219.29,46.28 218.51,46.28 217.73,45.5 216.09,45.5 214.88,44.29 214.8,44.29 214.41,43.9 213.91,43.9 213.62,43.6 UH1.BC1
  BOTTOM w0.102: 219.29,46.28 220.9,46.28 T36.1
N23944531: length 1.1
  TOP w0.089: v2(207.89,26.89) 208.28,26.5 T35.1
  BOTTOM w0.089: UH1.AL35 v2(207.89,26.89)
N23948454: length 1.2
  TOP w0.089: v2(200.35,37.44) 200.2,37.44 T40.1
  BOTTOM w0.152: v2(200.35,37.44) UH1.U13
N23950785: length 1.4
  TOP w0.089: T60.1 200.03,36.52 v2(200.34,36.83)
  BOTTOM w0.089: v2(200.34,36.83) 200.21,36.71 UH1.R15
N23950786: length 1.4
  TOP w0.102: v2(199.21,37.65) 199.2,37.64 T61.1
  BOTTOM w0.089: v2(199.21,37.65) 199.24,37.65 199.33,37.55 199.64,37.55 UH1.R13
N23950788: length 1.5
  TOP w0.089: v2(208.94,26.87) 209.52,26.28 T62.1
  BOTTOM w0.089: UH1.AN35 v2(208.94,26.87)
N23950789: length 1.9
  TOP w0.089: T63.1 208.26,25.65 v2(207.91,26.01)
  BOTTOM w0.089: v2(207.91,26.01) 207.79,26.13 UH1.AL37
N23950882: length 0.9
  BOTTOM w0.107: CH321.1 RH28.2
N23950883: length 2.6
  BOTTOM w0.102: RH29.2 CH322.1 224.63,19.09 224.63,20.32 v1(224.3,20.65)
N23952498: length 3.1
  BOTTOM w0.102: SW1.2 209.87,9.17 RH101.2 209.93,9.95 v1(209.67,10.21)
N23961117: length 1.5
  TOP w0.089: v2(200.3,26.65) 200.29,26.66 T70.1
  BOTTOM w0.089: UH1.U35 200.58,26.65 v2(200.3,26.65)
N23961134: length 1.6
  TOP w0.089: v2(206.55,37.15) 207.23,37.83 T66.1
  BOTTOM w0.089: v2(206.55,37.15) 206.35,37.35 UH1.AH14
N23961136: length 1.1
  TOP w0.089: v2(206.62,36.57) 207.1,36.57 T67.1
  BOTTOM w0.089: UH1.AH15 v2(206.62,36.57)
N23961138: length 1.2
  TOP w0.137: T68.1 199.42,29.3 v2(199.55,29.17)
  BOTTOM w0.089: v2(199.55,29.17) 199.69,29.03 UH1.R32
N23961140: length 1.1
  TOP w0.089: v2(200.35,25.95) 200.06,26.24 T71.1
  BOTTOM w0.089: UH1.U37 200.64,25.95 v2(200.35,25.95)
N23961142: length 1.2
  TOP w0.102: v2(201.51,36.76) 201.15,36.76 T72.1
  BOTTOM w0.089: UH1.Y15 201.7,36.57 v2(201.51,36.76)
N23961144: length 1.7
  TOP w0.102: T73.1 201.05,37.81 v2(201.51,37.35)
  BOTTOM w0.089: UH1.Y14 v2(201.51,37.35)
N23961148: length 1.2
  TOP w0.137: v2(198.92,27.99) 198.92,27.73 T69.1
  BOTTOM w0.089: UH1.N32 v2(198.92,27.99)
N23961156: length 3.3
  BOTTOM w0.102: QH6.1 198.01,4.93 RH433.2 v1(196.96,4.41)
N23961158: length 8.6
  TOP w0.102: v2(202.18,4.63) v1(202.79,4.63)
  IN3 w0.102: v2(199.68,4.28) 201.82,4.28 v2(202.18,4.63)
  BOTTOM w0.102: RH433.1 199.06,4.28 v2(199.68,4.28) 199.87,4.47 RH432.2 ; v2(202.18,4.63) 202.37,4.63 203.24,5.51 QH7.2 204.49,7.09 CH340.1
N23997893: length 5
  BOTTOM w0.089: UH1.BC22 213.72,33.39 213.79,33.32 214.13,33.32 214.21,33.23 214.97,33.23 215.22,32.99 217.98,32.99 T59.1
N23997895: length 5
  BOTTOM w0.089: UH1.BF23 214.96,32.98 215.14,32.79 218.26,32.79 218.38,32.92 219.06,32.92 T58.1
N24088922: length 3.5
  TOP w0.102: QE17.1 314.14,52.19 RE546.2 312.76,51.45 v1(313.03,51.19)
N24094798: length 7.5
  TOP w0.102: RV9.1 124.35,99.39 RV1400.1 124.08,99.08 124.08,98.45 124.32,98.21 125.05,98.21 v1(125.12,98.28) 125.23,98.39 RV6.1 127.46,96.72 QV7.1
N24426370: length 2.5
  TOP w0.102: UV6.12 327.13,67.67 v1(327.33,67.47) 328.05,66.75 RV622.2
N24491677: length 4.3
  BOTTOM w0.102: v1(143.11,98.39) 143.46,98.04 DV11.1 143.46,96.2 RV626.1 144.38,96.16 CV633.1 144.41,96.57 RV627.2
N24491765: length 5.8
  BOTTOM w0.102: QV18.1 147.39,95.57 RV625.1 149.23,96.19 149.23,97.7 149.63,98.09 v1(149.96,98.09)
N24491790: length 2.7
  BOTTOM w0.102: QV18.2 146.14,97.94 RV627.1 144.87,98.71 v1(144.66,98.92)
N24493415: length 1.1
  BOTTOM w0.102: RV629.1 145.51,92.16 v1(145.3,91.95)
N24493479: length 3.9
  BOTTOM w0.102: v1(149.01,90.66) 150.12,91.78 QV20.1 151.35,91.78 RV630.1
N24493490: length 4.2
  BOTTOM w0.102: RV631.1 148.22,93.86 QV20.2 149.71,93.35 v1(148.18,91.82)
N24493530: length 3.7
  BOTTOM w0.102: QV20.3 151.77,93.74 RV632.1 RV1656.2 154.21,92.87 v1(154.35,92.73)
N25075615: length 7.1
  BOTTOM w0.089: T302.1 208.71,14.17 208.71,15.27 208.02,15.96 208.02,17.11 207.39,17.73 207.39,19.68 207.38,19.7 207.38,20.25 207.39,20.26 207.39,20.33 207.47,20.41 UH1.AL48
N25137817: length 2.8
  BOTTOM w0.102: JNGFF2.67 341.15,52.37 341.87,51.65 T225.1
N25137936: length 4.3
  TOP w0.102: RZ326.1 v1(330.23,54.88) 330.58,55.24 v2(331,55.24)
  BOTTOM w0.102: v2(331,55.24) 330.98,55.24 330.65,54.91 JNGFF2.25
N26091115: length 4
  TOP w0.254: PR2009.2 151.89,58.06 v1(151.93,58.03) v2(151.93,57.47) 151.85,57.39 PR425.2 PR405.2
  BOTTOM w0.254: v2(151.93,57.47) 151.73,57.67 PU401.14
N26108717: length 2.7
  TOP w0.102: PD905.1 9.51,47.02 9.86,46.66 v1(10.49,46.66) 10.55,46.66 11.19,47.3 PU903.1
N26116844: length 6.7
  BOTTOM w0.102: PD903.1 v1(10.55,41.67)
  BOTTOM w0.508: PD903.1 11.79,41.64 PR916.2 11.84,39.79 PD904.1 PD901.1
N26116940: length 6.1
  TOP w0.381: PR12.2 PC6.1 69.52,121.7 69.55,121.72 PR18.1
  TOP w0.508: PR18.1 v2(68.62,122.26)
  IN2 w0.508: v2(68.62,122.26) 67.29,120.93 v2(67.29,120.24)
  BOTTOM w0.102: v2(68.62,122.26) 68.74,122.38 v1(69.13,122.38)
N26497504: length 3.7
  TOP w0.102: v1(125.01,101.26) 125.28,100.99 CV1635.1 ; CV1635.1 125.29,100.27 QV8.2 ; CV1635.1 RV1400.2
N26498681: length 3.1
  BOTTOM w0.102: v1(289.25,42.23) RZ381.2 291.49,42.23 QZ18.6 QZ18.5
N27079153: length 2.7
  BOTTOM w0.102: v1(6.68,37.57) 6.35,37.24 PR934.2
  BOTTOM w0.254: PC944.1 7.21,36.13 7.03,36.31 PR934.2
N27079157: length 2.5
  BOTTOM w0.102: PR914.2 v1(16.55,33.78)
  BOTTOM w0.508: PC930.1 15.31,32.63 PR914.2
N27079171: length 46.7
  TOP w0.254: v2(25.68,4.88) 26.15,4.41 PR917.2
  IN3 w0.152: v2(4.01,25.71) 3.73,25.71 3.58,25.56 3.58,22.19 1.95,20.57 1.95,16.63 7.36,11.23 20.15,11.23 21.12,10.25 23.74,10.25 25.83,8.16 25.83,6.17 25.42,5.77 25.42,5.13 v2(25.68,4.88)
  BOTTOM w0.203: PR937.2 6.69,25.89 v1(4.94,25.89) 4.19,25.89 v2(4.01,25.71)
N27089997: length 4.8
  BOTTOM w0.102: 71.2,5.8 v1(71.2,4.46)
  BOTTOM w0.254: PR513.2 68.34,6.48 68.44,6.38 PR514.1 68.93,6.38 PC513.1 70.41,5.8 PU503.5 71.2,5.8
N27182711: length 2
  TOP w0.102: PC1721.1 v1(56.9,71.06)
  TOP w0.203: PR1740.2 57.77,72.16 PC1721.1
N27933518: length 1.1
  TOP w0.102: PC1917.2 v1(93.18,100.2)
  vias: v2(94.98,100.04)
N27933520: length 1.1
  TOP w0.102: v1(93.15,98.81) 93.34,99 PR1905.1
  vias: v2(94.9,99.12)
N27933540: length 0.8
  TOP w0.102: v1(93.75,96.96) 94.06,96.65 v2(94.06,96.29)
N27933602: length 1.1
  TOP w0.102: v1(96.68,98.81) 96.49,99 PR1905.2
N27933660: length 1.3
  TOP w0.102: PC1919.2 98.57,91.97 v1(98.29,91.69)
N28152235: length 4.2
  TOP w0.102: PC1719.2 61.9,73.25 v1(62.33,72.82)
  TOP w0.203: PC1719.2 61.92,73.86 PR1730.2 61.92,74.72 PC1713.2 61.93,75.61 PR1735.1
N28152401: length 4.8
  TOP w0.102: v1(51.52,86.23) 51.99,85.76 PR1753.2
  TOP w0.203: PR1753.2 52.21,85.24 v2(52.88,84.56) 53.06,84.39 PU1700.15
  BOTTOM w0.203: PC1730.2 53.45,84 v2(52.88,84.56)
N28152437: length 3.3
  TOP w0.203: PU1700.3 58.93,86.41 v2(59.1,86.58)
  BOTTOM w0.203: PR1732.2 58.04,85.5 PC1718.2 58.9,86.38 v2(59.1,86.58)
N28152465: length 4
  TOP w0.203: v2(58.66,77.76) 58.53,77.89 PU1700.36
  BOTTOM w0.102: v2(58.66,77.76) v1(58.66,77.19)
  BOTTOM w0.203: PR1733.1 58.62,78.68 PC1722.1 58.62,77.8 v2(58.66,77.76)
N28152580: length 2.6
  TOP w0.203: PC1703.2 64.79,85.87 PR1709.1 63.92,85 PC1700.1 64.75,84.99 PR1708.2
N28152729: length 4.2
  TOP w0.102: PR1771.1 v1(64.91,88.54)
  TOP w0.203: PR1771.1 63.95,87.68 PR1711.1 64.39,87.65 64.8,87.24 PC1703.1 64.81,86.79 PR1710.2
N28152784: length 3.7
  TOP w0.203: PR1754.2 PC1732.1 52.27,83.99 v1(53.11,83.99) PU1700.16
N28152844: length 3.2
  BOTTOM w0.102: v1(51.69,69.25) 50.83,68.4 PR1768.2
  BOTTOM w0.254: PR1770.1 PH1704.1 PR1768.2
N28152958: length 8.4
  TOP w0.203: v2(53.36,69.82) 54.68,69.82 55.13,70.27 v1(55.13,70.89) PR1744.2 55.11,74.04 PR1748.1
  BOTTOM w0.203: v2(53.36,69.82) 52.45,68.9 PH1702.2
N28153073: length 65.6
  TOP w0.152: v2(65.57,80.45) 65.21,80.45 v1(64.94,80.72) 64.76,80.9 64.26,80.9 PR1701.1
  IN3 w0.102: v2(65.57,80.45) 65.77,80.65 65.77,82.88 66.05,83.16 66.69,83.16 69.6,86.07 72.44,86.07 73.05,85.46 76.8,85.46 77.08,85.18 78.68,85.18 78.99,85.49 106.6,85.49 107.28,84.81 109.66,84.81 110.31,85.46 116.42,85.46 117.66,86.7 v2(117.66,92.07)
  BOTTOM w0.152: v2(117.66,92.07) 117.61,92.03 PH1700.2
N28153459: length 4
  TOP w0.102: v1(78.25,95.54) PR1767.2
  TOP w0.254: PR1767.2 PR1769.1 76.59,96.38 76.45,96.24 76.45,96.18 76.51,96.11 v2(76.51,96)
  BOTTOM w0.254: PH1703.1 75.93,96.69 76.51,96.11 v2(76.51,96)
N28153589: length 3.1
  TOP w0.203: PU1700.43 61.12,81.19 v1(61.51,80.79) 61.82,80.49 v2(62.14,80.49)
  BOTTOM w0.203: v2(62.14,80.49) 62.64,81 PR1724.1
N28153954: length 2
  TOP w0.102: v1(56.89,90.73) 57.18,90.73 PR1737.2
  TOP w0.203: PR1737.2 PC1716.1
N28154016: length 6.4
  TOP w0.203: v2(59.47,90.87) 60.59,90.87 60.79,90.66 60.79,90.66 60.89,90.56 60.89,90.36 61.17,90.08 PR1726.2 61.28,90.07 PR1727.1 61.49,89.26 62.16,88.59 PC1711.1
  BOTTOM w0.203: v2(59.47,90.87) v1(60,90.34) 60.14,90.2 PC1712.1
N28154283: length 20.7
  TOP w0.102: v1(70.62,90.09) 70.62,90.54 v2(70.49,90.67)
  TOP w0.203: PR1746.1 55.15,90.87 v2(55.12,90.83) 55.09,90.81 PR1743.2
  IN3 w0.122: v2(70.49,90.67) 70.49,90.66 69.61,90.66 68.3,89.36 65.2,89.36 64.76,88.92 58.81,88.92 56.9,90.83 v2(55.12,90.83)
  BOTTOM w0.102: PH1701.2 71.34,91.64 71.08,91.38 71.08,91.25 v2(70.49,90.67)
N28180064: length 2
  TOP w0.102: v1(66.85,82.28) 66.85,82.76 PR1720.2
  TOP w0.203: PR1720.2 65.53,83.24 PC1709.1
N28185893: length 1.9
  TOP w0.102: PC1720.1 v1(58.64,71.13)
  TOP w0.203: PC1720.1 59.52,72.16 PR1738.2
N28185971: length 2.6
  TOP w0.102: v1(59.51,91.44) 59.38,91.44 59.04,91.1 59.04,90.63 59.5,90.16 PR1731.2
  TOP w0.203: PR1731.2 60.39,90.16 PC1715.1
N29227301: length 2.6
  TOP w0.102: v1(64.07,89.64) 63.79,89.64 63.04,88.89 PR1771.2
  TOP w0.203: PC1707.1 PR1771.2
N30206818: length 15.5
  TOP w0.102: v1(53.57,118.37) PQ1202.4
  TOP w0.305: PQ1202.4 52.15,118.86 51.3,119.71 49.31,119.71 49.01,120.01 49.01,121.21 49.31,121.51 PR1207.2 PC1203.2 50.47,122.5 PR1213.1 50.92,122.96 54.4,122.96 55.19,122.17 PQ1203.1
N30206910: length 53.2
  TOP w0.254: v2(80.26,110.44) 80.26,110.07 78.63,108.44 76.18,108.44 v1(74.94,107.2) 74.01,106.27 72.5,106.27 71.41,105.18 71.41,103.05 70.74,102.37 PR1209.1 ; PQ1203.2 52.85,122.17 52.31,121.63 52.11,121.63 51.99,121.51 PR1202.2 v2(51.35,122.25)
  IN2 w0.254: v2(51.35,122.25) 52.6,123.49 69.31,123.49 73.61,119.2 73.61,118.49 80.26,111.84 v2(80.26,110.44)
N30207371: length 7.5
  TOP w0.381: PQ1213.4 44.06,112.67 44.05,112.68 PC1202.2 42.91,112.68 42.71,112.47 PR1205.2 41.97,112.47 41.77,112.67 41.3,112.67 v1(41.22,112.6) 41.22,112.2 41.94,111.49 PR1212.1 41.94,110.96 42.45,110.45 PQ1215.1
N30393649: length 0.6
  BOTTOM w0.254: v2(169.66,9.02) PR306.1
  vias: v1(170.21,9.05)
N30393661: length 2.6
  TOP w0.102: v1(173.31,10.62) 173.31,10.78 172.71,11.38 171.73,11.38 PR316.1
N30393852: length 2
  BOTTOM w0.254: PR2008.1 166.86,9.79 166.86,10.5 v1(166.96,10.6) 167.81,10.6 PC307.1
N35551558: length 41.2
  TOP w0.102: PC1210.1 v1(26.7,119.41)
  TOP w0.381: PC1210.1 27.37,120.41 27.5,120.55 v2(27.5,120.6)
  IN2 w0.508: v2(25.57,102.12) 25.57,102.58 24.43,103.72 20.98,103.72 19.94,104.76 17.81,104.76 16.87,105.7 16.87,111.26 16.24,111.9 16.24,116.83 16.49,117.08 16.49,118.73 18.44,120.67 19.66,120.67 20.47,119.86 22.35,119.86 23.08,120.6 v2(27.5,120.6)
  BOTTOM w0.381: PQ1206.4 25.72,121.01 26.09,120.64 26.12,120.64 26.19,120.57 PR1228.2 27.47,120.57 v2(27.5,120.6) ; v2(25.57,102.12) PR1229.1
N35551572: length 20.3
  IN2 w0.102: v2(26.59,104.8) 26.59,104.86 27.69,105.97 33.73,105.97 34.97,107.21 v2(38.02,107.21)
  BOTTOM w0.102: PC1214.1 v1(27.15,102.03) ; PR1243.2 40.42,105.54 40.08,105.21 38.64,105.21 38.02,105.83 v2(38.02,107.21)
  BOTTOM w0.254: v2(26.59,104.8) 26.53,104.8 26.53,104.8 26.65,104.8 27.29,104.16 PQ1209.5 27.29,103.16 PC1214.1
N35551576: length 4.2
  BOTTOM w0.102: PR1236.1 v1(29.13,106.39)
  BOTTOM w0.254: PR1236.1 28.09,105.38 27.94,105.54 PQ1209.3 27.94,106.31 27.8,106.45 27.42,106.45 27.29,106.33 PQ1209.2
N35551581: length 2.6
  BOTTOM w0.102: PR1229.2 25.82,103.03 25.4,103.45 v1(25.4,103.92)
  BOTTOM w0.381: PR1229.2 26.27,103.47 26.64,103.83 PQ1209.6
N35551584: length 13.5
  BOTTOM w0.102: PR1240.2 38.64,105.88 v1(38.39,106.13)
  BOTTOM w0.254: PC1213.1 39.92,102.44 PU1201.7 42.9,102.44 43.28,102.82 43.28,104.18 PD1205.2 42.21,105.31 42.93,106.03 PR1238.2 41,106.64 40.85,106.8 PR1243.1 40.14,106.8 39.92,106.58 39.92,106.35 39.46,105.88 PR1240.2
N35551592: length 5.1
  BOTTOM w0.102: PR1237.2 v1(39.78,98.88)
  BOTTOM w0.254: PU1201.6 39.88,101.79 PR1247.1 PC1212.1 PR1237.2
N35551616: length 4.4
  BOTTOM w0.102: PQ1212.2 v1(46.15,96.57)
  BOTTOM w0.254: PR1249.1 PR1250.1 PR1248.1 47.12,97.76 PQ1212.2
N35551655: length 6.1
  BOTTOM w0.102: v1(50.16,103.95) 48.8,103.95 PR1208.2
  BOTTOM w0.254: PU1201.2 48.15,102.44 PR1217.1 PC1205.1 PR1208.2
N35551713: length 21.5
  TOP w0.102: PR1212.2 v1(40.02,111.34)
  TOP w0.254: PR1212.2 41.02,110.81 41.7,110.13 41.7,109.24 41.45,108.99 41.45,107.18 v2(41.5,107.13) ; PQ1201.6 56.42,106.59 v2(56.05,106.96)
  IN1 w0.099: v2(56.05,106.96) 56.05,107.17 55.63,107.59 41.96,107.59 v2(41.5,107.13)
N35551806: length 2.4
  TOP w0.102: v1(70.04,101.37) 69.82,101.59 PR1209.2
  TOP w0.254: PQ1204.3 69.72,102.45 PR1209.2
N35551822: length 27.6
  TOP w0.254: PR1213.2 v2(48.94,122.58) ; v2(55.42,106.96) v1(55.42,106.36) 55.42,106.15 56,105.56 57.45,105.56 57.89,105.12 PQ1201.3
  BOTTOM w0.254: v2(55.42,106.96) 55.42,107.31 55.01,107.72 53.91,107.72 53.68,107.49 49.26,107.49 48.04,108.71 48.04,113.64 48.81,114.41 48.81,122.45 v2(48.94,122.58)
N36255106: length 3.3
  TOP w0.102: v1(59.11,106.08) 57.75,106.08 PQ1201.5
  TOP w0.254: PR1220.1 57.24,107.54 PQ1201.5
N37051879: length 4.8
  BOTTOM w0.102: v1(77.68,7.37) 77.08,6.76 PC515.2
  BOTTOM w0.254: PU503.3 74.97,6.45 75.25,6.72 PR515.2 76.19,6.72 76.22,6.76 PC515.2 76.64,6.36 76.66,6.34 76.66,5.98 PR516.1
N37229012: length 1.4
  TOP w0.102: PC119.1 v1(121.84,127.85)
N37327097: length 7.3
  TOP w0.254: PR950.1 9.88,48.92 8.3,47.34 8.3,47.31 PD905.3 6.61,45.62 v1(6.19,45.62) 5.76,45.62 5.51,45.87 PR939.2
N37327116: length 2.3
  TOP w0.102: v1(14.61,44.87) PR946.1 14.09,45.93 14.02,46 PU903.4
N37327193: length 3.1
  TOP w0.102: PU903.2 11.37,46.65 v1(10.11,45.39) 10.08,45.36 PR942.2
N37327195: length 3
  TOP w0.102: v1(7.17,49.25) 7.61,48.82 PD905.2
  TOP w0.254: PR941.2 6.88,47.19 PD905.2
N37327368: length 3.5
  TOP w0.203: PU901.30 7.33,33.21 7.18,33.06 6.9,33.06 6.71,32.87 v1(6.4,32.87) 6.29,32.98 6.25,32.98 6.24,32.99
  TOP w0.254: 6.24,32.99 PR948.1 PR936.1
N37327475: length 1.6
  TOP w0.203: PU901.29 6.91,33.61 v2(6.84,33.54)
  BOTTOM w0.254: PR949.1 6.58,33.81 v2(6.84,33.54)
N37345559: length 7.6
  TOP w0.203: PR951.2 4.87,40.46 4.87,39.01 5.33,38.56 5.38,38.56 5.38,38.09 5.88,37.59 5.88,36.58 6.62,35.84 v1(6.62,35.5) 7.3,34.81 PU901.26
N37346094: length 3.5
  BOTTOM w0.102: v1(76.83,114.07) 76.5,113.74 PR1245.2
  BOTTOM w0.254: PR1245.2 76.81,113.13 77.36,112.57 77.92,112.57 78.28,112.93 PQ1210.5
N37346120: length 7.1
  BOTTOM w0.254: PR1233.1 82.38,113.02 v1(82.38,112.47) 82.48,112.37 83.4,112.37 83.7,112.67 84.37,112.67 84.63,112.93 PQ1211.5 84.63,113.69 84.88,113.94 86.33,113.94 PR1242.2
N37346130: length 3.4
  BOTTOM w0.102: v1(82.93,111.23) 83.69,110.46 PR1235.1
  BOTTOM w0.254: PR1235.1 PR1257.2 84.63,110.31 PQ1211.2
N37346160: length 43.2
  IN2 w0.254: v2(86.89,114.2) 86.89,113.52 88.12,112.29 88.12,109.77 85.91,107.56 78.8,107.56 76.93,105.68 73.14,105.68 71.72,104.26 67.91,104.26 66.49,105.68 66.49,107.43 67.18,108.11 69.78,108.11 v2(70.86,107.04)
  BOTTOM w0.254: v2(86.89,114.2) 86.66,114.43 v1(85.66,114.43) 84.3,114.43 83.98,114.11 PQ1211.4 ; PQ1207.6 70.14,108.16 PR1258.2 70.2,107.09 PR1230.1 v2(70.86,107.04)
N37346172: length 4.8
  BOTTOM w0.102: v1(66.94,104.52) 68.3,104.52 PR1232.1
  BOTTOM w0.254: PR1232.1 68.5,105.38 PQ1207.2 68.5,106.55 68.4,106.65 67.95,106.65 67.85,106.55 PQ1207.3
N37346182: length 2.5
  BOTTOM w0.254: PQ1207.5 68.5,108.7 v1(68.92,109.12) 70.07,109.12 PR1241.2
N37346205: length 30.3
  IN2 w0.254: v2(86.28,110.39) 84.33,108.43 77.73,108.43 75.59,106.29 72.65,106.29 72.02,105.66 69.08,105.66 67.79,106.95 v2(67.79,107.3)
  BOTTOM w0.254: v2(67.79,107.3) 67.65,107.3 67.36,107.59 67.36,108.74 67.48,108.86 67.48,109.75 67.36,109.88 66.47,109.88 66.01,109.42 PR1234.1 ; PQ1208.6 66.01,108.07 PR1234.1 ; PQ1211.1 86.25,111.34 v1(86.47,111.12) 86.47,110.58 v2(86.28,110.39) ; PR1261.2 PR1234.1
N37346217: length 4.1
  BOTTOM w0.102: PR1259.1 64.26,105.18 v1(64.03,104.95)
  BOTTOM w0.254: PQ1208.3 64.68,106.7 64.83,106.86 65.17,106.86 65.32,106.7 PQ1208.2 65.25,106.06 65.25,105.41 PR1259.1
N37346239: length 5.2
  BOTTOM w0.102: PR1260.2 v1(63.24,110.24)
  BOTTOM w0.254: PQ1208.5 65.32,108.48 65.2,108.61 64.74,108.61 PR1261.1 PR1260.2 63.29,109.07 PR1244.2
N37359040: length 30.7
  TOP w0.254: PR415.2 136.57,60.73 v1(136.78,60.93) 137.52,61.68 v2(137.65,61.68)
  IN3 w0.254: v2(149.25,62.21) 149.25,62.71 150.08,63.55 150.08,66.27 147.24,69.11 138.35,69.11 137.97,68.73 137.97,62 v2(137.65,61.68)
  BOTTOM w0.254: v2(149.25,62.21) 149.25,62.53 PR414.2 149.78,62.26 150.2,61.84 150.54,61.84 150.73,61.65 PU401.5
N37410469:
  vias: v1(90.13,10.06) v2(90.22,9.42) v2(90.22,8.79)
N39381572: length 2
  BOTTOM w0.102: v1(86.89,11.7) 87.21,11.38 PC113.2
  BOTTOM w0.254: PC113.2 87.88,11.32 88.65,11.32 PR108.1
N39381889: length 1.9
  TOP w0.102: v1(119.89,134.49) PR117.1
  TOP w0.254: PR117.1 PC127.2
N42077993: length 5.9
  TOP w0.254: v2(66.54,100.62) 66.18,100.62 65.87,100.3 PR1800.2
  BOTTOM w0.305: 68.41,101.68 69.21,100.88 PU1800.3
  BOTTOM w0.508: PC1812.2 66.65,102.38 v1(66.49,102.22) 66.49,100.66 v2(66.54,100.62)
N42078041:
  vias: v1(80.18,101.26) v2(80.68,101.42)
N42078055: length 0.7
  TOP w0.102: v1(78.98,100.7) 79.26,100.98 79.26,101.32
  vias: v2(79.66,101.43)
N42078421: length 1.4
  BOTTOM w0.102: v1(72.12,104.25) 71.51,103.65 PC1813.1
N42078543: length 1.9
  TOP w0.102: PR1803.1 73.22,92.33 73.22,93.33 v1(73.1,93.46)
N42078657: length 1.2
  TOP w0.102: PR1805.2 v1(79.18,104.98)
N42078671: length 2.1
  TOP w0.102: v1(75.97,103.2) 76.27,102.89 PC1822.2
  BOTTOM w0.254: PU1801.3 78.68,101.36 v2(78.61,101.43)
N42078715: length 1.4
  TOP w0.102: v1(82.52,95.34) 82.22,95.03 PC1825.2
N42079748: length 1.2
  TOP w0.102: PR1901.1 86.81,98.74 v1(87.12,98.44)
  vias: v2(85.37,98.87)
N42079752: length 1.4
  TOP w0.102: PC1907.2 86,100.77 v1(86.39,101.17)
  vias: v2(85.31,99.67)
N42079902: length 1.3
  TOP w0.102: PC1907.1 v1(84.6,101.22)
N42079910: length 1.6
  TOP w0.102: v2(85,95.81) v1(84.42,95.81)
  TOP w0.508: v2(85,95.81) 85.34,95.48 PR1900.2
N42079960: length 2.2
  TOP w0.102: PR1903.1 91.28,92.13 v1(91.28,91.9)
N52218840: length 2.9
  TOP w0.203: v2(53.54,78.35) 53.57,78.32 v1(54.05,78.32) 54.2,78.32 54.93,79.05 PU1700.27
  BOTTOM w0.203: PR1745.2 53.93,78.74 v2(53.54,78.35)
N119328643: length 8
  TOP w0.203: PR931.2 PR930.1 5.89,38.71 6.04,38.56 PC938.1 6.4,37.81 6.27,37.68 v1(6.27,36.78) 7.07,35.98 7.07,35.55 7.4,35.21 PU901.25
N131988242: length 2.9
  TOP w0.203: PU901.21 9.61,36.81
  TOP w0.254: PR920.2 9.2,38.42 v1(9.2,37.22) 9.61,36.81
N131988252: length 3.3
  TOP w0.203: PU901.22 9.21,36.52
  TOP w0.254: 9.21,36.52 8.62,37.11 8.56,37.11 v2(8.43,37.24)
  BOTTOM w0.254: PR922.2 8,38.38 v1(8,37.58) 8.34,37.24 v2(8.43,37.24)
N132000604: length 1.1
  TOP w0.102: PR921.2 v1(10.7,26.91)

## Copper pours and planes (outline as drawn)
1.2VSP on TOP (solid shape): 147.94,131.53 147.94,127.91 147.75,127.72 144.89,127.72 144.83,127.79 144.83,128.36 145.14,128.68 145.14,129.47 145.67,129.47 145.67,129.91 145.14,129.91 145.14,131.28 145.72,131.85 147.62,131.85
2.5VSP on BOTTOM (solid shape): 76.71,9.88 76.71,9.53 76.15,9.53 76.15,9.09 76.71,9.09 76.71,8.61 76.78,8.53 76.78,8.2 77.01,7.98 77.01,7.44 76.91,7.34 75.41,7.34 75.26,7.49 73.83,7.49 73.71,7.62 73.71,9.83 74.16,10.29 76.3,10.29
3V_SN on TOP (solid shape): 89.33,6.69 89.33,5.83 89.57,5.59 89.57,3.86 89.53,3.82 88.49,3.82 88.44,3.88 88.44,5.87 88.44,5.87 88.44,6.79 88.46,6.82 89.2,6.82
3V_VIN on TOP (solid shape): 84.07,5.71 85.26,5.71 85.3,5.68 85.34,5.58 85.42,5.49 85.51,5.4 86.48,5.4 86.62,5.54 88.11,5.54 88.11,5.53 88.11,4.62 87.52,4.04 83.61,4.04 82.93,4.72 82.93,6.04 83.08,6.2 83.59,6.2
3V_VIN on BOTTOM (solid shape): 85.19,5.59 85.31,5.59 85.47,5.43 85.51,5.43 85.52,5.43 85.64,5.41 85.77,5.43 85.78,5.43 86.12,5.43 86.13,5.43 86.4,5.44 86.58,5.63 86.59,5.64 87.04,6.1 88.49,6.1 88.59,5.99 88.59,5.1 87.07,3.58 81.38,3.58 80.9,4.06 80.9,4.47 81.45,4.47 81.45,4.97 80.9,4.97 80.9,5.27 81.45,5.27 81.45,5.77 80.9,5.77 80.9,6.15 80.95,6.2 84.58,6.2
5V_SN on BOTTOM (solid shape): 123.45,129.08 123.45,129.03 123.57,128.91 123.57,128.12 123.19,127.74 123.19,125.88 123.11,125.81 122.03,125.81 121.89,125.95 121.89,128.79 122.18,129.08 123.44,129.08
5V_VIN on TOP (solid shape): 128.43,135.28 128.43,133.97 128.63,133.77 131.78,133.77 132.25,133.3 132.25,128.45 132.05,128.24 131.62,128.24 131.62,128.79 131.11,128.79 131.11,128.24 130.82,128.24 130.82,128.79 130.31,128.79 130.31,128.24 129.56,128.24 128.98,128.83 128.98,131.22 128.55,131.65 124.99,131.65 124.89,131.75 124.89,133.17 125.01,133.3 126.06,133.3 126.39,133.63 126.39,134.39 126.53,134.53 127.14,134.53 127.31,134.71 127.31,135.33 127.35,135.37 128.34,135.37
5V_VIN on BOTTOM (solid shape): 128.33,135.2 128.33,133.32 128.2,133.2 126.59,133.2 126.48,133.31 126.48,134.48 126.54,134.54 127.17,134.54 127.33,134.7 127.33,135.29 127.39,135.36 128.18,135.36
+0.6V_DDR_VTT on TOP (solid shape): 176.3,15.29 176.3,14.96 176.79,14.46 178.9,14.46 178.99,14.38 178.99,13.54 178.77,13.32 175.47,13.32 175.26,13.54 175.26,14.05 175.21,14.1 175.21,15.42 175.56,15.77 175.81,15.77
+0.6V_DDR_VTT on TOP (solid shape): 47.05,12.69 47.43,12.69 47.53,12.59 47.58,12.47 47.67,12.37 47.67,11.25 47.52,11.1 47.07,11.1 47.07,10.55 46.89,10.55 46.89,11.1 46.45,11.1 46.43,11.08 46.4,11.08 46.4,11.41 46.3,11.51 46.2,11.73 45.98,11.84 45.9,11.91 45.9,12.45 46.15,12.69 47.04,12.69
+0.6V_DDR_VTT on TOP (solid shape): 95.13,15.69 95.13,14.34 94.95,14.16 92.55,14.16 92.42,14.02 92.42,13.64 92.59,13.47 93.12,13.47 93.51,13.08 93.51,12.62 93.48,12.58 92.1,12.58 92.01,12.63 92,12.72 91.97,13.04 91.7,13.21 91.66,13.22 91.65,13.26 91.65,14.9 91.74,14.99 94.16,14.99 94.22,14.99 94.22,15.04 94.22,15.6 94.55,15.93 94.9,15.93
+0.6V_DDR_VTT on IN2 (solid shape): 109.19,11.89 109.19,11.1 108.89,10.79 104.59,10.79 104.06,11.33 104.06,12.52 104.16,12.62 108.45,12.62
+0.6V_DDR_VTT on IN2 (solid shape): outline of 198 points within 158.79,11.58 178.93,13.97
+0.6V_DDR_VTT on IN1: outline of 190 points within 45.59,8.72 105.61,15.18
+0.6VSP on TOP (solid shape): 46.76,10.42 47.2,10.42 47.2,10.97 47.47,10.97 47.52,10.92 47.52,9.6 47.21,9.3 46.76,9.3 46.49,9.56 46.48,9.6 46.46,9.65 46.45,9.67 46.45,10.92 46.5,10.97 46.76,10.97
+0.6VSP on BOTTOM (solid shape): 47.04,11.78 47.07,11.61 47.19,11.47 47.19,10.31 47.54,9.96 47.54,9.61 47.14,9.2 47.14,9.19 47.14,8.48 47.08,8.48 47.04,8.45 46.96,8.43 46.89,8.45 46.84,8.48 46.63,8.48 46.59,8.45 46.56,8.44 46.53,8.43 46.46,8.42 46.45,8.41 46.35,8.51 46.35,9.14 46.5,9.29 46.5,10.44 46.3,10.64 46.3,11.76 46.35,11.81 47.01,11.81
+0.9V_LAN on TOP (solid shape): 330.3,86.94 330.33,86.91 330.88,86.91 331.02,86.77 331.02,85.41 330.87,85.25 329.53,85.25 329.03,85.76 328.01,85.76 327.89,85.88 327.89,87.15 328.11,87.38 330.3,87.38
+0.9V_LAN on TOP (solid shape): 323.16,83.64 323.16,82.86 324.33,81.69 324.33,80.1 324.2,79.98 323.38,79.98 323.25,80.1 323.25,81.81 322.54,82.53 322.54,83.65 322.59,83.71 323.1,83.71
+0.9V_LAN on IN3: 323.26,79.78 322.69,80.35 318.12,80.35 316.66,81.81 316.66,88.54 319.07,90.96 320.72,90.96 320.81,90.91 320.82,90.82 321.16,90.35 321.49,90.82 321.51,90.91 321.59,90.96 322.63,90.96 322.88,90.35 323.13,90.96 327.15,90.96 327.3,90.81 327.51,90.77 328.6,89.69 328.6,87.65 329.1,87.15 330.75,87.15 330.75,87.02 331.64,86.13 331.64,85.16 331.61,85.15 331.3,84.87 331.48,84.49 331.53,84.41 331.5,84.33 329.75,82.59 324.55,82.59 324.14,82.17 324.14,81.07 324.52,80.68 324.52,80.19 324.11,79.78
+1.0V_ALW_PCH on BOTTOM (solid shape): 189.23,49.69 189.23,48.95 189.18,48.89 188.27,48.89 188.15,48.77 188.15,48.18 188.05,48.08 187.35,48.08 187.19,48.23 187.19,49.72 187.22,49.75 187.37,49.76 187.5,49.82 189.1,49.82
+1.0V_ALW_PCH on IN2 (solid shape): outline of 114 points within 194.71,15.77 203.34,20.14
+1.0V_ALW_PCH on TOP: 199.2,44.54 199.2,42.48 199.41,42.27 200.2,42.27 200.22,42.29 202.12,42.29 203.4,41.01 203.4,37.3 203.56,37.13 204.83,37.13 204.95,37.25 204.95,42.84 203.18,44.6 199.26,44.6
+1.0V_ALW_PCH on TOP: 195.14,20.67 194.76,20.67 194.75,20.69 189.38,20.69 187.82,22.25 187.82,28.16 192.99,33.32 196.47,33.32 197.75,34.61 198.85,34.61 199.36,35.11 201.46,35.11 203.42,37.08 203.42,37.1 203.44,37.11 204.77,37.11 204.86,37.2 204.86,37.64 204.71,37.79 201.9,37.79 201.81,37.71 201.81,36.7 201.65,36.54 186.66,36.54 185.04,34.91 185.04,30.72 185.82,29.93 185.82,20.55 188.3,18.07 188.3,17.42 187.96,17.08 187.96,15.94 188.06,15.84 196.19,15.84 196.5,16.15 196.5,17.46 198.64,19.59 198.64,20.54 198.51,20.67 196.54,20.67 196.54,20.1 195.14,20.1
+1.0V_ALW_PCH on TOP: 205.26,18.38 205.01,18.13 202.69,18.13 202.56,18.26 202.56,19.69 202.66,19.78 205.2,19.78 205.26,19.72
+1.0V_ALW_PCH on BOTTOM: 194.95,19.65 194.95,17.62 195.46,17.11 196.6,17.11 196.73,17.24 196.73,19.59 196.54,19.78 195.08,19.78
+1.0V_ALW_PCH on IN2: 188.01,49.48 188.01,45.96 189.17,44.8 195,44.8 195.86,43.95 201.9,43.95 202.07,44.12 202.07,45.83 201.77,46.13 197.27,46.13 196.16,47.25 190.63,47.25 189.85,48.03 189.85,49.25 189.51,49.58 188.12,49.58
+1.0V_AMPHYPLL on BOTTOM (solid shape): 193.87,20.1 194.71,20.1 194.75,20.06 194.75,19.48 194.77,19.46 194.77,17.43 195.53,16.67 196.54,16.67 196.67,16.54 196.67,15.78 196.54,15.65 195.14,15.65 194.89,15.91 192.6,15.91 192.48,16.04 192.48,19.21 192.76,19.49 193.3,19.49 193.45,19.65 193.45,20.08 193.5,20.12 193.86,20.12
+1.0V_BCLKPLL2_R on BOTTOM (solid shape): 188.98,46.11 188.98,45.82 189.05,45.75 190.88,45.75 191.82,44.81 192.05,44.81 192.44,44.41 192.44,44.38 193.05,43.78 193.16,43.78 193.34,43.6 193.34,43.58 193.37,43.47 193.44,43.38 193.44,42.42 193.34,42.32 193.06,42.32 193.02,42.36 193,42.4 193,42.58 193.05,42.74 193,42.91 193,43.08 193.02,43.37 192.78,43.52 192.77,43.52 192.64,43.59 192.63,43.61 192.47,43.79 192.24,43.83 192.23,43.83 191.83,43.83 191.82,43.81 191.67,43.81 190.36,45.12 187.85,45.12 187.59,45.53 187.16,45.31 186.91,45.49 186.61,45.4 186.49,45.51 186.49,46.23 186.56,46.29 188.81,46.29
+1.0V_CLPLLEBB on TOP: outline of 96 points within 198.06,20.1 202.49,29.43
+1.0V_MPHY on TOP: 194.08,32.46 194.25,32.63 194.26,32.62 199.99,32.62 200.77,31.85 201.77,31.85 201.89,31.72 201.89,29.63 201.57,29.31 201.57,29.05 201.32,28.8 200.12,28.8 199.58,28.26 199,28.26 198.85,28.1 198.85,24.8 198.81,24.77 198.81,24.07 197.81,23.06 197.81,21.18 197.49,20.86 190.38,20.86 188.49,22.76 188.49,28.53 192.41,32.46
+1.0V_MPHY on VCC: 184.62,21.3 184.45,21.47 184.45,32.56 186.08,34.19 202.1,34.19 202.1,27.88 201.81,27.58 198.7,27.58 197.91,26.8 197.91,22.36 196.86,21.3
+1.0V_OC on TOP: 201.77,34.86 201.77,34.28 201.77,34.26 201.76,34.24 201.71,34.2 201.7,34.18 201.68,34.18 201.19,34.18 200.92,34.44 200.33,34.44 200.21,34.33 199.44,34.33 199.37,34.39 199.37,34.9 199.46,34.98 201.65,34.98
+1.0V_PRIM on TOP (solid shape): 146.12,56.74 146.12,55.22 145.87,54.97 140.79,54.97 139.99,55.77 139.99,56.93 140.37,57.31 145.55,57.31
+1.0V_PRIM on TOP (solid shape): 184.22,15.82 184.22,15.72 185.62,14.33 185.64,14.33 185.72,14.25 189.75,14.25 189.75,14.24 189.81,14.17 189.81,11.62 189.23,11.04 184.74,11.04 183.48,12.3 183.48,13.66 182.86,14.27 182.86,15.65 183.37,16.15 183.89,16.15
+1.0V_PRIM on TOP (solid shape): outline of 148 points within 129.01,70.1 145.89,94.39
+1.0V_PRIM on BOTTOM (solid shape): 188.36,12.53 188.36,9.73 188.01,9.37 186.28,9.37 186.23,9.42 184.76,9.42 184.4,9.78 184.4,12.85 184.86,13.31 187.58,13.31
+1.0V_PRIM on BOTTOM (solid shape): outline of 105 points within 134.64,54.58 141.73,72.8
+1.0V_PRIM on TOP: 202.87,29.5 202.64,29.73 202.64,30.74 202.89,30.99 202.91,30.99 203.14,31.06 203.29,31.24 203.25,31.64 202.88,31.8 202.8,31.78 202.71,31.75 202.68,31.73 202.48,31.94 202.49,31.97 202.54,32.25 202.39,32.5 202.35,32.56 202.39,32.62 202.54,32.87 202.49,33.16 202.47,33.19 202.71,33.43 202.74,33.41 203.22,33.54 203.11,34.02 203.06,34.11 203.11,34.2 203.26,34.41 203.23,34.67 203.23,34.78 203.31,34.83 203.87,34.83 203.98,34.71 203.98,34.1 203.97,34.09 204.03,34.03 204.03,33.63 204.39,33.27 206.12,33.27 206.34,33.05 206.34,29.59 206.32,29.57 206.32,29.29 206.28,29.24 205.84,29.24 205.58,29.5
+1.0V_PRIM on VCC: 184.94,11.07 184.45,11.56 184.45,20.62 184.62,20.79 197.07,20.79 198.42,22.14 198.42,26.59 198.91,27.08 202.02,27.08 202.61,27.67 202.61,34.34 203.16,34.89 209.3,34.89 210.1,34.08 210.1,13.47 209.36,12.72 191.69,12.72 190.06,11.07
+1.0V_PRIM on IN3: 206.76,31.79 207.45,31.1 207.45,22.57 208.15,21.87 208.15,19.84 208.05,19.74 208.05,18.62 206.71,17.28 203.15,17.28 202.84,17.59 202.84,18.3 203.18,18.64 204.85,18.64 204.85,19.49 204.24,20.1 203.44,20.1 202.54,21.01 202.54,22.15 200.03,24.65 200.03,31.19 200.63,31.79
+1.0V_PRIM_CNV_HVLO on TOP (solid shape): 204.86,36.65 204.86,36.5 204.92,36.37 204.92,35.68 204.75,35.5 203.93,35.5 203.84,35.6 203.84,35.83 204.23,36.23 204.23,36.72 204.33,36.82 204.69,36.82
+1.0V_PRIM_FUSE on TOP: 202.71,24.26 202.74,24.26 203.13,24.65 203.13,25.7 203.32,25.89 203.32,27.23 203.22,27.33 203.22,27.51 203.31,27.74 203.22,27.98 203.22,28.89 203.27,29.05 203.25,29.21 203.23,29.24 203.32,29.33 203.86,29.33 203.96,29.23 203.96,28.97 203.73,28.74 203.73,24.1 202.92,23.29 202.92,20.92 203.23,20.6 203.23,20.16 203.11,20.03 202.4,20.03 202.07,20.37 202.07,23.61
+1.0V_SRC on TOP: 201.95,34.21 201.9,34.26 201.9,35.34 203.5,36.94 203.96,36.94 204.04,36.87 204.04,36.39 203.7,36.05 203.7,35.37 202.62,34.3 202.65,34.26 202.59,34.21
+1.0V_VCCST on IN2 (solid shape): outline of 372 points within 116.51,73.65 121.08,76.67
+1.0V_VCCST on TOP: 129.43,69.68 129.43,71.03 129.66,71.26 132.45,71.26 132.88,71.69 132.88,72.45 132.74,72.59 132.51,72.59 132.32,72.79 132.32,75.58 132.36,75.62 130.21,75.62 129.78,75.18 129.78,73.89 129.69,73.8 128.77,73.8 128.48,74.09 128.48,75.25 129.47,76.24 133.22,76.24 133.46,76 133.99,76 133.99,79.72 133.98,79.73 133.98,83.32 131.28,86.03 131.28,86.65 131.44,86.82 136.47,86.82 137.75,85.53 137.75,73.06 134.37,69.68
+1.0V_VCCST_C on TOP (solid shape): 132.56,88.9 132.56,87.55 132.53,87.53 129.97,87.53 129.87,87.63 129.87,88.42 129.71,88.57 129.71,89.23 129.82,89.33 132.13,89.33
+1.0V_VCCSTG on TOP (solid shape): 145.33,80.03 145.33,78.51 144.57,77.75 144.27,77.75 144.27,78.2 143.83,78.2 143.83,77.75 142.54,77.75 142.29,78 142.29,79.78 143.05,80.54 144.83,80.54
+1.0V_VCCSTG on TOP (solid shape): 130.16,73.46 130.16,72.3 129.93,72.07 128.11,72.07 128.01,71.98 128.01,71.43 127.89,71.31 126.99,71.31 126.88,71.42 126.88,72.14 127.79,73.05 127.79,73.39 128.01,73.61 130.01,73.61
+1.0V_VCCSTG_C on TOP (solid shape): 145.11,77.32 145.11,74.7 144.98,74.57 142.67,74.57 142.29,74.95 142.29,77.24 142.57,77.52 144.9,77.52
+1.0VALWP on TOP (solid shape): 178.71,10.45 178.71,6.22 178.48,5.99 177.47,5.99 177.15,6.31 177.15,10.5 177.3,10.65 178.51,10.65
+1.0VALWP on BOTTOM (solid shape): outline of 87 points within 176.23,2.72 183.66,13.17
+1.0VS_VCCIO on TOP (solid shape): outline of 1264 points within 114.01,61.62 146.48,72.3
+1.0VS_VCCIO on BOTTOM (solid shape): 146.17,69.44 146.17,67.06 145.49,66.37 144.41,66.37 144.41,66.79 144.38,66.82 144.38,66.9 144.3,66.9 144.28,66.92 143.65,66.92 143.65,66.37 143.21,66.37 143.21,66.92 142.45,66.92 142.45,66.37 141.27,66.37 140.48,67.16 140.48,69.01 141.07,69.6 146.02,69.6
+1.0VS_VCCIO on VCC: 120.68,59.84 120.42,60.1 117.25,60.1 116.36,60.98 115.09,60.98 114.73,61.34 114.73,68.33 113.2,69.85 113.2,72.82 113.31,72.92 142.18,72.92 145.08,70.02 145.08,66.68 142.29,63.88 142.29,60.2 141.93,59.84
+1.2V_DDR_B+ on TOP (solid shape): 40.89,8.13 42.41,8.13 42.46,8.08 42.46,6.58 42.29,6.4 40.38,6.4 40.03,6.76 40.03,8.25 40.1,8.33 40.69,8.33
+1.2V_DDR_B+ on BOTTOM (solid shape): 40.84,8.2 42.34,8.2 43.49,7.05 46.19,7.05 46.22,7.02 46.22,6.57 46.21,6.56 44.6,6.56 43,4.95 42.44,4.95 42.44,5.48 41.92,5.48 41.92,4.95 41.64,4.95 41.64,5.48 41.12,5.48 41.12,4.95 40.76,4.95 40.56,5.16 40.56,6.25 40.43,6.37 40.41,6.37 40.03,6.76 40.03,8.28 40.08,8.33 40.71,8.33
+1.2V_DDRP on TOP (solid shape): 49.43,10.29 49.43,9.91 48.59,9.07 48.23,9.07 48.1,9.19 48.1,10.42 48.21,10.53 49.19,10.53
+1.2V_DDRP on TOP (solid shape): 65.17,7.92 65.17,7.31 65.16,7.3 65.16,5.45 64.84,5.13 59.48,5.13 59.46,5.15 58.55,5.15 58.47,5.23 58.47,7.52 59.2,8.25 64.84,8.25
+1.2V_DDRP on BOTTOM (solid shape): 49.42,10.29 49.42,9.91 47.95,8.43 47.32,8.43 47.27,8.48 47.27,9.02 47.27,9.02 47.27,9.15 47.75,9.63 47.75,10.5 47.77,10.53 49.19,10.53
