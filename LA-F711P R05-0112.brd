# Allegro board LA-F711P R05-0112.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
TBTA_DEBUG4: length 8.3
  BOTTOM w0.076: 29.98,94 29.97,93.99 29.97,93.93 29.96,93.93 29.96,92.99 30.31,92.65 30.37,92.65 30.79,92.23 30.79,92.17 31.27,91.69 31.27,91.23 31.62,90.88 31.62,90.53 31.38,90.29 UT5.K3
  BOTTOM w0.089: 29.98,94 29.98,95 v4(28.9,96.09) 28.62,96.37 28.62,97.04 RT90.2
TBTA_LSRX_R: length 3.7
  BOTTOM w0.076: RT88.2 31.42,92.92 31.77,92.56 v4(31.77,92.04) 31.77,91.41 32.12,91.06 32.12,90.43 UT5.K4
TBTA_LSTX_R: length 3.7
  BOTTOM w0.076: RT87.2 30.53,93.14 30.63,93.04 31.06,93.04 31.61,92.49 31.61,92.38 31.56,92.33 31.56,91.74 31.61,91.69 31.61,91.35 31.96,90.99 31.96,90.77 UT5.L4
TBTA_MRESET: length 2.7
  BOTTOM w0.076: UT5.E11 36.56,87.69 v1(36.8,87.45)
  BOTTOM w0.104: RT86.1 37.42,86.83 v1(36.8,87.45)
TBTA_RESET_N_EC_R: length 2.5
  BOTTOM w0.076: UT5.F11 36.84,88.19
  BOTTOM w0.102: 36.84,88.19 37.04,88.19
  BOTTOM w0.104: 37.04,88.19 37.38,87.85 RT110.2
TBTA_ROM_CLK_PD: length 3.3
  BOTTOM w0.076: UT5.A3 31.38,84.73
  BOTTOM w0.104: 31.38,84.73 31.38,84.5 v1(30.71,83.83) 30.13,83.25 RT54.1
TBTA_ROM_CLK_PD_R: length 52.5
  BOTTOM w0.102: RT54.2 30.13,80.69 30.99,79.83 33.6,79.83 34.87,78.56 34.87,75.01 37.08,72.8 40.75,72.8 44.83,76.87 44.83,78.77 48.32,82.26 48.32,84.24 48.43,84.35 48.43,89.02 46.55,90.9 UT6.6 46.55,93.85 47.9,95.2 50.64,95.2 v1(50.86,95.41) 51.69,96.24 51.69,98.86 52.22,99.39 JDB1.2
TBTA_ROM_CS#_PD: length 6.8
  BOTTOM w0.076: UT5.B3 31.14,85.94 31.14,84.96 30.91,84.73
  BOTTOM w0.102: v1(29.49,81) 29.49,82.27 RT57.1 28.86,83.27 28.99,83.4 29.49,83.4
  BOTTOM w0.104: 30.91,84.73 30.82,84.73 29.49,83.4
TBTA_ROM_CS#_PD_R: length 51.4
  BOTTOM w0.102: RT57.2 28.86,80.62 30.28,79.2 33.13,79.2 34.26,78.07 34.26,74.76 36.86,72.16 40.98,72.16 45.51,76.69 45.51,78.26 49.12,81.86 RT51.2 49.12,84.24 49.09,84.27 UT6.1 49.09,88.05 50.52,89.49 50.52,90.93 v1(50.89,91.29) 52.79,93.19 52.79,94.63 54.3,96.14 54.3,97.66 54.07,97.89 JDB1.5
TBTA_ROM_DI_PD: length 3.6
  BOTTOM w0.076: 31.87,84.73 31.87,85.24 32.12,85.49 32.12,85.95 UT5.B4
  BOTTOM w0.104: 31.87,84.73 31.87,84.03 v1(32.05,83.84) RT55.1
TBTA_ROM_DI_PD_R: length 53.8
  BOTTOM w0.102: 43.27,84.27 44.24,85.24 44.24,87.78 45.28,88.82 UT6.5 45.28,93.44 47.65,95.81 50.24,95.81 51.08,96.65 51.08,99.21 v1(51.48,99.61) 52.42,100.56 54.71,100.56 55.04,100.23 55.04,99.21 54.72,98.89 JDB1.3
  BOTTOM w0.104: 43.27,84.27 43.27,76.5 40.45,73.68 37.38,73.68 35.71,75.36 35.71,79.15 34.19,80.67 32.56,80.67 32.05,81.18 RT55.2
TBTA_ROM_DO_PD: length 5.4
  BOTTOM w0.076: 31.61,84.73 31.61,85.42 UT5.A4
  BOTTOM w0.102: 31.61,83.79 31.02,83.19 RT56.1 31.19,82.89 31.54,82.54 v1(31.54,80.97)
  BOTTOM w0.104: 31.61,84.73 31.61,83.79
TBTA_ROM_DO_PD_R: length 47.8
  IN2 w0.254: v2(51.61,93.8) 51.61,92.62 50.5,91.52 50.5,90.53 v2(47.81,87.83)
  BOTTOM w0.102: JDB1.4 52.54,98.39 52.29,98.15 v1(52.29,95.92) 52.29,94 52.1,93.8 v2(51.61,93.8) ; v2(47.81,87.83) 47.82,87.83 UT6.2 47.82,84.6 47.44,84.23 46.83,84.23 46.67,84.07 RT52.2
  BOTTOM w0.104: RT52.2 47.22,83.65 47.22,82.02 44.22,79.02 44.22,77.13 40.55,73.45 37.29,73.45 35.48,75.26 35.48,78.94 33.98,80.44 31.27,80.44 31.02,80.69 RT56.2
TBTA_ROM_HOLD#_PD: length 1.8
  BOTTOM w0.102: RT50.2 48.1,93.88 47.82,93.59 UT6.7
TBTA_ROM_WP#_PD: length 3.3
  BOTTOM w0.102: v1(44.31,83.65) RT53.2 46.55,84.79 UT6.3
TBTA_ROSC: length 8.1
  IN1 w0.099: v2(26.54,89.89) 26.59,89.84 27.56,89.84 28.39,89.01 v2(31.36,89.01)
  BOTTOM w0.076: v2(31.36,89.01) 31.36,88.99 31.06,88.69 UT5.G2
  BOTTOM w0.102: RT100.1 25.4,90.22 v1(25.51,90.33) 25.79,90.33 26.23,89.89 v2(26.54,89.89)
THERMTRIP1#: length 6.8
  TOP w0.104: RE301.1 v1(323.73,44.08) 323.73,43.29 324.28,42.75 324.28,41.58 324.28,41.27 324.28,41.27 324.28,40.72 323.58,40.02 322.99,40.02 UE1.B12
THERMTRIP2#: length 39.9
  TOP w0.102: v2(321.89,18.69) 322.5,18.69 323.11,18.08 323.11,15.75 322.37,15.01 322.37,13.87 323.21,13.03 CE36.1 323.64,12.6 v1(324.25,13.21) 324.4,13.36 RE69.2 324.4,14.3 324.39,14.31 QE4.1 ; UE1.H3 v2(315.72,34.35)
  IN1 w0.099: v2(321.89,18.69) 320.4,17.2 318.06,17.2 317.62,17.64 313.99,17.64 312.18,19.45 312.18,23.27 313.64,24.73 313.64,25.92 314.73,27.02 314.73,31.51 314.53,31.71 314.53,32.12 314.78,32.37 315.08,32.37 315.34,32.63 315.34,33.76 315.72,34.14 v2(315.72,34.35)
TOUCH_SCREEN_DET#: length 186
  IN2 w0.102: v2(177.03,86.38) 176.3,85.65 176.3,85.14 176.81,84.63 176.81,79.94 178.91,77.83 178.91,74.63 177.62,73.33 177.62,57.03 180.46,54.18 185.16,54.18 188.97,57.99 192.13,57.99 196.61,53.52 199.75,53.52 200.41,54.18 206.28,54.18 207.39,53.07 209.01,51.44 209.01,46.87 209.69,46.19 209.69,40.92 209.33,40.56 209.33,39.44 209.99,38.77 v2(209.99,38.41)
  BOTTOM w0.089: UH1.BC33 213.44,28.19 213.28,28.35 213.28,29.73 213.18,29.83 213.18,30.32 213.32,30.47 213.32,33.13 212.67,33.78 212.19,33.78 211.88,34.09 211.88,35.55 211.17,36.26 211.17,36.58 210.5,37.25 210.5,37.88 209.99,38.39 v2(209.99,38.41)
  BOTTOM w0.102: RV8.1 108.3,103.65 108.3,105.51 108.15,105.67 108.15,106.42 JEDP1.32 108.15,107.75 108.76,108.36 117.66,108.36 127.54,118.23 143.85,118.23 168.31,93.78 168.31,92.7 174.63,86.38 v1(175.84,86.38) v2(177.03,86.38)
TOUCH_SCREEN_PD#: length 179.5
  TOP w0.089: RH348.2 v1(207.72,14.76) 208.51,14.76 v2(209.29,13.98)
  IN2 w0.102: v2(169.36,86.64) 169.62,86.38 169.62,59.24 171.33,57.53 171.33,43.4 171.78,42.95 171.78,39.42 172.66,38.55 173.18,38.55 182.12,29.61 182.12,29.52 186.3,25.34 186.3,22.38 189.9,18.78 192.47,18.78 195.69,15.56 199.53,15.56 201.33,13.77 209.07,13.77 v2(209.29,13.98)
  BOTTOM w0.089: v2(209.29,13.98) 209.29,14.93 208.21,16.01 208.21,17.19 207.57,17.82 207.57,19.76 207.56,19.77 207.56,20.17 207.57,20.19 207.57,20.24 207.72,20.39 207.72,20.84 207.75,20.87 207.75,21.4 207.84,21.48 207.84,21.61 207.88,21.65 UH1.AM45
  BOTTOM w0.102: v2(169.36,86.64) 161.87,94.13 161.87,97.84 142.6,117.11 129.02,117.11 124.63,112.72 124.63,109.8 123.12,108.28 122.59,108.28 121.65,107.34 JEDP1.5
TOUCHPAD_INTR#: length 263.3
  TOP w0.102: v2(213.76,9.1) 214.17,8.69 214.17,7.38 213.4,6.61 213.4,3.98 v2(214.99,2.39) ; v2(240.76,18.86) 240.76,18.69 238.99,16.93 v1(238.99,16.9) 238.99,12.64 239.99,11.65 239.99,9.05 v2(240,9.04) ; RE318.2 310.1,35.71 304.69,35.71 303.53,36.88 303.53,38.05 305.23,39.75 305.23,42 304.73,42.49 303.17,42.49 302.7,42.02 302.7,41.69 302.48,41.48 300.81,41.48 299.14,39.81 299.14,39 297.53,37.39 297.53,36.4 294.33,33.2 294.33,27.18 293.03,25.88 293.03,24.92 289.78,21.66 289.78,18.17 282.95,11.34 282.92,11.34 v2(282.89,11.37)
  IN1 w0.099: v2(142.12,8.22) 142.12,8.24 142.72,8.84 147.39,8.84 148.4,9.85 162.27,9.85 162.46,10.04 170.73,10.04 171.65,10.96 177.11,10.96 178.42,12.28 180.77,12.28 184.1,8.95 188.15,8.95 192.71,4.39 193.29,4.39 194,3.68 194,2.39 194.31,2.09 200.55,2.09 201.08,2.62 202.93,2.62 204.13,1.42 214.02,1.42 v2(214.99,2.39)
  IN2 w0.102: v2(282.89,11.37) 282.89,11.34 282.93,11.3 282.93,11.08 282.27,10.43 279.7,10.43 277.8,12.33 260.31,12.33 257.17,9.19 240.16,9.19 v2(240,9.04) 235.88,9.04 235.44,8.6 228.35,8.6 227.76,8.01 216.07,8.01 214.98,9.1 v2(213.76,9.1)
  IN3 w0.102: v2(224.62,26.08) 224.62,25.86 225.14,25.34 225.69,25.34 227.35,23.67 230.39,23.67 231.95,22.12 233.14,22.12 236.38,18.87 240.64,18.87 240.64,18.86 v2(240.76,18.86)
  BOTTOM w0.089: 223.61,26.28 223.38,26.28 222.77,26.89 222.17,26.89 220.52,28.54 219.85,28.54 219.7,28.4 214.96,28.4 UH1.BF32
  BOTTOM w0.102: 223.61,26.28 224.42,26.28 v2(224.62,26.08) 224.62,25.86 225.57,24.91 RH402.2 ; JKBTP1.5 142.02,8.32 142.12,8.22 v2(142.12,8.22)
TP_LAN_JTAG_TCK: length 3.4
  TOP w0.102: v1(316.13,82.87) RL2.1 316.72,83.91 317.3,84.5 UL1.35
TP_LAN_JTAG_TDI: length 4.6
  TOP w0.102: T88.1 313.9,85.92 316.56,85.92 316.79,85.7 UL1.32
TP_LAN_JTAG_TDO: length 1.2
  TOP w0.102: UL1.34 317.52,84.9 317.38,84.76 T89.1
TP_LAN_JTAG_TMS: length 2.1
  TOP w0.102: RL1.1 316.25,85.3 UL1.33
TP_SKL_E30: length 9.4
  TOP w0.102: T284.1 121.15,74.19 120.75,74.6 118.29,74.6 v2(118.06,74.37)
  BOTTOM w0.076: UC1.E30 118.38,74.73 118.06,74.41 v2(118.06,74.37)
TP_SKL_F30: length 18.1
  TOP w0.102: T285.1 133.36,76.4 130.15,76.4 129.99,76.57 123.48,76.57 122.81,77.24 119.81,77.24 118.79,76.22 118.47,76.22 v2(117.43,75.19)
  BOTTOM w0.076: v2(117.43,75.19) 117.43,75.14 117.73,74.85 UC1.F30
TPM_GPIO0: length 2.1
  TOP w0.102: UZ12.29 250.88,30.5 v1(250.9,30.48) 251,30.38 RZ112.2
TPM_GPIO4: length 4
  TOP w0.102: T283.1 243.55,32.11 244.01,31.65 244.01,30.1 244.12,30 UZ12.13
TPM_LPM#: length 3
  TOP w0.102: UZ12.3 247.94,33.45 247.6,33.79 247.07,33.79 v1(246.91,33.95) 246.91,34.38 RZ363.2
TPM_PIRQ#: length 31.4
  TOP w0.089: v2(223.03,29.46) 222.52,29.98 221.3,29.98 221.15,30.12 219.66,30.12 RC560.1 RC561.1
  TOP w0.102: UZ12.18 245.94,27.22 245.35,26.63 243.51,26.63 v1(243.44,26.69) 242.79,27.34 241.99,27.34 RZ69.2 240.91,26.89 v2(240.88,26.86)
  IN2 w0.102: v2(240.88,26.86) 240.88,26.78 239.43,25.32 229.82,25.32 227.59,27.55 224.94,27.55 v2(223.03,29.46)
TPM_PIRQ#_B20: length 9.9
  TOP w0.089: RC561.2 218.51,31.25 217.99,31.78 217.31,31.78 RH339.2
  TOP w0.102: v2(210.67,30.66) 211.44,31.43 v1(213.41,31.43) 213.5,31.34 214.25,31.34 214.51,31.08 216.61,31.08 RH339.2
  BOTTOM w0.089: UH1.AU26 v2(210.67,30.66)
TPM_PIRQ#_R: length 13.3
  TOP w0.089: v2(223,30.05) 222.8,30.24 221.29,30.24 221.23,30.3 220.14,30.3 219.68,30.76 RC560.2
  BOTTOM w0.089: UH1.BD29 214.07,29.97 214.26,30.15 215.05,30.15 215.23,30.33 217.81,30.33 v1(217.86,30.28) 218.76,30.28 218.82,30.33 221.96,30.33 222.11,30.19 222.85,30.19 v2(223,30.05)
TPM_TYPE: length 5.7
  TOP w0.102: v2(211.25,27.36) 211.1,27.2 209.78,27.2 209.61,27.37 v1(209.29,27.37) 207.58,27.37 207.27,27.06 RH379.1
  BOTTOM w0.089: v2(211.25,27.36) 211.25,27.9 211.49,28.13 UH1.AW32
TSENSE_2PH: length 18.6
  TOP w0.203: PU1700.25 53.84,80.39 52.99,79.54 v1(52.99,79.3) 52.99,78.81 v2(53.04,78.76)
  BOTTOM w0.203: v2(53.04,78.76) PC1731.1
  BOTTOM w0.254: PR1768.1 50.84,69.32 53.41,71.88 53.41,74.92 51.61,76.73 50.51,76.73 50.08,77.15 50.08,78.51 50.34,78.76 52.12,78.76 52.45,78.44 PC1731.1
TSENSE_4PH: length 35.8
  TOP w0.102: v2(53.03,85.17) v1(53.03,85.7)
  TOP w0.203: PU1700.14 53.83,84.79 53.45,85.17 v2(53.03,85.17)
  TOP w0.254: PR1767.1 76.89,94.63 v2(76.37,95.15)
  IN3 w0.254: v2(53.03,85.17) 54.72,86.85 54.72,87.98 53.8,88.9 53.8,92.35 55.88,94.43 75.66,94.43 v2(76.37,95.15)
  BOTTOM w0.203: PC1729.1 53.31,84.89 v2(53.03,85.17)
TYPEC_CON_SEL1: length 27.9
  IN2 w0.102: v2(232.53,32.67) 232.53,31.88 230.91,30.26 227.13,30.26 226.69,29.82 224.45,29.82 223.59,30.68 221.77,30.68 220.59,31.86 219.99,31.86 219.16,32.69 216.05,32.69 215.42,33.32 212.56,33.32 212.19,32.95 v2(212.19,32.94)
  BOTTOM w0.089: UH1.BA24 v2(212.19,32.94)
  BOTTOM w0.102: RH555.1 RH556.1 230.23,32.71 230.81,32.14 v3(232.3,32.14) 232.53,32.37 v2(232.53,32.67)
TYPEC_CON_SEL2: length 28.1
  IN2 w0.102: v2(231.79,34) 231.45,34 228.75,31.3 227.36,31.3 226.95,31.71 224.29,31.71 222.73,33.27 220.54,33.27 220.43,33.38 218.52,33.38 218.07,33.83 210.34,33.83 209.47,32.96 v2(209.47,32.94)
  BOTTOM w0.089: UH1.AP24 209.14,32.62 v2(209.47,32.94)
  BOTTOM w0.102: RH553.1 RH554.1 230.56,33.59 230.72,33.75 v1(231.26,33.75) 231.54,33.75 v2(231.79,34)
TYPEC_ID: length 7.7
  TOP w0.102: RE343.1 308.71,40.28 CE62.1 309.73,40.28 310.16,39.85 310.16,39.85 310.54,39.47 310.54,39.38 310.78,39.14 311.04,39.14 311.31,38.88 311.31,38.61 312.58,37.34 312.78,37.13 313.21,37.13
  TOP w0.104: UE1.F2 314.12,36.75 313.59,36.75 313.21,37.13
UART_MISO: length 10.2
  BOTTOM w0.076: UT5.F2 30.8,88.19 30.56,87.95 30.28,87.95 29.22,87.95 29.07,87.8
  BOTTOM w0.102: v1(22.16,88.34) RT82.1 23.41,87.68 23.82,87.27 RT83.2 24.48,87.42 24.82,87.76 25.85,87.76 26.13,87.48 28.75,87.48 29.07,87.8
UART_MOSI: length 7.1
  BOTTOM w0.076: 29.07,87.01 29.54,87.48 30.25,87.48 30.28,87.45 30.64,87.45 UT5.E2
  BOTTOM w0.102: RT83.1 RT81.1 ; 29.07,87.01 29.03,86.97
  BOTTOM w0.104: 29.03,86.97 28.55,86.49 26.42,86.49 v1(26.35,86.41) 26.2,86.26 RT81.1
UG1_ISL88738: length 3.7
  IN1 w0.762: 13.9,33.07 14.91,33.07 16.32,31.66
  BOTTOM w0.102: v1(17.33,31.7) v2(17.33,31.01)
  vias: v2(12.7,33.11) v2(13.28,33.12) v2(16.57,31.03)
UG2_ISL88738: length 30.2
  IN3 w0.762: 20.46,17.55 20.16,17.26 20.16,13.92 18.79,12.55 12.89,12.55 10.85,14.58 10.85,21.06 9.09,22.82 9.09,29.03 9.44,29.39
  vias: v1(22.26,17.45) v2(9.79,30.71) v2(9.8,30.12) v2(21.74,17.45) v2(22.07,16.95)
UIM_CLK: length 32.6
  IN1 w0.099: v2(331.83,58.82) 332.49,58.82 333.25,58.06 341.24,58.06 343.61,55.69 345.1,55.69 346.72,54.08 346.72,53.94 v2(346.67,53.89)
  BOTTOM w0.102: JNGFF2.32 332.4,59.4 v2(331.83,58.82) ; JSIM1.3 356.08,47.69 351.87,47.69 351.09,48.48 CZ38.1 350.42,48.61 350,49.03 349.18,49.03 348.99,49.22 348.99,49.63 346.67,51.96 v2(346.67,53.89)
UIM_DATA: length 49.8
  IN1 w0.099: v2(331.89,58.24) 332.39,58.24 333.05,57.58 341.04,57.58 343.41,55.21 344.76,55.21 v2(346.08,53.89)
  BOTTOM w0.102: v2(331.89,58.24) 331.93,58.24 332.9,59.21 JNGFF2.34 ; JSIM1.7 369.56,47.69 358.12,47.69 357.32,46.89 352.17,46.89 351.47,46.19 CZ39.1 350.42,47.18 RZ335.2 350.45,47.53 349.98,48 347.21,48 346.08,49.12 v2(346.08,53.89)
UIM_RESET: length 31.6
  IN1 w0.099: v2(347.28,53.87) 347.28,54.38 345.49,56.17 343.81,56.17 341.44,58.54 333.45,58.54 332.45,59.54 v2(331.83,59.54)
  BOTTOM w0.102: v2(331.83,59.54) 331.9,59.6 JNGFF2.30 ; v2(347.28,53.87) 347.29,53.86 347.29,52.02 348.23,51.08 349.74,51.08 350.42,50.4 CZ40.1 350.42,49.92 350.94,49.4 354.03,49.4 354.86,50.22 JSIM1.2
UPD1_SMBCLK: length 414.6
  TOP w0.107: v2(303.82,56.07) 303.82,56.12 304.84,56.12 306.87,54.09 v1(307.64,54.09) 308.8,54.09 313.17,49.72 314.97,49.72 316.35,48.34 316.35,43.02 315.95,42.62 RE303.1 315.64,42.49 315.65,42.49 315.65,39.08 UE1.C3 ; RT58.1 17.85,83.24 18.48,83.24 QT1.1 18.7,83.33 v2(18.28,83.74)
  IN3 w0.102: v2(18.28,83.74) 18.93,83.74 19.15,83.96 19.15,84.47 19.04,84.57 19.04,95.77 17.82,96.98 17.82,100.42 18.82,101.42 18.82,103 17.68,104.13 17.68,106.36 17.3,106.75 17.3,109.65 17.66,110.02 17.66,110.95 16.01,112.6 16.01,114.84 16.36,115.19 16.36,115.64 17.08,116.36 18.16,116.36 19.98,118.17 20.88,118.17 22.9,120.19 30.97,120.19 40.47,110.69 49.87,110.69 50.12,110.44 56.82,110.44 60.7,114.32 60.7,123.1 62.04,124.43 84.74,124.43 84.91,124.27 89.92,124.27 91.2,125.55 113.05,125.55 113.64,124.97 120.16,124.97 120.52,124.61 124.78,124.61 130.7,118.69 136.6,118.69 197.22,58.07 211.66,58.07 212.78,56.96 218.24,56.96 218.39,56.81 223.3,56.81 234.25,45.86 235.18,45.86 240.07,40.97 243.98,40.97 244.76,40.2 249.9,40.2 250.75,39.34 253.69,39.34 254.24,38.79 262.25,38.79 275.11,42.66 276.64,44.18 280.9,44.18 291.92,55.2 291.92,56.74 294.61,59.44 301.01,59.44 301.41,59.44 303.77,57.08 303.77,56.12 v2(303.82,56.07)
UPD1_SMBCLK_Q: length 42.9
  TOP w0.107: v2(27.25,94.59) 27.86,95.2 RT375.2 ; v2(32.3,84.35) 31.92,83.97 RT67.1 ; RT58.2 17.94,84.44 18.42,84.92 QT1.6 18.7,84.29 18.72,84.28 v2(18.72,84.23)
  IN1 w0.099: v2(27.25,94.59) 26.77,95.08 25.78,95.08 25.43,95.43 23.25,95.43 22.91,95.09 22.63,94.81 22.63,94.33 20.49,92.19 20.49,86.2 18.72,84.42 v2(18.72,84.23) 18.72,84.02 19,83.74 19,83.18 20.37,81.81 28.11,81.81 28.57,82.27 30.77,82.27 31.54,83.04 31.54,84.27 31.67,84.39 32.26,84.39 v2(32.3,84.35)
  BOTTOM w0.076: v2(32.3,84.35) 32.69,84.73 32.69,85.24 32.62,85.3 32.62,85.95 UT5.B5
  BOTTOM w0.107: v2(27.25,94.59) 27.8,95.15 28.54,95.15 RT92.1
UPD1_SMBDAT: length 412.7
  TOP w0.107: v2(303.11,56.15) 303.57,56.61 v1(304.39,56.61) 305.04,56.61 307.07,54.58 309,54.58 313.37,50.21 315.17,50.21 316.83,48.55 316.83,43.31 317.29,42.85 RE302.1 316.53,41.99 316.53,39.95 316.13,39.55 UE1.B4 ; v2(20.11,84.25) 20,84.37 QT1.4 20.74,84.92 RT59.1
  IN3 w0.102: v2(303.11,56.15) 303.29,56.32 303.29,56.88 301.21,58.95 294.81,58.95 292.4,56.54 292.4,55 281.1,43.7 276.84,43.7 275.37,42.23 262.32,38.3 254.04,38.3 253.49,38.86 250.55,38.86 249.7,39.71 244.56,39.71 243.78,40.49 239.87,40.49 234.98,45.37 234.05,45.37 223.1,56.32 218.19,56.32 218.04,56.47 212.58,56.47 211.46,57.59 197.02,57.59 136.4,118.21 130.5,118.21 124.58,124.13 120.32,124.13 119.96,124.48 113.44,124.48 112.85,125.07 91.4,125.07 90.12,123.79 84.71,123.79 84.54,123.95 62.24,123.95 61.18,122.9 61.18,114.12 57.02,109.96 49.92,109.96 49.67,110.21 40.27,110.21 30.77,119.71 23.1,119.71 21.08,117.69 20.18,117.69 18.36,115.87 17.28,115.87 16.84,115.44 16.84,114.99 16.49,114.64 16.49,112.8 18.14,111.15 18.14,109.82 17.78,109.45 17.78,106.95 18.17,106.56 18.17,104.33 19.3,103.2 19.3,101.22 18.3,100.22 18.3,97.18 19.52,95.97 19.52,84.84 v2(20.11,84.25)
UPD1_SMBDAT_Q: length 38.3
  TOP w0.107: 19.97,83.63 20,83.6 QT1.3 ; 19.97,83.63 RT59.2 ; 19.97,83.63 v2(19.91,83.69) ; v2(26.49,94.59) 26.49,94.9 26.97,95.38 RT376.2 ; RT66.1 32.18,84.86 v2(32.3,84.99)
  IN1 w0.099: v2(26.49,94.59) 25.43,94.59 25.08,94.95 23.45,94.95 23.11,94.61 23.11,94.13 20.97,92 20.97,86 19.53,84.56 19.53,84.1 19.91,83.72 v2(19.91,83.69) 19.73,83.51 19.73,83.13 20.57,82.29 27.92,82.29 28.37,82.75 30.58,82.75 31.06,83.24 31.06,84.47 31.47,84.87 32.19,84.87 v2(32.3,84.99)
  BOTTOM w0.076: UT5.A5 32.38,85.07 v2(32.3,84.99)
  BOTTOM w0.107: v2(26.49,94.59) 26.99,94.09 27.44,94.09 27.93,94.58 RT93.1
UPD1_SMBINT#: length 405.6
  TOP w0.102: v2(323.97,56.49) v1(324.54,56.49)
  TOP w0.104: UE1.F10 v2(321.32,36.75)
  IN3 w0.102: v2(323.97,56.49) 324.46,56 324.46,51.39 325.14,50.71 325.14,49.06 323.41,47.33 323.41,42.57 321.74,40.89 321.74,37.17 v2(321.32,36.75)
  BOTTOM w0.102: v2(321.32,36.75) 321.72,37.15 323.48,37.15 323.76,37.43 RE91.1 ; v2(323.97,56.49) 323.88,56.4 320.59,56.4 320.2,56.79 311.83,56.79 311.26,56.22 305.53,56.22 303.52,54.22 298.25,54.22 297.02,52.98 290.18,52.98 283.43,46.23 283.43,40.44 280.09,37.1 272.53,37.1 272.48,37.06 269.83,37.06 269.21,36.44 250.54,36.44 248.67,38.31 244.13,38.31 241.93,40.51 240.74,40.51 238.28,42.97 236.26,42.97 221.77,57.45 216.81,57.45 211.4,62.86 211.4,75.27 196.68,89.99 175.39,89.99 162.8,102.58 162.27,102.58 145,119.85 126.98,119.85 124.73,117.6 114.28,117.6 111.03,114.35 108.04,114.35 107.48,113.79 92.47,113.79 87.21,108.53 78.86,108.53 76.88,106.55 73.56,106.55 70.89,103.88 69.48,103.88 69.28,103.68 65.85,103.68 62.86,100.69 58.2,100.69 57.61,101.27 55.19,101.27 54.71,100.79 52.11,100.79 50.82,99.5 50.82,96.88 50.03,96.09 47.42,96.09 42.57,91.24 42.57,88.69 42.85,88.42 42.85,76.41 40.46,74.02 37.44,74.02 35.94,75.51 35.94,79.24 ; 33.83,81.69 RT60.1
  BOTTOM w0.104: 35.94,79.24 33.83,81.36 33.83,81.69
UPD1_SMBUS_ALERT#: length 6.1
  BOTTOM w0.076: 34.13,84.72 34.13,86.39 33.96,86.56 33.57,86.56 33.46,86.45 33.26,86.45 33,86.19 UT5.B6
  BOTTOM w0.102: RT68.1 RT60.2
  BOTTOM w0.104: RT60.2 33.83,83.34 33.7,83.47 v1(33.7,83.97) 34.13,84.4 34.13,84.72
UPD2_SMBCLK: length 13.7
  TOP w0.107: v2(325.08,44.59) 325.23,44.44 325.23,43.31 325.34,43.2 325.86,43.2 325.87,43.2 326.23,43.2 RPE12.3 ; UE1.D7 v2(318.12,38.35)
  IN1 w0.099: v2(325.08,44.59) 325.08,44.53 324.21,43.66 322.82,43.66 322.27,43.11 321.88,43.11 321.87,43.11 321.68,43.11 320.54,41.96 319.84,41.96 318.5,40.62 318.5,38.99 318.12,38.61 v2(318.12,38.35)
UPD2_SMBDAT: length 15.4
  TOP w0.107: v2(324.44,44.59) 324.5,44.53 324.5,44.45 324.74,44.21 v1(324.74,43.15) 324.74,43.11 325.13,42.72 325.66,42.72 325.66,42.71 RPE12.4 ; UE1.E7 318.52,37.2 v2(318.12,37.6)
  IN1 w0.099: v2(318.12,37.6) 317.7,38.02 317.7,40.16 317.7,40.5 318.08,40.88 318.08,40.88 319.64,42.44 320.34,42.44 321.48,43.59 321.99,43.59 321.99,43.59 322.07,43.59 322.63,44.14 324.01,44.14 324.44,44.57 v2(324.44,44.59)
UPD2_SMBINT#: length 7.2
  TOP w0.104: UE1.F5 v2(316.52,36.75)
  BOTTOM w0.102: v2(316.52,36.75) 316.91,37.14 v1(316.91,37.9) 316.91,39.78 316.54,40.15 316.54,41.69 316.78,41.93 316.99,41.93 RE92.1
USB2_COMP: length 4.9
  BOTTOM w0.089: 194.26,44.67 195.11,43.82 195.11,43.33 195.08,43.3 195.08,42.74 UH1.F4
  BOTTOM w0.102: RH193.1 194.26,46.18 194.26,44.67
USB2_ID: length 226.5
  TOP w0.102: v2(170.68,96.09) v1(167.69,93.09) 167.69,79.09 187.16,59.62 v2(187.16,59.34)
  IN3 w0.102: v2(189.98,50.84) 188.03,52.78 188.03,58.34 187.16,59.22 v2(187.16,59.34)
  BOTTOM w0.089: 191.28,49.53 193.54,49.53 194.8,48.27 194.85,48.27 195.14,47.98 195.14,47.56 194.55,46.96 RH365.1 194.51,46.77 194.51,44.67 195.3,43.88 195.3,43.25 195.27,43.22 195.27,42.81 UH1.G3
  BOTTOM w0.102: v2(189.98,50.84) 191.28,49.53 ; RT74.2 42.12,88.89 42.12,91.43 47.28,96.6 49.86,96.6 50.19,96.93 50.19,99.54 51.02,100.38 51.02,101.68 51.76,102.41 52.85,102.41 53.36,101.9 56.18,101.9 56.82,102.54 59.11,102.54 60.08,101.57 63.1,101.57 65.66,104.13 69.09,104.13 69.3,104.34 70.7,104.34 73.37,107.01 76.69,107.01 78.95,109.27 87.3,109.27 92.62,114.59 107.16,114.59 107.49,114.92 110.55,114.92 113.83,118.21 124.5,118.21 126.94,120.64 145.38,120.64 155.38,110.64 155.95,110.64 170.5,96.09 v2(170.68,96.09)
USB2_VBUSSENSE: length 7.1
  BOTTOM w0.089: UH1.F3 194.77,43.3 194.92,43.46 194.92,43.69 193.91,44.71 193.91,45.98 193.56,46.32 193.23,46.32 RH364.1 193.19,47.28 193.19,48.15 192.91,48.42 v1(192.91,48.73)
USB3_DP2_1_MRX_C_DTX_N5: length 8
  BOTTOM w0.089: JUSBC1.B10 6.52,111.88 6.68,111.71 6.85,111.71 7.11,111.45 7.11,110.95 7.54,110.51 8.05,110.51 9.64,108.93 11.64,108.93 RT419.1 11.93,108.82 12.22,108.82 CT633.2
USB3_DP2_1_MRX_C_DTX_P5: length 8
  BOTTOM w0.089: CT632.2 12.26,108.55 11.88,108.55 RT418.1 11.47,108.66 9.52,108.66 7.94,110.25 7.43,110.25 6.84,110.83 6.84,111.34 6.74,111.45 6.64,111.45 6.57,111.38 JUSBC1.B11
USB3_DP2_1_MRX_DTX_N5: length 18.8
  IN1 w0.089: v2(16.11,108.23) 16.18,108.29 17.1,108.29 17.94,109.13 17.94,111.35 18.37,111.78 19.43,111.78 19.91,112.26 19.91,116.69 20.29,117.07 21.05,117.07 21.78,116.34 21.78,115.96 v2(21.83,115.91)
  BOTTOM w0.089: v2(16.11,108.23) 15.29,108.23 14.68,108.84 13.85,108.84 DT6.2 13.44,108.86 13.1,108.86 CT633.1 ; v2(21.83,115.91) 21.79,115.87 21.79,115.37 21.7,115.28 UT9.3
USB3_DP2_1_MRX_DTX_P5: length 18.8
  IN1 w0.089: v2(21.24,115.91) 21.45,116.12 21.45,116.2 20.91,116.74 20.43,116.74 20.24,116.55 20.24,112.13 19.56,111.45 18.51,111.45 18.27,111.21 18.27,108.99 17.24,107.96 16.54,107.96 16.43,107.85 16.43,107.72 16.35,107.64 v2(16.11,107.64)
  BOTTOM w0.089: CT632.1 13.15,108.59 13.4,108.59 DT5.2 13.85,108.57 14.56,108.57 15.18,107.96 15.8,107.96 v2(16.11,107.64) ; v2(21.24,115.91) 21.52,115.64 21.52,115.49 21.35,115.32 UT9.2
USB3_DP2_1_MTX_C_DRX_N5: length 4.3
  BOTTOM w0.089: JUSBC1.A3 8.25,112.12 8.38,111.99 8.61,111.99 9.44,111.15 11.33,111.15 11.48,111.29 CT96.2
USB3_DP2_1_MTX_C_DRX_P5: length 4.3
  BOTTOM w0.089: CT95.2 11.27,110.88 9.33,110.88 8.5,111.72 8.29,111.72 8.19,111.62 JUSBC1.A2
USB3_DP2_1_MTX_DRX_N5: length 9.6
  BOTTOM w0.089: UT9.42 19.85,110.55 19.8,110.5 19.72,110.5 19.65,110.56 19.02,110.56 18.91,110.45 v4(18.52,110.45) 18.13,110.45 18.02,110.56 17.3,110.56 16.53,109.79 14.61,109.79 14.08,110.32 14.08,110.56 13.55,111.09 12.94,111.09 DT14.2 12.59,111.1 12.26,111.1 CT96.1
USB3_DP2_1_MTX_DRX_P5: length 9.6
  BOTTOM w0.089: CT95.1 12.23,110.83 12.57,110.83 DT13.2 12.77,110.64 12.96,110.82 13.44,110.82 13.81,110.45 13.81,110.21 14.5,109.52 16.64,109.52 17.11,109.99 17.12,109.99 17.13,110 v4(17.13,110.01) 17.41,110.29 17.91,110.29 18.01,110.18 19.02,110.18 19.13,110.29 19.54,110.29 19.64,110.2 UT9.41
USB3_DP2_2_MRX_C_DTX_N5: length 4.9
  BOTTOM w0.089: JUSBC1.A10 8.15,115.63 8.31,115.79 8.56,115.79 8.89,116.12 10.79,116.12 10.97,116.29 11.43,116.29 RT416.1 11.76,116.25 CT630.2
USB3_DP2_2_MRX_C_DTX_P5: length 4.8
  BOTTOM w0.089: JUSBC1.A11 8.21,116.13 8.28,116.05 8.44,116.05 8.78,116.39 10.68,116.39 10.86,116.56 11.48,116.56 RT417.1 12.08,116.7 CT631.2
USB3_DP2_2_MRX_DTX_N5: length 16
  IN1 w0.089: v2(15.22,116.46) 15.49,116.72 16.54,116.72 17.33,117.51 19.07,117.51 19.37,117.82 21.18,117.82 21.48,118.12 22.92,118.12 24.31,116.73 24.31,116.42 v2(24,116.1)
  BOTTOM w0.089: v2(15.22,116.46) 14.96,116.72 13.71,116.72 DT17.2 13,116.46 CT630.1 ; UT9.8 23.45,115.14 23.53,115.22 23.53,115.42 23.81,115.7 24.07,115.7 24.08,115.71 24.17,115.71 24.28,115.81 24.28,115.95 24.13,116.1 v2(24,116.1)
USB3_DP2_2_MRX_DTX_P5: length 16
  IN1 w0.089: v2(24.65,116.1) 24.65,116.87 23.06,118.45 21.35,118.45 21.04,118.15 19.24,118.15 18.93,117.85 17.19,117.85 16.4,117.06 v2(15.22,117.06)
  BOTTOM w0.089: CT631.1 13.17,116.82 DT18.2 13.55,116.99 15.16,116.99 v2(15.22,117.06) ; UT9.9 23.8,115.31 23.93,115.43 24.19,115.43 24.19,115.44 24.28,115.44 24.55,115.7 24.55,116 v2(24.65,116.1)
USB3_DP2_2_MTX_C_DRX_N5: length 7.2
  BOTTOM w0.089: CT98.2 11.32,118.07 11.03,118.07 10.45,117.48 8.6,117.48 8.1,116.98 7.23,116.98 7.1,116.84 7.1,115.76 6.85,115.52 6.67,115.52 6.52,115.37 JUSBC1.B3
USB3_DP2_2_MTX_C_DRX_P5: length 7.2
  BOTTOM w0.089: JUSBC1.B2 6.44,115.87 6.52,115.79 6.74,115.79 6.83,115.87 6.83,116.95 7.12,117.25 7.98,117.25 8.49,117.75 10.33,117.75 10.92,118.34 11.35,118.34 CT97.2
USB3_DP2_2_MTX_DRX_N5: length 13.8
  BOTTOM w0.089: UT9.44 19.68,111.25 19.65,111.27 18.34,111.27 17.94,111.67 17.94,113.77 17.23,114.48 16.98,114.48 16.33,115.13 v4(16.33,116.23) 16.33,116.56 16.08,116.81 16.08,117.62 15.64,118.06 12.93,118.06 DT10.2 12.54,118.06 12.22,118.06 CT98.1
USB3_DP2_2_MTX_DRX_P5: length 13.8
  BOTTOM w0.089: CT97.1 12.22,118.33 12.54,118.33 DT9.2 12.93,118.33 15.76,118.33 16.35,117.73 16.35,116.92 16.6,116.68 16.6,115.24 17.09,114.75 17.34,114.75 18.21,113.88 v4(18.21,112.04) 18.21,111.78 18.45,111.54 19.62,111.54 19.68,111.6 UT9.45
USB3_PRX_C_MTX_N5: length 4.7
  BOTTOM w0.112: CT112.2 26.78,117 26.32,117 25.83,116.51 25.83,114.99 25.5,114.66 25.5,114.19 25.36,114.05 UT9.11
USB3_PRX_C_MTX_P5: length 4.8
  BOTTOM w0.112: CT111.2 26.7,116.8 26.4,116.8 26.03,116.43 26.03,114.91 25.7,114.58 25.7,114.1 25.29,113.7 UT9.12
USB3_PRX_DTX_N1: length 265.4
  IN1 w0.099: v2(191.48,38.63) 191.48,38.39 191.48,38.28 191.48,37.86 191.57,37.77 191.57,36.67 192.15,36.08 192.15,34.82 191.85,34.52 191.85,32.26 191.18,31.59 191.18,30.29 188.63,27.74 188.63,21.13 197.05,12.71 211.94,12.71 213.59,11.06 221.44,11.06 222.76,9.74 222.77,9.74 222.83,9.68 236.34,9.68 236.41,9.74 236.52,9.74 236.52,9.74 242.7,9.74 245.54,12.58 278.63,12.58 279.45,13.41 280.85,13.41 280.99,13.27 295.81,13.27 296.78,14.23 303.47,14.23 304.18,13.53 310.03,13.53 312.34,11.22 315.81,11.22 316.35,11.76 321.18,11.76 321.71,11.23 322.93,11.23 323.46,11.76 323.46,12.23 324.31,13.08 325.81,13.08 328.53,15.8 328.53,18.22 331.24,20.93 331.73,20.93 334.47,23.67 334.47,24.07 336.06,25.65 336.06,28.31 335.13,29.24 335.13,32.8 333.82,34.11 333.82,36.97 333.32,37.47 333.32,37.83 332.93,38.22 332.93,45.98 334.81,47.85 338.04,47.85 338.18,47.99 344.69,47.99 345.29,48.58 346.89,48.58 347.08,48.38 354.03,48.38 355.36,49.71 355.36,54.77 350.69,59.45 350.69,70.23 350.85,70.39 v2(350.92,70.47)
  BOTTOM w0.089: UH1.D11 194.17,38.77 193.82,38.77 193.69,38.64 193.33,38.64 192.84,39.13 192.36,39.13 192.25,39.24 191.86,39.24 191.62,39 191.63,38.79 v2(191.48,38.63)
  BOTTOM w0.097: v2(350.92,70.47) 350.88,70.43 350.88,70.01 350.98,69.91 351.98,69.91 352.27,70.19 DI4.9 DI4.1 354.85,70.19 355.01,70.04 355.15,70.04 356.74,71.63 357.3,71.63 357.94,72.27 358.17,72.27 358.65,72.75 JUSB1.5
USB3_PRX_DTX_N2: length 251.4
  TOP w0.097: UZ29.18 361.48,47.13 361.55,47.05 361.55,46.53 361.81,46.28 362.23,46.28 v2(362.31,46.21)
  IN1 w0.099: v2(190.42,40.51) 190.42,39.58 189.63,38.79 189.63,30.54 186.96,27.86 186.96,20.72 196.75,10.93 210.13,10.93 211.5,9.57 214.35,9.57 214.85,9.07 218.95,9.07 220.09,7.93 228.09,7.93 229.06,6.96 232.55,6.96 233.37,7.77 238.3,7.77 238.78,7.29 243.75,7.29 246.11,9.65 264.28,9.65 265.18,10.55 266.75,10.55 267.55,11.35 280.11,11.35 280.24,11.49 281.71,11.49 282.21,11.99 296.35,11.99 297.36,13.01 302.96,13.01 303.67,12.3 308.22,12.3 308.45,12.06 308.45,11.42 309.97,9.91 324.66,9.91 330.64,15.89 330.64,17.88 333.07,20.31 333.59,20.31 336.1,22.81 336.1,23 337.96,24.87 337.96,33.49 337.02,34.44 335.47,34.44 335.07,34.83 335.07,37.46 334.55,37.98 334.55,38.34 334.28,38.61 334.28,45.58 335.32,46.62 341.3,46.62 341.36,46.68 353.64,46.68 357.2,43.12 361.42,43.12 361.76,43.46 361.76,46.22 361.85,46.32 362.19,46.32 v2(362.31,46.21)
  BOTTOM w0.089: UH1.B9 193.3,39.66 192.58,39.66 192.44,39.8 191.15,39.8 190.95,39.99 190.95,40.14 190.59,40.51 v2(190.42,40.51)
USB3_PRX_DTX_N3: length 230.9
  TOP w0.097: JUSB2.5 13.55,87.44 15.05,88.94 15.74,88.94 17.35,90.55 17.68,90.55 17.84,90.39 DI1.9 DI1.1 19.59,90.39 19.77,90.56 19.79,90.54 23.08,90.54 23.24,90.7 23.76,90.7 v2(23.95,90.52)
  IN3 w0.102: v2(23.95,90.52) 24.13,90.7 25.13,90.7 27.42,92.99 33.32,92.99 34.33,93.99 34.33,96.3 37.58,99.55 38.25,99.55 41.48,102.78 59.59,102.78 61.85,105.03 66.6,105.03 66.99,105.42 72.16,105.42 78.84,112.1 92.5,112.1 92.97,112.57 100.22,112.57 102.37,110.42 113.27,110.42 118,105.69 118,104.52 119.08,103.44 121.01,103.44 123.11,101.35 124.35,101.35 128.91,96.78 131.09,96.78 138.46,89.42 144.85,89.42 175.17,59.1 175.17,47.52 177.4,45.29 179.48,45.29 181.85,42.92 182.74,42.92 186.1,39.56 189.33,39.56 v2(189.5,39.38)
  BOTTOM w0.089: UH1.B10 193.6,38.91 193.66,38.97 193.66,39.09 193.59,39.16 193.18,39.16 193.03,39.31 192.43,39.31 192.29,39.45 191.71,39.45 191.57,39.31 190.64,39.31 190.36,39.59 189.7,39.59 v2(189.5,39.38)
USB3_PRX_DTX_N4: length 172
  IN3 w0.089: v2(197.05,36.89) 197.01,36.73 197.08,36.62 197.31,36.6 197.34,36.6 197.62,36.88 197.62,37.32 198.01,37.71 198.28,37.71 198.48,37.91 198.48,38.42 198.19,38.71 198.19,39.28 197.87,39.6 197.87,39.89 196.84,40.93 196.52,40.93 196.51,40.92 196.36,40.92 196.32,40.96 196.32,40.96 196.31,40.96 196.3,40.97
  IN3 w0.102: 196.3,40.97 196.02,41.25 196.02,42 195.91,42.11 195.89,42.11 194.71,43.29 193.76,43.29 193.17,42.7 186.9,42.7 184.25,45.35 184.25,45.67 179.77,50.15 179.77,52.71 180.46,53.41 180.46,54.67 179.01,56.13 179.01,65.01 164.34,79.68 162.15,79.68 149.03,92.81 140.46,92.81 122.75,110.51 121.23,110.51 114.42,117.32 86.58,117.32 86.09,117.82 86.09,118.25 85.99,118.35 v2(85.76,118.35)
  BOTTOM w0.094: UH1.K16 197.36,36.62 197.1,36.89 v2(197.05,36.89)
  BOTTOM w0.097: JUSB3.5 82.81,127.75 83,127.56 83,127.06 83.71,126.35 83.71,125.59 84.39,124.92 84.39,124.44 84.23,124.28 DI6.1 DI6.9 84.23,122.42 84.39,122.27 84.39,122.09 84.81,121.67 85.1,121.67 86.04,120.72 86.04,118.63 v2(85.76,118.35)
USB3_PRX_DTX_P1: length 265.4
  IN1 w0.099: v2(192.06,38.65) 191.69,38.25 191.69,37.94 191.78,37.86 191.78,36.75 192.36,36.17 192.36,34.73 192.06,34.43 192.06,32.17 191.39,31.5 191.39,30.21 188.84,27.65 188.84,21.22 197.14,12.92 212.03,12.92 213.68,11.27 221.53,11.27 222.84,9.95 222.86,9.95 222.92,9.89 236.26,9.89 236.32,9.95 236.43,9.95 236.43,9.95 242.61,9.95 245.45,12.79 278.54,12.79 279.36,13.62 280.93,13.62 281.07,13.48 295.73,13.48 296.69,14.45 303.56,14.45 304.27,13.74 310.11,13.74 312.42,11.43 315.72,11.43 316.26,11.97 321.27,11.97 321.8,11.44 322.84,11.44 323.25,11.84 323.25,12.32 324.22,13.29 325.72,13.29 328.32,15.89 328.32,18.31 331.15,21.14 331.64,21.14 334.26,23.76 334.26,24.15 335.85,25.74 335.85,28.22 334.92,29.15 334.92,32.72 333.61,34.03 333.61,36.88 333.11,37.38 333.11,37.75 332.72,38.13 332.72,46.06 334.72,48.06 337.95,48.06 338.09,48.2 344.61,48.2 345.2,48.79 346.97,48.79 347.17,48.59 353.94,48.59 355.15,49.8 355.15,54.69 350.48,59.36 350.48,70.34 350.38,70.44 v2(350.31,70.44)
  BOTTOM w0.089: v2(192.06,38.65) 191.95,38.65 191.81,38.77 191.8,38.93 191.93,39.06 192.18,39.06 192.28,38.95 192.77,38.95 193.26,38.46 193.69,38.46 193.83,38.32 193.88,38.32 193.98,38.22 194.1,38.22 194.18,38.3 194.18,38.5 194.12,38.56 193.98,38.56 UH1.C11
  BOTTOM w0.097: JUSB1.6 358.65,71.7 358.26,72.08 358.02,72.08 357.37,71.44 356.82,71.44 355.23,69.85 355.01,69.85 354.85,69.69 DI4.2 DI4.8 353.06,69.69 352.96,69.8 352.96,69.91 352.86,70.01 352.34,70.01 352.06,69.73 350.9,69.73 350.7,69.93 350.7,70.12 350.38,70.44 v2(350.31,70.44)
USB3_PRX_DTX_P2: length 251.3
  TOP w0.097: v2(362.31,46.79) 361.98,46.46 361.89,46.46 361.74,46.61 361.74,46.9 361.98,47.13 UZ29.19
  IN1 w0.099: v2(191.13,40.55) 191.03,40.55 190.63,40.15 190.63,39.49 189.84,38.7 189.84,30.45 187.17,27.77 187.17,20.81 196.84,11.14 210.22,11.14 211.58,9.78 214.44,9.78 214.94,9.28 219.04,9.28 220.18,8.14 228.18,8.14 229.15,7.17 232.46,7.17 233.28,7.98 238.39,7.98 238.87,7.5 243.66,7.5 246.02,9.86 264.2,9.86 265.1,10.76 266.67,10.76 267.47,11.56 280.02,11.56 280.16,11.7 281.62,11.7 282.12,12.2 296.26,12.2 297.27,13.22 303.05,13.22 303.76,12.51 308.3,12.51 308.66,12.15 308.66,11.51 310.05,10.12 324.57,10.12 330.43,15.98 330.43,17.97 332.98,20.52 333.5,20.52 335.89,22.9 335.89,23.09 337.75,24.96 337.75,33.4 336.93,34.23 335.38,34.23 334.86,34.75 334.86,37.37 334.34,37.89 334.34,38.26 334.07,38.52 334.07,45.67 335.23,46.83 341.21,46.83 341.27,46.89 353.73,46.89 357.29,43.33 361.33,43.33 361.54,43.55 361.54,46.31 361.77,46.53 362.05,46.53 v2(362.31,46.79)
  BOTTOM w0.089: UH1.C9 193.67,39.79 193.42,39.79 193.38,39.84 192.65,39.84 192.51,39.98 191.22,39.98 191.13,40.07 v2(191.13,40.55)
USB3_PRX_DTX_P3: length 231
  TOP w0.097: v2(23.95,91.1) 23.74,90.89 23.16,90.89 23,90.73 19.87,90.73 19.71,90.89 DI1.2 DI1.8 17.84,90.89 17.68,90.73 17.27,90.73 15.67,89.12 14.98,89.12 14.37,88.52 13.74,88.52 13.55,88.71 JUSB2.6
  IN3 w0.102: v2(189.5,39.97) 189.31,39.78 186.19,39.78 182.83,43.14 181.94,43.14 179.57,45.51 177.49,45.51 175.39,47.61 175.39,59.19 144.94,89.64 138.55,89.64 131.18,97 129,97 124.44,101.56 123.2,101.56 121.1,103.66 119.17,103.66 118.22,104.61 118.22,105.78 113.36,110.64 102.46,110.64 100.31,112.79 92.88,112.79 92.41,112.32 78.75,112.32 72.07,105.64 66.9,105.64 66.51,105.25 61.76,105.25 59.5,103 41.39,103 38.16,99.77 37.49,99.77 34.11,96.39 34.11,94.09 33.23,93.21 27.33,93.21 25.04,90.92 24.13,90.92 v2(23.95,91.1)
  BOTTOM w0.089: UH1.C10 193.96,39.07 193.69,39.34 193.25,39.34 193.11,39.48 192.5,39.48 192.36,39.62 191.63,39.62 191.49,39.48 190.71,39.48 190.43,39.76 189.7,39.76 v2(189.5,39.97)
USB3_PRX_DTX_P4: length 171.9
  IN3 w0.089: 196.44,41.11 196.91,41.11 198.05,39.97 198.05,39.67 198.37,39.36 198.37,38.79 198.66,38.49 198.66,37.83 198.36,37.53 198.08,37.53 197.8,37.25 197.8,36.8 197.41,36.42 197.3,36.42 197.15,36.44 v2(196.92,36.29)
  IN3 w0.102: 196.44,41.11 196.21,41.33 196.21,42.08 196.04,42.25 196.04,42.27 194.8,43.51 193.67,43.51 193.08,42.92 186.99,42.92 184.47,45.44 184.47,45.76 179.99,50.24 179.99,52.62 180.68,53.32 180.68,54.76 179.23,56.22 179.23,65.1 164.43,79.9 162.24,79.9 149.12,93.02 140.55,93.02 122.84,110.73 121.32,110.73 114.51,117.54 86.68,117.54 86.31,117.91 86.31,118.16 v2(86.5,118.35)
  BOTTOM w0.089: UH1.J15 196.63,36.56 196.9,36.29 v2(196.92,36.29)
  BOTTOM w0.097: JUSB3.6 83.34,127.75 83.19,127.6 83.19,127.14 83.9,126.43 83.9,125.67 84.57,125 84.57,124.44 84.73,124.28 DI6.2 DI6.8 84.73,122.42 84.57,122.27 84.57,122.17 84.89,121.85 85.17,121.85 86.23,120.8 86.23,118.63 v2(86.5,118.35)
USB3_PRX_MTX_N5: length 230.3
  IN3 w0.089: v2(196,37.69) 196.33,37.69 196.42,37.78 196.82,37.78 196.94,37.67 197.2,37.67 197.48,37.94 197.48,38.25 196.24,39.49 196.24,40.12 196.02,40.34 196.02,40.65 195.83,40.84 194.93,40.84 194.64,40.56 193.15,40.56 193.15,40.56
  IN3 w0.102: 193.15,40.56 191.61,42.1 186.65,42.1 183.65,45.1 183.65,45.42 179.17,49.9 179.17,54.86 178.37,55.66 178.37,64.68 163.96,79.09 161.9,79.09 148.78,92.21 140,92.21 132.13,100.08 131.68,100.08 126.56,105.19 125.24,105.19 115.41,115.02 102.28,115.02 100.88,116.43 78.7,116.43 77.52,115.24 75.41,115.24 68.74,108.57 64.16,108.57 63.48,107.89 61.12,107.89 59.47,106.23 30.49,106.23 30.02,106.7 30.02,109.7 30.65,110.34 30.65,111.28 30.53,111.4 30.53,113.55 30.02,114.06 30.02,115.2 29.47,115.75 28.52,115.75 28.18,116.09 28.18,116.73 28.35,116.9 28.98,116.9 v2(29,116.93)
  BOTTOM w0.089: v2(196,37.69) 196,37.82 196.17,38 196.47,38 196.59,37.88 UH1.J13
  BOTTOM w0.112: v2(29,116.93) 28.95,116.88 28.43,116.88 CT112.1
USB3_PRX_MTX_P5: length 230.3
  IN3 w0.089: v2(196.48,37.31) 196.4,37.39 196.4,37.52 196.49,37.6 196.75,37.6 196.87,37.49 197.28,37.49 197.66,37.87 197.66,38.32 196.41,39.57 196.41,40.19 196.2,40.41 196.2,40.73 195.91,41.02 194.85,41.02 194.57,40.74 193.24,40.74
  IN3 w0.102: 193.24,40.74 191.69,42.3 186.73,42.3 183.84,45.18 183.84,45.5 179.36,49.98 179.36,54.94 178.56,55.74 178.56,64.76 164.04,79.28 161.98,79.28 148.86,92.4 140.07,92.4 132.21,100.27 131.76,100.27 126.64,105.38 125.32,105.38 115.49,115.21 102.36,115.21 100.96,116.62 78.62,116.62 77.44,115.43 75.34,115.43 68.66,108.76 64.08,108.76 63.4,108.08 61.04,108.08 59.39,106.43 30.57,106.43 30.21,106.78 30.21,109.63 30.84,110.26 30.84,111.36 30.72,111.48 30.72,113.63 30.21,114.13 30.21,115.28 29.55,115.94 28.6,115.94 28.37,116.17 28.37,116.65 28.43,116.71 28.64,116.71 29,116.35 v2(29,116.34)
  BOTTOM w0.089: v2(196.48,37.31) 196.65,37.31 196.88,37.53 UH1.K13
  BOTTOM w0.112: v2(29,116.34) 28.91,116.34 28.58,116.67 28.25,116.67 CT111.1
USB3_PTX_C_DRX_N1: length 11.1
  BOTTOM w0.097: CI13.1 351.14,67.22 351.46,67.22 351.91,67.67 351.91,68.27 352.18,68.54 353.02,68.54 353.17,68.69 DI4.7 DI4.4 354.77,68.69 354.93,68.54 355.22,68.54 355.48,68.28 v4(355.48,67.75) 355.48,67.33 355.8,67 357.31,67 357.84,66.47 358.36,66.47 358.65,66.76 JUSB1.8
USB3_PTX_C_DRX_N2: length 2.1
  TOP w0.097: CZ151.2 360.8,46.08 360.81,46.38 360.63,46.56 360.63,46.75 360.48,46.91 UZ29.16
USB3_PTX_C_DRX_N3: length 10.5
  TOP w0.097: JUSB2.8 13.55,93.72 13.91,94.08 14.17,94.08 14.53,93.72 14.72,93.72 16.39,92.05 v4(16.98,92.05) 17.68,92.05 17.84,91.89 DI1.7 DI1.4 19.62,91.89 19.78,92.05 20.05,92.05 20.27,92.26 20.61,92.26 20.65,92.22 21.23,92.22 21.27,92.26 21.78,92.26 CI5.1
USB3_PTX_C_DRX_N4: length 10.5
  BOTTOM w0.097: CI27.1 86.35,121.63 v4(86.09,121.89) 85.89,122.09 85.89,122.31 85.73,122.47 DI6.7 DI6.4 85.73,124.28 85.89,124.44 85.89,124.61 86.08,124.8 86.57,124.8 86.61,124.84 87.2,124.84 87.23,124.8 87.65,124.8 88.46,125.62 88.46,126.58 89.02,127.13 89.02,127.43 88.69,127.75 JUSB3.8
USB3_PTX_C_DRX_P1: length 11.1
  BOTTOM w0.097: CI16.1 350.94,67.03 351.58,67.03 352.1,67.55 352.1,68.2 352.22,68.32 v4(352.48,68.32) 352.97,68.32 353.1,68.19 DI4.6 DI4.5 354.74,68.19 354.9,68.35 355.14,68.35 355.29,68.2 355.29,68.09 355.25,68.05 355.25,67.46 355.29,67.42 355.29,67.25 355.72,66.82 357.23,66.82 358.65,65.4 JUSB1.9
USB3_PTX_C_DRX_P2: length 2.1
  TOP w0.097: UZ29.17 360.98,46.91 360.82,46.75 360.82,46.63 361,46.45 360.98,46 360.98,46 CZ150.2
USB3_PTX_C_DRX_P3: length 10.5
  TOP w0.097: CI4.1 21.77,92.45 v4(20.94,92.45) 20.19,92.45 19.98,92.23 19.78,92.23 19.62,92.39 DI1.5 DI1.6 17.84,92.39 17.68,92.23 17.32,92.23 17.28,92.27 16.69,92.27 16.65,92.23 16.47,92.23 14.8,93.9 14.61,93.9 14.24,94.27 14.01,94.27 13.55,94.73 JUSB2.9
USB3_PTX_C_DRX_P4: length 10.4
  BOTTOM w0.097: CI28.1 86.7,121.82 86.48,121.82 86.25,122.04 86.09,122.21 86.09,122.34 86.23,122.49 DI6.6 DI6.5 86.23,124.28 86.07,124.44 86.07,124.53 86.16,124.62 v4(86.9,124.62) 87.73,124.62 88.65,125.54 88.65,126.51 89.2,127.06 89.2,127.47 89.48,127.75 JUSB3.9
USB3_PTX_C_MRX_N5: length 4.3
  BOTTOM w0.112: UT9.14 24.88,112.99 25.89,112.99 26.02,113.12 26.02,113.25 26.45,113.68 26.45,114.82 26.78,115.15 27.02,115.15 CT114.2
USB3_PTX_C_MRX_P5: length 4.4
  BOTTOM w0.112: CT113.2 27.1,114.95 26.86,114.95 26.65,114.74 26.65,113.6 26.22,113.16 26.22,113.04 25.97,112.79 25.45,112.79 25.3,112.65 UT9.15
USB3_PTX_DRX_N1: length 251.3
  IN1 w0.099: v2(195.83,39.92) 195.83,39.93 195.59,40.02 195.32,40.11 195.31,40.11 195.29,40.1 195.24,40.08 195.22,40.06 195.22,39.91 195.88,39.25 195.88,38.15 195.59,37.86 195.59,36.98 192.68,34.06 192.68,30.62 189.45,27.4 189.45,21.48 196.8,14.13 205.39,14.13 205.99,13.53 212.28,13.53 213.93,11.89 221.88,11.89 223.26,10.51 236.02,10.51 236.08,10.57 242.35,10.57 245.19,13.41 278.28,13.41 279.11,14.23 281.24,14.23 281.38,14.09 295.47,14.09 296.89,15.51 303.36,15.51 304.52,14.35 310.37,14.35 312.14,12.59 322.59,12.59 323.91,13.9 325.39,13.9 327.63,16.14 327.63,18.67 331.19,22.23 331.86,22.23 333.64,24.01 333.64,24.41 334.3,25.07 334.3,32.46 332.49,34.27 332.49,37.49 331.88,38.1 331.88,46.09 334.46,48.67 336.78,48.67 337.21,49.11 340.22,49.11 340.34,49.22 342.95,49.22 343.49,49.77 346.08,49.77 346.15,49.84 348.57,49.84 349.2,49.21 353.69,49.21 354.54,50.06 354.54,54.43 348.15,60.82 348.15,66.97 348.37,67.19 348.51,67.19 348.61,67.3 348.66,67.3 348.85,67.48 348.85,67.62 v2(348.81,67.67)
  BOTTOM w0.089: UH1.F9 195.56,40.06 195.69,40.06 v2(195.83,39.92)
  BOTTOM w0.097: v2(348.81,67.67) 348.81,67.62 349.06,67.37 349.5,67.37 CI13.2
USB3_PTX_DRX_N2: length 244.6
  TOP w0.097: CZ151.1 360.71,44.47 360.71,43.98 360.69,43.96 v2(360.53,43.8)
  IN1 w0.099: v2(360.53,43.8) 360.53,44.53 360.46,44.61 356.73,44.61 353.97,47.37 338.44,47.37 338.3,47.23 335.06,47.23 333.58,45.75 333.58,38.44 333.93,38.09 333.93,37.73 334.43,37.23 334.43,34.37 335.78,33.02 335.78,29.72 336.67,28.83 336.67,25.4 335.08,23.81 335.08,22.67 333.34,20.92 332.81,20.92 330.03,18.14 330.03,16.43 326.01,12.41 325.34,12.41 323.46,10.53 310.22,10.53 309.07,11.68 309.07,12.32 308.47,12.91 303.92,12.91 303.22,13.62 297.03,13.62 296.02,12.61 281.88,12.61 281.38,12.11 279.99,12.11 279.85,11.97 267.3,11.97 266.5,11.17 264.93,11.17 264.03,10.27 245.83,10.27 243.75,8.18 239.11,8.18 238.9,8.39 231.59,8.39 231.28,8.7 220.82,8.7 219.07,10.44 212.64,10.44 212.28,10.8 211.71,10.8 211.37,11.14 211.37,11.71 211.06,12.03 196.77,12.03 187.57,21.23 187.57,27.57 190.25,30.24 190.25,38.54 191.55,39.83 191.75,39.83 192.22,40.31 192.22,41.74 192.84,42.36 194.06,42.36 194.17,42.44 v2(194.3,42.78)
  BOTTOM w0.089: UH1.C3 v2(194.3,42.78)
USB3_PTX_DRX_N3: length 222.3
  TOP w0.097: v2(24.57,92.03) 24.57,92.03 24.36,92.24 23.37,92.24 CI5.2
  IN3 w0.102: v2(24.57,92.03) 24.75,92.22 25.75,92.22 27.16,93.62 33.07,93.62 33.69,94.25 33.69,96.65 41.37,104.33 60.26,104.33 61.59,105.66 66.34,105.66 66.73,106.05 71.9,106.05 78.58,112.73 90.9,112.73 91.55,113.38 100.87,113.38 102.97,111.29 114.08,111.29 119.17,106.2 120.09,106.2 120.65,105.64 120.65,105.03 122.62,103.06 124.73,103.06 129.89,97.89 131,97.89 138.66,90.23 144.92,90.23 175.79,59.36 175.79,49.86 182.11,43.55 182.99,43.55 185.71,40.83 189.21,40.83 189.92,40.12 189.92,39.3 191.3,37.92 193.62,37.92 194.36,38.66 194.82,38.66 194.95,38.49 v2(194.93,38.34)
  BOTTOM w0.089: v2(194.93,38.34) 194.92,38.36 194.92,38.71 195.21,39 195.47,39 195.59,38.88 195.59,38.76 195.49,38.65 UH1.F11
USB3_PTX_DRX_N4: length 158.1
  IN3 w0.102: v2(181.69,49.89) 181.52,50.05 181.52,50.28 180.7,51.1 180.7,51.98 181.48,52.75 181.48,55.37 179.85,57 179.85,65.45 164.78,80.53 162.5,80.53 149.05,93.98 140.81,93.98 123.3,111.5 121.63,111.5 114.49,118.63 92.73,118.63 92.27,119.1 89.23,119.1 89.01,118.88 89.01,118.56 v2(88.81,118.36)
  BOTTOM w0.089: 188.13,37.69 188.15,37.67 188.15,37.66 189.07,36.74 191.19,36.74 191.87,37.42 192.78,37.42 193.09,37.11 193.6,37.11 193.64,37.15 193.64,37.34 193.55,37.43 193.45,37.43 UH1.B14
  BOTTOM w0.097: 188.13,37.69 187.31,38.51 187.31,39.31 v4(184.41,42.21) 182.51,44.12 182.51,47.07 181.19,48.38 181.19,49.59 181.31,49.7 181.31,49.78 181.41,49.89 v2(181.69,49.89) ; v2(88.81,118.36) 89.22,118.77 89.22,119.79 89.11,119.9 89.11,122.16 89.05,122.22 88.81,122.22 88.32,121.72 CI27.2
USB3_PTX_DRX_P1: length 251.4
  IN1 w0.099: v2(348.81,66.92) 348.75,66.98 348.46,66.98 348.36,66.88 348.36,60.91 354.75,54.52 354.75,49.97 353.78,49 349.11,49 348.48,49.63 346.24,49.63 346.17,49.56 343.58,49.56 343.03,49.01 340.43,49.01 340.31,48.89 337.3,48.89 336.87,48.46 334.55,48.46 332.09,46 332.09,38.19 332.7,37.58 332.7,34.36 334.51,32.55 334.51,24.98 333.86,24.32 333.86,23.93 331.95,22.02 331.28,22.02 327.84,18.58 327.84,16.06 325.48,13.69 323.99,13.69 322.68,12.37 312.05,12.37 310.28,14.14 304.43,14.14 303.27,15.3 296.98,15.3 295.56,13.88 281.29,13.88 281.15,14.02 279.2,14.02 278.37,13.2 245.28,13.2 242.44,10.36 236.17,10.36 236.11,10.3 223.17,10.3 221.79,11.67 213.84,11.67 212.19,13.32 205.91,13.32 205.31,13.92 196.71,13.92 189.24,21.39 189.24,27.48 192.46,30.71 192.46,34.15 195.38,37.06 195.38,37.95 195.67,38.23 195.67,39.17 195,39.83 195,40.14 195.13,40.27 v2(195.59,40.45)
  BOTTOM w0.089: UH1.F7 195.23,40.22 195.37,40.22 v2(195.59,40.45)
  BOTTOM w0.097: v2(348.81,66.92) 349.08,67.19 349.34,67.19 CI16.2
USB3_PTX_DRX_P2: length 244.6
  TOP w0.097: CZ150.1 361.21,44.75 360.89,44.44 360.89,44.03 v2(361.11,43.8)
  IN1 w0.099: v2(361.11,43.8) 360.74,44.18 360.74,44.62 360.54,44.82 356.82,44.82 354.06,47.58 338.35,47.58 338.21,47.44 334.97,47.44 333.37,45.84 333.37,38.35 333.72,38 333.72,37.64 334.22,37.14 334.22,34.28 335.57,32.93 335.57,29.63 336.46,28.74 336.46,25.49 334.87,23.9 334.87,22.76 333.25,21.13 332.72,21.13 329.82,18.22 329.82,16.51 325.92,12.62 325.26,12.62 323.38,10.74 310.31,10.74 309.28,11.77 309.28,12.4 308.56,13.12 304.01,13.12 303.31,13.83 296.95,13.83 295.93,12.82 281.79,12.82 281.29,12.32 279.9,12.32 279.76,12.18 267.21,12.18 266.41,11.38 264.84,11.38 263.94,10.48 245.75,10.48 243.66,8.39 239.2,8.39 238.99,8.6 231.68,8.6 231.37,8.91 220.9,8.91 219.16,10.66 212.73,10.66 212.37,11.01 211.8,11.01 211.59,11.22 211.59,11.8 211.15,12.24 196.86,12.24 187.78,21.31 187.78,27.48 190.46,30.15 190.46,38.45 191.63,39.62 191.83,39.62 192.43,40.22 192.43,41.66 192.93,42.15 194.12,42.15 194.24,42.23 v2(194.62,42.09)
  BOTTOM w0.089: UH1.D4 v2(194.62,42.09)
USB3_PTX_DRX_P3: length 222.3
  TOP w0.097: v2(24.57,92.62) 24.37,92.42 23.42,92.42 CI4.2
  IN3 w0.102: v2(24.57,92.62) 24.75,92.44 25.66,92.44 27.07,93.84 32.98,93.84 33.47,94.34 33.47,96.74 41.28,104.55 60.17,104.55 61.5,105.88 66.25,105.88 66.64,106.27 71.81,106.27 78.49,112.95 90.81,112.95 91.46,113.6 100.96,113.6 103.06,111.51 114.17,111.51 119.26,106.42 120.18,106.42 120.86,105.73 120.86,105.12 122.71,103.28 124.82,103.28 129.98,98.11 131.09,98.11 138.75,90.45 145.01,90.45 176.01,59.45 176.01,49.95 182.2,43.76 183.09,43.76 185.8,41.05 189.31,41.05 190.14,40.21 190.14,39.39 191.39,38.14 193.33,38.14 193.35,38.11 193.54,38.11 194.28,38.85 194.51,38.85 v2(194.95,39.29)
  BOTTOM w0.094: UH1.G12 195.93,38.27 195.84,38.36 195.84,38.89 195.55,39.18 195.06,39.18 v2(194.95,39.29)
USB3_PTX_DRX_P4: length 158.1
  IN3 w0.102: v2(89.68,118.38) 89.68,118.34 89.61,118.26 89.3,118.26 89.23,118.34 89.23,118.79 89.32,118.88 92.18,118.88 92.64,118.41 114.4,118.41 121.54,111.28 123.21,111.28 140.72,93.76 148.96,93.76 162.41,80.31 164.69,80.31 179.64,65.36 179.64,56.91 181.26,55.28 181.26,52.84 180.49,52.07 180.49,51.01 181.3,50.19 181.3,50.08 181.1,49.89 v2(180.92,49.89)
  BOTTOM w0.089: 188,37.55 188.02,37.54 188.02,37.54 189,36.56 191.28,36.56 191.95,37.23 192.72,37.23 193.02,36.93 193.67,36.93 193.81,37.07 193.81,37.29 UH1.C14
  BOTTOM w0.097: 188,37.55 187.12,38.43 187.12,39.24 184.51,41.85 184.46,41.85 184.04,42.26 184.04,42.32 182.32,44.04 182.32,46.99 181.01,48.3 181.01,49.8 v2(180.92,49.89) ; CI28.2 88.44,122.4 89.12,122.4 89.29,122.23 89.29,119.97 89.4,119.86 89.4,118.66 v2(89.68,118.38)
USB3_PTX_MRX_N5: length 225.6
  IN3 w0.102: v2(29,115.34) 28.88,115.21 27.42,115.21 26.86,114.66 26.86,108.1 29.35,105.61 59.73,105.61 61.33,107.21 65.16,107.21 65.89,107.94 69,107.94 72.94,111.89 75.36,111.89 78.59,115.11 101.3,115.11 102.07,114.35 115.02,114.35 124.93,104.45 126.14,104.45 131.14,99.44 131.88,99.44 139.74,91.58 148.52,91.58 161.64,78.46 163.59,78.46 177.29,64.76 177.29,53.33 178.55,52.07 178.55,49.64 181.25,46.94 181.25,46.62 v2(181.09,46.46)
  BOTTOM w0.089: UH1.C15 193.72,36.57 193.72,36.46 193.7,36.44 193.7,36.39 193.54,36.23 192.25,36.23 192.14,36.13 188.34,36.13 188,36.47
  BOTTOM w0.112: v2(29,115.34) 28.81,115.15 28.7,115.15 CT114.1 ; 188,36.47 185.13,39.34 185.13,40.28 181.3,44.1 181.3,46.25 v2(181.09,46.46)
USB3_PTX_MRX_P5: length 225.5
  IN3 w0.102: v2(181.89,46.48) 181.65,46.48 181.44,46.7 181.44,47.01 178.74,49.72 178.74,52.15 177.48,53.4 177.48,64.84 163.67,78.65 161.72,78.65 148.6,91.77 139.82,91.77 131.96,99.63 131.22,99.63 126.22,104.64 125,104.64 115.1,114.54 102.14,114.54 101.38,115.31 78.51,115.31 75.28,112.08 72.86,112.08 68.92,108.13 65.81,108.13 65.08,107.4 61.26,107.4 59.65,105.8 29.43,105.8 27.05,108.18 27.05,114.58 27.49,115.02 28.74,115.02 v2(29,114.76)
  BOTTOM w0.089: 188,36.75 188.44,36.31 192.07,36.31 192.17,36.41 193.47,36.41 193.52,36.46 193.52,36.51 193.54,36.53 193.54,36.66 193.49,36.71 UH1.B15
  BOTTOM w0.112: v2(29,114.76) 28.81,114.94 28.62,114.94 CT113.1 ; v2(181.89,46.48) 181.89,46.66 181.73,46.82 181.63,46.82 181.5,46.7 181.5,44.18 185.33,40.36 185.33,39.42 188,36.75
USB20_N1: length 183.3
  TOP w0.097: UI3.2 340,66.81 340.16,66.65 340.16,64.67 340.26,64.57 340.26,64.32 v2(340.04,64.11)
  IN1 w0.099: v2(304.84,54.63) 305.07,54.4 306.6,54.4 309.18,56.98 313.1,56.98 315.19,54.89 319.77,54.89 320.59,55.71 320.59,58.65 321.81,59.87 323.66,59.87 324.07,60.29 331.47,60.29 333.63,62.45 339.15,62.45 340.31,63.61 340.31,63.84 v2(340.04,64.11)
  IN3 w0.102: v2(196.82,50.48) 196.82,50.27 196.92,50.17 197.19,50.17 197.46,50.43 197.46,51.68 199.44,53.66 216.87,53.66 217.72,52.81 221.45,52.81 224.63,49.63 226.69,49.63 233.18,43.14 233.94,43.14 238.75,38.34 242.89,38.34 243.67,37.57 248.79,37.57 249.66,36.7 252.24,36.7 252.78,36.16 266.59,36.16 267.21,36.78 268.46,36.78 269.37,37.69 271.94,37.69 272.78,38.53 277.72,38.53 278.96,39.78 292.15,39.78 294.65,42.28 294.65,45.9 303.14,54.39 304.59,54.39 v2(304.84,54.63)
  BOTTOM w0.089: UH1.J3 196.8,42.63 196.72,42.71 196.72,43.09 196.8,43.16 196.8,44.6 196.14,45.26 196.14,50.02 196.39,50.27 196.61,50.27 v2(196.82,50.48)
USB20_N2: length 266.8
  IN3 w0.102: v2(198.28,37.11) 198.49,36.9 198.49,36.71 198.8,36.4 199.52,36.4 199.87,36.74 199.87,39.75 200.32,40.19 200.32,41.92 194.97,47.27 193.95,47.27 192.87,48.34 192.87,56.75 185.81,63.8 184.73,63.8 166.13,82.4 163.27,82.4 149.13,96.54 149.13,99.4 142.31,106.22 137.75,106.22 124.62,119.35 93.19,119.35 92.81,119.74 84.63,119.74 82.14,117.25 77.69,117.25 77.05,116.6 75.62,116.6 68.4,109.38 60.8,109.38 59.13,107.71 42.29,107.71 42.17,107.84 37.1,107.84 36.56,108.38 35.18,108.38 31.35,112.21 31.35,114.1 31.06,114.39 31.06,116.29 29.7,117.65 27.12,117.65 25.74,116.27 25.74,115.12 24.47,113.85 24.47,108.52 23.76,107.82 23.76,107.24 22.88,106.35 22.88,104.07 21.86,103.05 21.86,102.18 22,102.04 22,90.31 23.83,88.48 23.83,87.43 23.73,87.32 v2(22.93,87.32)
  BOTTOM w0.094: v2(198.28,37.11) UH1.N13
  BOTTOM w0.097: LI3.1 22.2,87.32 22.44,87.08 22.69,87.08 v2(22.93,87.32)
