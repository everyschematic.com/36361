# Allegro board LA-F711P R05-0112.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
HDMI_OB: length 26.3
  TOP w0.508: RV11.2 103.07,121.87 RV12.2 v2(103.93,122.73) ; RV13.2 RV16.2 v2(107.51,122.71) ; v2(113.94,122.48) 113.43,122.99 RV15.2 ; QV4.1 98.93,122.2 99.23,121.89 RV10.2 100.4,122.78 v1(99.98,123.21) v2(99.39,123.8) ; RV14.2 110.26,123.01 v2(110,122.76) 110,122.07 RV17.2
  IN3 w0.508: v2(99.39,123.8) 99.82,123.37 102.64,123.37 103.27,122.73 v2(103.93,122.73) 107.49,122.73 ; v2(113.94,122.48) 113.51,122.91 110.16,122.91 v2(110,122.76) 109.98,122.73 107.49,122.73 ; 107.49,122.73 v2(107.51,122.71)
HDMI_TX_N0: length 2.7
  TOP w0.097: RV30.1 112.54,124.32 LV9.2 112.39,123.85 112.21,123.67 112.21,123.32 RV15.1 112.22,122.71 112.22,122.52 CV36.2
HDMI_TX_N1: length 2.9
  TOP w0.097: CV34.2 105.36,121.35 105.36,121.52 RV13.1 105.36,122.22 105.36,122.99 LV6.2 105.69,123.31 RV27.1
HDMI_TX_N2: length 2.8
  TOP w0.097: CV32.2 101.82,121.36 101.82,121.59 RV11.1 101.82,122.2 101.82,122.95 LV3.2 102.19,123.31 RV24.1
HDMI_TX_P0: length 2.7
  TOP w0.097: CV35.2 112.04,122.5 112.04,122.68 RV14.1 112.02,123.33 112.02,123.63 111.84,123.82 LV9.1 111.68,124.33 RV31.1
HDMI_TX_P1: length 2.9
  TOP w0.097: RV28.1 104.82,123.31 LV6.1 105.18,122.96 105.18,122.2 RV12.1 105.18,121.54 105.18,121.36 CV33.2
HDMI_TX_P2: length 2.8
  TOP w0.097: RV25.1 101.32,123.31 LV3.1 101.64,123 101.64,122.22 RV10.1 101.64,121.57 101.64,121.4 CV31.2
HOST_DEBUG_TX: length 83.7
  TOP w0.102: RZ132.1 337.9,57.43 337.64,57.7 336.91,57.7 v2(336.36,57.15)
  TOP w0.104: UE1.G11 v2(322.12,35.95)
  IN1 w0.099: v2(319.47,23.7) 320.03,24.26 320.03,25.18 320.51,25.67 320.51,29.79 321.7,30.98 321.7,33.71 321.47,33.93 321.2,33.93 320.94,34.19 320.94,34.77 v2(322.12,35.95)
  IN3 w0.102: v2(329.03,57.65) 329.03,56.77 329.84,55.97 330.79,55.97 331.02,56.2 v2(331.02,56.65)
  BOTTOM w0.102: v2(331.02,56.65) 333.08,56.65 333.57,57.15 v2(336.36,57.15) ; v2(319.47,23.7) 319.9,23.7 323.62,19.98 323.62,17.34 323.27,16.99 323.27,14.45 RE306.2 325.94,13.8 326.83,13.8 RE73.2 327.51,13.3 v1(328.44,12.37) 330.44,10.38 333.35,10.38 334.73,11.76 334.73,15.04 334.54,15.24 333.5,15.24 333.4,15.13 JDEG1.8 ; v2(329.03,57.65) 329.03,57.34 328.09,56.39 328.09,51.64 328.34,51.38 328.34,47.4 328.6,47.14 328.6,42.21 328.22,41.83 327.61,41.83 327.1,41.33 327.1,41.06 325.25,39.21 325.21,39.21 324.19,38.18 324.19,37.12 324.02,36.95 322.86,36.95 322.12,36.21 v2(322.12,35.95)
HOST_SD_WP#: length 321.1
  TOP w0.102: v2(187.67,17.63) 187.56,17.53 186.81,17.53 186.54,17.8 186.54,18.44 185.39,19.59 185.39,29.88 184.64,30.63 184.64,39.94 190.59,45.88 190.59,51.52 v1(191.74,52.68) 193.9,54.84 197.15,54.84 v2(197.15,54.84)
  IN2 w0.102: v2(197.15,54.84) 197.23,54.84 198.08,55.69 211.03,55.69 221.46,45.26 v2(222.07,45.26)
  IN3 w0.102: v2(33.82,71.35) 34.32,70.84 34.32,52.98 34.77,52.53 34.77,51.13 31.03,47.4 31.03,42.95 30.35,42.27 30.35,32.43 25.27,27.35 25.27,14.71 26.46,13.52 49.66,13.52 51.37,11.8 61.49,11.8 61.76,11.53 64.97,11.53 65.34,11.17 82.57,11.17 83.37,11.96 86.51,11.96 86.99,12.45 87.8,12.45 88.92,13.56 94.33,13.56 94.84,14.07 99.01,14.07 99.69,13.39 105.53,13.39 106.49,12.42 109.28,12.42 110.42,11.28 137.94,11.28 138.43,11.76 152.81,11.76 154.49,13.44 169.77,13.44 170,13.66 175.06,13.66 177.22,15.82 179.5,15.82 182.14,18.47 187.41,18.47 187.78,18.1 187.78,17.74 v2(187.67,17.63)
  BOTTOM w0.089: 221.72,45.26 221.53,45.26 217.32,41.05 217.32,40.85 217.13,40.66 217.11,40.66 216.9,40.45 216.64,40.45 216.23,40.04 215.74,40.04 215.53,39.83 215.22,39.83 215.04,40.01 214.74,40.01 214.47,40.28 UH1.BE8
  BOTTOM w0.102: QR1.2 34.94,70.82 34.41,71.35 v2(33.82,71.35) ; 221.72,45.26 v2(222.07,45.26) 222.54,45.73 RH214.2
HP_OUT_L: length 12.2
  TOP w0.203: 340.56,43.08 340.56,42.95 340.86,42.65 340.86,41.38 340.72,41.24 UA1.32
  TOP w0.381: 340.56,43.08 340.56,43.35 v2(340.5,43.41) ; v2(347.17,43.42) 348.06,42.53 CA43.2 RA7.1
  IN1 w0.381: v2(347.17,43.42) 346.34,43.42 346.06,43.7 340.79,43.7 v2(340.5,43.41)
HP_OUT_R: length 12
  TOP w0.203: UA1.33 340.32,41.32 340.56,41.55 340.56,42.26 v2(340.38,42.43)
  TOP w0.381: RA8.1 348.53,41.55 CA44.2 347.81,41.26 347.52,41.55 v2(347.52,41.93)
  IN1 w0.381: v2(340.38,42.43) 340.42,42.47 341.32,42.47 341.92,43.07 345.13,43.07 346.26,41.93 v2(347.52,41.93)
HSYNC_CONN: length 7.2
  BOTTOM w0.107: RV122.1 359.66,100.37 359.58,100.29 CV133.1 ; CV133.1 RV1650.2 ; CV133.1 v1(360.57,99.83) 361.52,99.83 362.13,99.22 362.13,99.22 JCRT1.13
HSYNC_CRT: length 52.6
  TOP w0.107: UV6.19 330.53,70.23 v2(331.01,69.75)
  IN1 w0.099: v2(331.01,69.75) 332.02,68.73 333,68.73 335.13,70.86 335.13,78.29 340.88,84.04 341.28,84.04 341.29,84.04 348.89,84.04 350.82,85.97 350.82,86.3 350.82,86.8 350.73,86.89 350.73,94.8 354.1,98.18 v2(357.73,98.18)
  BOTTOM w0.107: RV1650.1 357.77,98.91 v1(357.59,98.73) 357.59,98.32 v2(357.73,98.18)
HV_GATE1_A: length 3.6
  BOTTOM w0.076: 34.79,84.73 34.62,84.9 34.62,85.95 UT5.B9
  BOTTOM w0.102: RT64.1 35.87,83.66 35.43,84.09
  BOTTOM w0.104: 34.79,84.73 v1(35.31,84.22) 35.43,84.09
HV_GATE2_A: length 5.3
  BOTTOM w0.076: UT5.A9 34.38,84.81
  BOTTOM w0.102: v1(34.68,81.06) 34.5,81.24 34.5,82.96 34.8,83.25 RT65.1 34.98,83.96
  BOTTOM w0.104: 34.38,84.81 34.38,84.56 34.98,83.96
HW_ACAVIN_NB: length 502.2
  TOP w0.102: v1(74.94,113.97) 75.38,113.97 v2(75.61,114.2) ; UE1.N6 317.51,30.54 317.51,29.07 317.12,28.68 317.12,27.15 316.53,26.57 v2(316.15,26.57)
  TOP w0.254: v2(6.78,48.79) 6.4,48.41 PR941.1 ; PR21.1 75.61,114.83 v2(75.61,114.2)
  IN1 w0.254: v2(54.43,103.45) 52.55,103.45 52.02,102.92 38.65,102.92 38.02,102.29 29.26,102.29 28.9,102.64 26.97,102.64 25.77,101.44 22.52,101.44 18.94,105.02 17.92,105.02 15.95,103.05 14.7,103.05 v2(13.85,102.19)
  IN2 w0.254: v2(54.43,103.45) 54.43,104.11 58.09,107.77 58.09,108.93 59.24,110.08 67.23,110.08 67.86,110.72 70.49,110.72 v2(71.91,109.3)
  IN3 w0.102: v2(316.15,26.57) 316.08,26.57 315.22,27.43 315.22,29.13 312.93,31.42 312.93,35.58 314.54,37.19 314.54,40.18 317.96,43.6 317.96,47.55 319.16,48.74 319.16,49.66 320.73,51.23 321.65,51.23 323.09,52.68 323.09,55.16 321.69,56.56 321.69,57.22 321.41,57.51 v2(321.28,57.51)
  IN3 w0.254: v2(13.85,102.19) 14.44,102.79 15.15,102.79 16.21,101.73 16.21,96.51 17.55,95.18 17.55,86.51 15.29,84.25 15.29,82.73 14.45,81.9 9.9,81.9 5.19,77.19 5.19,63.26 6.85,61.6 6.85,48.87 v2(6.78,48.79)
  BOTTOM w0.102: v2(75.61,114.2) 77.99,116.58 98.69,116.58 101.11,119 124.18,119 126.5,121.32 145.68,121.32 153.81,113.18 154.73,113.18 176.45,91.46 196,91.46 211.89,75.57 211.89,63.02 217,57.91 221.96,57.91 236.31,43.57 238.33,43.57 240.6,41.3 241.79,41.3 244.32,38.76 248.86,38.76 250.73,36.89 269.02,36.89 269.64,37.52 271.63,37.52 272.55,38.43 278.72,38.43 278.94,38.21 280.56,38.21 282.97,40.63 282.97,46.42 289.99,53.44 296.83,53.44 298.06,54.67 303.33,54.67 305.34,56.68 310.96,56.68 311.6,57.33 321.1,57.33 v2(321.28,57.51)
  BOTTOM w0.254: PR1258.1 PR1241.1 71.42,109.3 v2(71.91,109.3) 73.52,109.3 75.31,111.09 75.31,113.89 v2(75.61,114.2) ; v2(54.43,103.45) 54.43,104.04 52.37,106.1 48.92,106.1 PR1206.2 47.89,105.75 PC1207.1 47.02,104.76 PR1203.2 47.4,104.39 47.4,103.36 47.12,103.09 PU1201.1
HW_GPS_DISABLE#_R: length 3.3
  TOP w0.102: DZ6.2 330.6,61.49 330.6,62.3 v2(330.34,62.57)
  BOTTOM w0.102: v2(330.34,62.57) 330.9,62 JNGFF2.26
I2C1_SCK_TP: length 132.4
  TOP w0.107: RZ29.1 153.49,9.25 RZ21.2 154.86,9.25 156.23,7.88 156.44,7.88 160.91,12.35 163.95,12.35 165.37,13.76 173.65,13.76 174.27,13.14 178.9,13.14 v2(179.37,13.61) ; v2(223.85,34.29) 223.81,34.25 223.81,34.18 223.9,34.09 225.91,34.09 226.14,33.86 228.43,33.86 229.8,32.49 229.8,29.96 231.37,28.39 v1(231.37,26.25) 231.37,23.81 229.84,22.28 229.84,21.97 227.91,20.04 227.91,17 225.38,14.48 223.64,14.48 222.43,13.27 222.43,11.94 224.23,10.14 224.23,5.66 223.52,4.96 v2(223.52,4.5)
  IN3 w0.102: v2(223.52,4.5) 223.42,4.6 223.42,4.8 223.08,5.14 221.6,5.14 219.9,3.44 216.62,3.44 214.24,5.83 203.96,5.83 201.99,7.8 198.59,7.8 195.46,10.92 194.71,10.92 191.15,14.49 190.06,14.49 188.91,15.63 187.86,15.63 187.51,15.98 185.42,15.98 185.06,15.62 181.41,15.62 179.72,13.93 179.69,13.93 v2(179.37,13.61)
  BOTTOM w0.089: 220.55,34.89 218.59,34.89 217.54,33.85 216.07,33.85 216.04,33.88 215.17,33.88 215.15,33.89 214.77,33.89 214.56,33.69 UH1.BE21
  BOTTOM w0.107: v2(223.85,34.29) 223.79,34.36 223.79,34.5 223.4,34.89 220.55,34.89
I2C1_SCK_TP_R: length 12.3
  TOP w0.107: RZ29.2 152.32,9.17 v2(151.81,8.66) 151.48,8.33 RZ117.2 150.67,8.33 150.23,7.89 145.2,7.89 145.06,7.76 144.19,7.76 143.85,8.1 143.85,8.25 v2(143.87,8.28)
  BOTTOM w0.107: v2(143.87,8.28) 143.78,8.38 143.78,8.82 143.52,9.08 JKBTP1.2 ; v2(151.81,8.66) 152.32,9.17 RZ29.2
I2C1_SDA_TP: length 130.2
  TOP w0.107: v2(222.94,4.5) 222.94,5.06 223.74,5.86 223.74,9.94 221.94,11.74 221.94,13.48 223.43,14.97 225.18,14.97 227.42,17.2 227.42,20.24 229.35,22.17 229.35,22.48 230.88,24.01 230.88,28.18 v1(230.13,28.94) 229.31,29.76 229.31,32.29 228.23,33.37 225.93,33.37 225.71,33.6 223.7,33.6 223.32,33.97 223.32,34.18 v2(223.24,34.26) ; v2(180.06,13.59) 179.74,13.27 179.72,13.27 179.1,12.65 174.07,12.65 173.44,13.28 165.57,13.28 164.16,11.86 161.11,11.86 156.64,7.39 156.13,7.39 155.04,6.3 RZ20.2 153.62,6.3 RZ26.1
  IN3 w0.102: v2(180.06,13.59) 181.61,15.14 185.26,15.14 185.62,15.49 187.31,15.49 187.65,15.15 188.71,15.15 189.86,14 190.95,14 194.51,10.44 195.26,10.44 198.39,7.31 201.79,7.31 203.76,5.35 214.04,5.35 216.42,2.96 220.1,2.96 221.8,4.66 222.88,4.66 222.94,4.6 v2(222.94,4.5)
  BOTTOM w0.089: v2(223.24,34.26) 222.79,34.7 218.67,34.7 217.62,33.66 215.99,33.66 215.96,33.68 215.25,33.68 215.22,33.66 UH1.BF21
I2C1_SDA_TP_R: length 13
  TOP w0.107: v2(143.29,8.28) 143.36,8.21 143.36,7.9 143.99,7.27 145.59,7.27 145.73,7.4 v1(147.81,7.4) 150.48,7.4 150.67,7.21 RZ116.2 151.46,7.21 v2(151.74,6.93) 152.17,6.5 RZ26.2
  BOTTOM w0.107: v2(143.29,8.28) 143.29,8.62 143.03,8.88 143.03,9.36 143.02,9.37 JKBTP1.3 ; v2(151.74,6.93) 152.17,6.5 RZ26.2
I_ADP: length 369.6
  TOP w0.104: v2(322.17,40.73) 322.17,40.19 321.72,39.74 UE1.B11
  IN2 w0.102: v2(180.62,58.3) 180.91,58.59 180.91,60.6 182.2,61.89 213.36,61.89 218.21,57.04 222.69,57.04 235.25,44.47 236.39,44.47 240.48,40.38 244.04,40.38 245.06,39.36 249.25,39.36 250.43,38.18 252.74,38.18 252.87,38.05 265.19,38.05 265.97,38.84 267.29,38.84 268.01,39.56 271.39,39.56 271.93,40.11 273.06,40.11 275.76,42.81 281.49,42.81 284.55,45.87 291.57,45.87 294.03,48.32 294.03,49.02 294.2,49.19 300.78,49.19 304.72,53.14 307.95,53.14 308.71,52.37 318.92,52.37 321.66,49.63 321.94,49.63 v2(321.97,49.61)
  BOTTOM w0.102: v2(321.97,49.61) 322.35,49.22 322.35,48.35 320.77,46.77 320.77,44.41 321.32,43.87 321.32,43.33 322.22,42.42 322.22,41.27 322.17,41.22 v2(322.17,40.73) ; v2(180.62,58.3) 177.65,58.3 v1(173.16,53.81) 168.08,48.73 163.75,48.73 154.9,39.87 49.52,39.87 44.29,45.11 32.77,45.11 28.73,49.15 25.12,49.15 23.28,50.99 15.95,50.99 14.24,49.29 14.01,49.29 13.41,48.68 13.41,47.78 12.72,47.09 8.59,47.09 6.19,44.69 6.19,44.37 4.29,42.47 4.29,39.67 PR935.2
I_BATT: length 353.1
  IN2 w0.102: v2(294.43,48.69) 294.43,48.41 290.1,44.07 283.63,44.07 281.66,42.11 280.12,42.11 278.96,40.95 274.74,40.95 273.43,39.65 272.12,39.65 271.58,39.1 269.03,39.1 268.31,38.38 266.16,38.38 265.24,37.45 250.44,37.45 249.15,38.75 244.9,38.75 243.72,39.93 240.2,39.93 236.31,43.81 235.18,43.81 223.15,55.84 218.4,55.84 213.69,60.55 187.04,60.55 185.92,59.44 185.92,58.65 183.79,56.52 182.98,56.52 181.3,58.2 v2(181.2,58.2)
  BOTTOM w0.102: RE64.2 312.52,36.63 312.37,36.78 312.37,38.8 310.53,40.63 310.53,43.6 308.59,45.54 305.8,45.54 304.3,47.04 303.63,47.04 302.06,48.61 294.51,48.61 v2(294.43,48.69) ; 5.38,39.47 5.38,39.52 4.77,40.13 4.77,42.56 6.47,44.25 6.47,44.65 8.68,46.86 12.82,46.86 13.64,47.68 13.64,48.59 14.11,49.06 14.34,49.06 16.04,50.76 23.19,50.76 25.11,48.84 28.68,48.84 32.74,44.77 43.88,44.77 49.01,39.65 155.29,39.65 164.14,48.5 168.32,48.5 177.71,57.89 v1(179.4,57.89) 180.89,57.89 v2(181.2,58.2)
I_BATT_R: length 5.7
  TOP w0.104: UE1.J4 v2(315.72,33.55)
  BOTTOM w0.102: RE64.1 CE3.1 314.19,35.33 v1(314.44,35.09) 314.44,33.49 314.76,33.17 315.34,33.17 v2(315.72,33.55)
I_SYS: length 429.1
  TOP w0.102: v2(3.7,42.21) 3.13,41.64 3.13,39.55 3.6,39.08 3.6,38.63 4.87,37.36 4.87,36.91 5.06,36.72 5.06,36.09 v1(5.29,35.86) 5.44,35.71 PR936.2
  TOP w0.203: PU1700.24 53.77,80.79 52.79,79.8 v2(52.57,79.8)
  IN2 w0.102: v2(52.57,79.8) 52.12,79.36 52.12,74.5 51.47,73.85 51.47,62.05 46.08,56.66 43.46,56.66 40.13,53.33 35.71,53.33 33.9,55.15 v2(33.9,55.19) ; v2(180.4,59.27) 180.4,60.41 182.1,62.12 213.45,62.12 217.99,57.58 222.77,57.58 235.32,45.03 236.18,45.03 240.35,40.86 243.88,40.86 245.16,39.59 249.37,39.59 250.54,38.42 253.03,38.42 253.16,38.28 265.09,38.28 266.06,39.24 267.37,39.24 267.92,39.79 271.29,39.79 271.97,40.47 273.09,40.47 275.67,43.04 281.39,43.04 285.01,46.66 291.79,46.66 v2(293.6,48.47)
  IN3 w0.102: v2(33.9,55.19) 20.49,55.19 13.73,48.42 12.56,48.42 12.32,48.18 12.32,47.62 v2(12.43,47.51)
  BOTTOM w0.102: RE312.2 311.45,34.75 311.53,34.82 311.53,38.49 310.54,39.48 310.54,40.31 310.31,40.54 310.31,43.5 308.5,45.31 305.7,45.31 304.2,46.81 303.53,46.81 302.06,48.28 293.79,48.28 v2(293.6,48.47) ; v2(180.4,59.27) 179.85,58.72 177.54,58.72 167.77,48.96 163.25,48.96 154.4,40.1 49.84,40.1 44.46,45.49 32.94,45.49 29.03,49.4 25.19,49.4 23.38,51.22 15.85,51.22 14.15,49.52 13.92,49.52 13.17,48.77 13.17,47.88 12.8,47.51 v2(12.43,47.51) 12.4,47.54 8.7,47.54 5.96,44.8 5.96,44.47 3.7,42.22 v2(3.7,42.21)
  BOTTOM w0.203: PR1755.1 54.05,79.8 v2(52.57,79.8)
I_SYS_R: length 9.5
  TOP w0.102: UE1.J5 v2(316.52,33.55)
  BOTTOM w0.102: RE312.1 311.91,33.95 311.91,34.62 312.11,34.82 313.18,34.82 313.31,34.7 RE313.1 CE4.1 314.01,33.43 v1(314.24,33.19) 314.54,32.89 314.54,32.59 314.8,32.33 315.95,32.33 316.14,32.53 316.14,33.17 v2(316.52,33.55)
ILIM_1PH: length 5.1
  TOP w0.203: v2(62.49,83.56) 62.46,83.59 PU1700.49
  BOTTOM w0.203: PR1718.2 61.03,84.81 PC1708.2 61.59,84.46 v2(62.49,83.56)
ILIM_2PH: length 2.7
  TOP w0.203: PU1700.32 v1(56.93,78.17) 56.93,77.84 PR1742.1
ILIM_4PH: length 3.1
  TOP w0.203: PR1741.2 56.87,87.48 57.33,87.01 v1(57.33,86.63) PU1700.7
ILIM_SEL: length 2.7
  TOP w0.102: v1(341.96,66.36) 341.96,66.24 341.59,65.88 RI13.1 341,65.9 UI3.4
ILMT_+1VALWP: length 5.1
  BOTTOM w0.102: PR607.2 165.92,10.85 v1(165.59,11.18)
  BOTTOM w0.254: PR607.2 165.93,10.17 PR609.1 165.93,9.3 166.37,8.86 167.8,8.86 168.25,8.42 PU301.13
ILMT_DDR: length 3.6
  TOP w0.102: v2(45.26,5.16) v1(44.67,5.16)
  TOP w0.254: v2(45.26,5.16) 45.28,5.18 45.54,5.18 45.79,4.93 PR207.2 46.16,4.55 46.35,4.36 PR205.1
  BOTTOM w0.254: v2(45.26,5.16) 45.36,5.26 45.36,5.36 45.61,5.61 PU200.17
IMON_1PH: length 3.5
  TOP w0.203: v2(61.92,82.3) 61.83,82.39 PU1700.46
  BOTTOM w0.203: v2(61.92,82.3) 61.53,82.69 PR1713.2 61.04,82.68 PC1706.2
IMVP_VR_ON: length 380.6
  TOP w0.102: UE4.2 344.46,49.86 v2(344.1,50.22) 343.9,50.22 343.75,50.06 343.75,49.43 343.53,49.21 UE3.4 342.59,49.21 342.44,49.06 342.44,48.21 RE304.1 343.77,48.1 v1(344.09,47.78)
  IN1 w0.099: v2(60.54,91.63) 60.54,88.84 60.98,88.39 60.98,79.83 v2(63.52,77.29)
  IN2 w0.102: v2(317.1,55.8) 317.45,55.45 318.58,55.45 321.06,52.96 323.28,52.96 324.13,53.81 336.15,53.81 337.78,52.18 337.78,51.51 338.18,51.1 342.75,51.1 343.63,50.22 v2(344.1,50.22)
  BOTTOM w0.102: v2(317.1,55.8) 317.04,55.85 315.44,55.85 315.36,55.78 311.7,55.78 311.49,55.99 305.62,55.99 303.62,53.99 298.35,53.99 297.12,52.76 290.27,52.76 283.65,46.14 283.65,40.34 280.19,36.87 272.62,36.87 272.58,36.83 269.93,36.83 269.3,36.21 250.45,36.21 248.58,38.08 244.04,38.08 241.91,40.21 240.72,40.21 238.31,42.62 236.29,42.62 221.68,57.23 216.71,57.23 211.16,62.78 211.16,73.57 195.32,89.41 175.65,89.41 169.49,95.56 168.71,95.56 144.76,119.52 127.02,119.52 124.87,117.37 114.56,117.37 111.29,114.1 108.2,114.1 107.51,113.4 92.43,113.4 87.33,108.31 78.96,108.31 76.98,106.32 73.66,106.32 70.99,103.65 69.58,103.65 69.37,103.45 66.06,103.45 64.37,101.76 64.37,97.94 60.76,94.33 60.76,91.86 v2(60.54,91.63) ; v2(63.52,77.29) 63.52,80.14 63.93,80.54 PR1724.2
IMVP_VR_ON_EC: length 72
  TOP w0.102: v2(322.05,52.21) 322.66,52.82 323.04,52.82 v1(325.81,50.05) 326.26,49.6 RPE10.1 ; RE304.2 341.63,48.52 342.15,49.03 342.15,49.36 342.49,49.71 v2(342.49,50.4) 342.41,50.48 341.56,50.48 UE3.1
  TOP w0.104: UE1.N7 317.7,29.93 317.7,28.76 317.35,28.4 317.35,26.77 316.91,26.34 316.81,26.34 316.4,25.93 v2(316.15,25.93)
  IN2 w0.102: v2(322.05,52.21) 322.85,52.21 323.88,53.24 336.4,53.24 337.49,52.15 337.49,51.35 337.96,50.88 341.33,50.88 341.8,50.4 v2(342.49,50.4)
  IN3 w0.102: v2(316.15,25.93) 314.99,27.09 314.99,29.03 312.64,31.38 312.64,39.58 316.89,43.83 316.89,46.8 318.93,48.84 318.93,49.85 321.09,52.01 321.85,52.01 v2(322.05,52.21)
INT_SPK_L+: length 15.4
  IN2 w1.016: 347.84,25.13 347.01,25.97 346.95,25.97 343.43,29.49 342.69,29.49 341.78,30.4 341.78,30.5 339.51,32.77 339.51,34.15 338.47,35.19 338.47,36.2
  vias: v1(336.83,37.92) v2(335.58,37.82) v2(336.22,37.87) v2(348.74,24.93) v2(348.74,24.35)
INT_SPK_L-: length 19
  IN2 w1.016: 347.8,22.49 346.36,22.49 345.96,22.9 345.96,24.81 342.92,27.84 342.49,27.84 340.5,29.83 340.5,29.98 338.23,32.25 338.23,33.63 337.16,34.7 337.16,36
  vias: v1(349.22,22.48) v2(335.67,37.01) v2(336.22,37.24) v2(348.77,22.76) v2(348.77,22.17)
INT_SPK_R+: length 21.1
  IN2 w1.016: 347.69,20.66 344.89,20.66 344.09,21.46 344.09,24.21 342.49,25.81 340.95,25.81 335.3,31.46 335.3,33.39 335.84,33.92
  vias: v1(336.6,35.29) v2(335.54,35.1) v2(336.13,35.09) v2(348.8,20.98) v2(348.8,20.39)
INT_SPK_R-: length 24.4
  IN2 w1.016: 347.78,19.14 347.43,18.8 344.97,18.8 342.82,20.94 342.82,23.68 341.97,24.54 340.42,24.54 333.91,31.05 333.91,33.95 334.51,34.55
  vias: v1(336.56,36.58) v2(335.56,36) v2(336.13,36.17) v2(348.85,19.49) v2(348.89,18.86)
INT_SPKR_L+:
  vias: v1(346.33,25.41) v2(341.08,23.59) v2(341.69,23.59)
INT_SPKR_L-:
  vias: v1(346.35,22.21) v2(341.15,22.57) v2(341.74,22.6)
INT_SPKR_R+: length 0.9
  TOP w0.203: v2(341.17,21.4) 340.68,21.4 v1(340.42,21.13)
  vias: v2(341.76,21.4)
INT_SPKR_R-:
  vias: v1(346.45,18.12) v2(341.15,20.09) v2(341.78,20.1)
IR_CAM_DET#: length 162.8
  IN2 w0.102: v2(175.31,84.63) 175.7,84.25 175.7,82.96 175.44,82.7 175.44,60.53 175.66,60.31 175.66,50.46 175.28,50.08 175.28,44.97 175.72,44.54 194.92,44.54 195.96,43.5 204.81,43.5 206.88,41.43 206.88,40.22 207.29,39.81 207.29,38.65 208.4,37.53 208.4,36.65 208.91,36.14 211.52,36.14 211.95,36.57 212.32,36.57 212.74,36.99 213.09,36.99 213.75,36.33 219.01,36.33 219.57,35.78 v2(219.57,35.77)
  BOTTOM w0.089: v2(219.57,35.77) 219.5,35.77 219.01,36.26 215.1,36.26 214.93,36.43 214.6,36.43 214.46,36.57 213.99,36.57 UH1.BD16
  BOTTOM w0.102: RH373.1 221.65,36.78 221.1,36.23 220.03,36.23 v2(219.57,35.77) ; JIR1.1 130.61,115.49 131.9,116.78 142.53,116.78 161.24,98.08 161.24,94.19 170.85,84.58 v1(173.88,84.58) 175.26,84.58 v2(175.31,84.63)
ISH_UART0_CTS#: length 113.8
  IN3 w0.089: v2(216.18,37.24) 216.18,36.82 218.17,34.83 218.17,33.56 219.77,31.95 219.77,31.06 221.73,29.1 223.46,29.1 223.61,29.25
  IN3 w0.102: v2(292.26,20.11) 292.26,19.73 291.75,19.22 287.62,19.22 287.08,19.76 278.04,19.76 277.59,19.3 271.73,19.3 271.03,20 270.09,20 269.87,20.22 254.9,20.22 254.69,20.42 252.52,20.42 252.38,20.28 247.43,20.28 247.21,20.07 242.04,20.07 241.3,20.8 237.29,20.8 234.13,23.96 233.49,23.96 232.74,24.71 231.77,24.71 228.75,27.72 228.75,28.23 227.68,29.3 226.69,29.3 225.84,28.44 224.66,28.44 223.85,29.25 223.61,29.25
  BOTTOM w0.089: v2(216.18,37.24) 216.12,37.31 215.74,37.31 215.66,37.38 214.98,37.38 214.97,37.37 UH1.BF14
  BOTTOM w0.107: RZ80.1 306.96,23.12 307.96,22.12 307.96,21.74 308.67,21.04 308.67,19.43 305.67,16.43 303.93,16.43 303.61,16.75 v1(295.45,16.75) 293.76,16.75 292.29,18.22 292.29,20.08 v2(292.26,20.11)
ISH_UART0_CTS#_R: length 3.7
  BOTTOM w0.107: JNGFF1.62 305.6,23.36 RZ80.2
ISH_UART0_RTS#: length 115.9
  IN3 w0.089: v2(209.6,35.52) 209.6,35.67 209.97,36.04 211.02,36.04 211.26,35.8 215.69,35.8 215.97,36.08 216.67,36.08 217.99,34.76 217.99,33.4 218.74,32.64 218.74,31.58 221.4,28.92 223.46,28.92 223.61,28.77
  IN3 w0.102: v2(292.93,18.97) 292.93,18.61 292.32,18 287.11,18 286.57,18.54 278.55,18.54 278.09,18.08 271.23,18.08 270.53,18.78 269.58,18.78 269.37,19 254.39,19 254.19,19.2 253.03,19.2 252.5,18.68 246.47,18.68 246.31,18.85 241.53,18.85 241.02,19.35 236.58,19.35 233.34,22.6 232.15,22.6 230.59,24.15 227.55,24.15 226.21,25.5 226.21,26.17 223.61,28.77
  BOTTOM w0.089: UH1.AR18 209.24,35.34 209.41,35.52 v2(209.6,35.52)
  BOTTOM w0.107: RZ81.1 306.79,22.23 308.18,20.83 308.18,19.63 305.46,16.91 304.13,16.91 303.81,17.24 294.3,17.24 292.93,18.61 v2(292.93,18.97)
ISH_UART0_RTS#_R: length 4.8
  BOTTOM w0.107: RZ371.2 305.85,22.22 RZ81.2 305.39,22.68 v1(304.26,22.68) 304.08,22.86 JNGFF1.64
ISH_UART0_RXD: length 116.8
  IN3 w0.089: v2(218.39,35.72) 219.27,34.84 219.27,33.96 220.44,32.79 220.44,32.08 221.89,30.63 223.49,30.63 223.61,30.51
  IN3 w0.102: v2(291.08,20.11) 290.47,20.73 277.64,20.73 277.18,20.27 272.13,20.27 271.43,20.97 270.49,20.97 270.27,21.18 255.3,21.18 255.09,21.39 252.14,21.39 251.79,21.74 251.27,21.74 250.91,21.39 247.07,21.39 246.33,22.13 239.78,22.13 239.42,21.77 237.69,21.77 234.53,24.93 233.89,24.93 233.15,25.67 232.17,25.67 230.97,26.86 230.97,26.87 229.72,28.13 229.72,28.63 228.08,30.26 226.16,30.26 225.83,29.94 224.88,29.94 224.31,30.5 223.74,30.5 223.73,30.51 223.61,30.51
  BOTTOM w0.089: v2(218.39,35.72) 218.34,35.67 218.34,35.66 217.77,35.08 215.23,35.08 214.43,35.88 UH1.BE17
  BOTTOM w0.107: RZ78.1 307.24,24.89 309,23.14 309,22.08 309.64,21.44 309.64,19 306.09,15.45 303.53,15.45 303.2,15.77 293.35,15.77 291.08,18.04 v2(291.08,20.11)
ISH_UART0_RXD_R: length 4.2
  BOTTOM w0.107: RZ78.2 305.57,25.17 v1(304.53,25.17) 303.45,25.17 303.23,24.95 303.23,24.64 302.96,24.36 JNGFF1.58
ISH_UART0_TXD: length 113.8
  IN3 w0.089: v2(217.81,35.71) 218.89,34.63 218.89,33.08 221.52,30.45 223.17,30.45 223.61,30.02
  IN3 w0.102: 223.61,30.02 223.74,29.88 224.25,29.88 224.67,29.45 226.03,29.45 226.36,29.78 227.88,29.78 229.23,28.43 229.23,27.93 230.49,26.67 230.49,26.66 231.97,25.19 232.94,25.19 233.69,24.44 234.33,24.44 237.49,21.28 241.5,21.28 242.24,20.55 247.01,20.55 247.23,20.76 252.18,20.76 252.32,20.9 254.89,20.9 255.1,20.7 270.07,20.7 270.29,20.48 271.23,20.48 271.93,19.79 277.39,19.79 277.84,20.24 287.55,20.24 288.09,19.7 291.55,19.7 291.67,19.82 v2(291.67,20.11)
  BOTTOM w0.089: UH1.BF17 214.9,35.79 215.36,35.32 217.42,35.32 v2(217.81,35.71)
  BOTTOM w0.107: v2(291.67,20.11) 291.67,18.15 293.56,16.26 v1(298.94,16.26) 303.41,16.26 303.73,15.94 305.89,15.94 309.15,19.2 309.15,21.24 308.51,21.88 308.51,22.25 RZ79.1
ISH_UART0_TXD_R: length 3.6
  BOTTOM w0.107: RZ79.2 305.7,23.86 v1(304.91,23.86) JNGFF1.60
ISPSCL: length 2
  TOP w0.107: UV6.30 326.73,74.67 RV106.1
ISPSDA: length 2.1
  TOP w0.107: RV107.1 327.13,74.5 UV6.29
IST_TRIG: length 16.2
  BOTTOM w0.076: 120.78,52.9 120.16,53.52 119.47,53.52 UC1.E3
  BOTTOM w0.102: 120.78,52.9 120.88,52.8 126.62,52.8 127.18,53.37 127.18,57.38 125.97,58.6 T3.1
ITP_PMODE_CPU: length 208.1
  TOP w0.102: RC144.2 42.83,50.93 43.58,51.69 43.58,53.34 v2(43.99,53.75)
  BOTTOM w0.089: UH1.AL3 207.21,42.73 207.21,44.02 207.37,44.19 207.37,45.8 208.48,46.91 208.48,47.96 T192.1 209.01,48.49 209.01,49.68 209.14,49.81 209.14,50.17
  BOTTOM w0.102: 209.14,50.17 209.14,53.47 203.16,59.45 195.2,59.45 188.55,66.1 173.67,66.1 173.49,65.92 173.26,65.92 173.02,65.68 173.02,64.45 163.46,54.89 163.46,53.3 151.4,41.25 58.7,41.25 51.16,48.79 51.16,53.97 50.78,54.36 45.46,54.36 45,53.9 44.14,53.9 v2(43.99,53.75)
JCRT-11: length 4.9
  BOTTOM w0.102: JCRT1.11 360.75,105.18 T200.1
JDIMM1_EVENT#: length 4.7
  TOP w0.102: v2(60.98,12.8) 61.01,12.83 61.01,14.38 61.2,14.57 RD14.1 v1(62.55,14.57)
  BOTTOM w0.102: JDIMM1.134 61.47,13.29 v2(60.98,12.8)
JDIMM2_EVENT#: length 4.5
  TOP w0.102: v2(142.58,12.76) v1(142.58,12.2)
  TOP w0.104: RD27.1 142.68,14.57 142.85,14.39 142.85,13.14 142.58,12.87 v2(142.58,12.76)
  BOTTOM w0.102: v2(142.58,12.76) 142.47,12.87 JDIMM2.134
JTAG_CLK: length 34.4
  TOP w0.104: UE1.C8 v2(319.72,39.15)
  IN3 w0.102: v2(319.72,39.15) 319.34,38.77 319.34,35.03 318.93,34.62 318.93,31.04 318.56,30.67 318.56,28.78 318.87,28.47 319.01,28.47 319.26,28.22 319.26,27.82 v2(318.83,27.39)
  BOTTOM w0.102: v2(318.83,27.39) v1(319.62,27.39) 320.03,27.39 320.71,26.71 321.79,26.71 324.25,24.24 324.25,23.38 325.93,21.7 325.93,19.33 326.54,18.72 326.54,17.32 326.74,17.12 RPE7.2 327.55,17.12 328.41,16.26 330.46,16.26 331.4,15.32 JDEG1.4
JTAG_RST#: length 8.9
  TOP w0.102: RE63.1 327.78,39.71 JTAG1.1 327.75,39.73 RE65.1
  TOP w0.104: RE65.1 CE30.1 325.36,39.28 325.36,38.52 325.83,38.05 325.83,37.74 325.63,37.55 325.4,37.55 324.73,36.87 324.73,36.78 324.2,36.26 324.2,36.26 323.49,35.55 UE1.G13
JTAG_TDI: length 34.4
  TOP w0.104: UE1.E9 v2(320.52,37.55)
  IN3 w0.102: v2(320.52,37.55) 320.14,37.17 320.14,35.54 319.14,34.54 319.14,30.96 318.79,30.61 318.79,28.88 318.97,28.7 319.1,28.7 320.01,27.79 v2(320.01,25.74)
  BOTTOM w0.102: JDEG1.2 330.4,15.3 329.9,15.8 327.93,15.8 327.62,16.12 RPE7.4 327.04,16.12 326.31,15.39 325.17,15.39 324.53,16.03 324.53,18.06 324.99,18.52 v1(324.99,19.04) 324.99,21.86 323.8,23.05 323.8,24.04 322.86,24.98 321.9,24.98 321.31,25.58 320.18,25.58 v2(320.01,25.74)
JTAG_TDO: length 36
  TOP w0.102: UE1.F6 v2(318.12,36.75)
  IN3 w0.102: v2(318.84,28.02) 318.31,28.02 314.54,31.79 314.54,34.51 314.98,34.95 316.81,34.95 317.21,35.36 317.49,35.36 318.12,35.99 v2(318.12,36.75)
  BOTTOM w0.102: JDEG1.5 331.9,15.14 330.56,16.49 328.72,16.49 327.59,17.62 RPE7.1 326.94,17.62 326.77,17.79 326.77,22.12 325.71,23.18 325.71,23.73 325.01,24.43 324.38,24.43 321.77,27.05 v1(321.28,27.05) 320.69,27.05 319.72,28.02 v2(318.84,28.02)
JTAG_TMS: length 43.2
  TOP w0.102: UE1.C5 v2(317.32,39.15)
  IN3 w0.102: v2(319.62,25.22) 319.54,25.3 319.54,26.48 319.13,26.89 318.76,26.89 313.74,31.9 313.74,34 314.95,35.2 315.51,35.2 316.14,35.83 316.14,36.11 316.4,36.37 316.68,36.37 316.9,36.59 316.9,36.91 317.16,37.17 317.48,37.17 317.7,37.39 317.7,38.51 317.32,38.89 v2(317.32,39.15)
  BOTTOM w0.102: v2(319.62,25.22) 319.55,25.3 319.55,26.09 319.93,26.48 321.69,26.48 324.02,24.15 324.02,23.14 325.42,21.75 v1(325.42,20.71) 325.42,18.62 324.76,17.96 324.76,16.12 325.26,15.62 326.22,15.62 326.63,16.03 326.63,16.34 326.9,16.62 RPE7.3 327.56,16.62 328.15,16.03 330,16.03 330.9,15.12 JDEG1.3
KB_DET#: length 167.7
  IN1 w0.099: v2(182.42,13.7) 181.78,13.7 180.81,12.73 177.94,12.73 176.75,11.54 171.57,11.54 170.96,10.93 162.41,10.93 161.78,10.3 148.21,10.3 147.2,9.29 142.53,9.29 142.25,9.02 130.88,9.02 130.4,9.5 v2(129.92,9.5)
  IN2 w0.102: v2(225.28,36.09) 225.1,36.27 224.02,36.27 223.11,35.36 222.12,35.36 221.55,35.93 220.75,35.93 220.11,36.56 213.84,36.56 213.18,37.22 212.65,37.22 212.43,37.01 211.75,37.01 v2(211.53,37.22) 209.03,37.22 207.6,38.65 207.6,40.08 207.96,40.44 207.96,44.13 205.01,47.08 196.95,47.08 196.48,47.55 191.6,47.55 186.67,52.48 178.37,52.48 v2(177.95,52.06) ; v2(182.42,13.7) 182.08,14.05 182.08,25.67 181.78,25.96 179.02,25.96 v2(170.58,34.39)
  BOTTOM w0.089: UH1.AW15 v2(211.53,37.22)
  BOTTOM w0.102: v2(170.58,34.39) 170.58,42.71 177.95,50.07 v2(177.95,52.06) ; v2(129.92,9.5) CZ84.1 131.24,10.01 134.18,10.01 134.19,10 JKBTP1.20 ; RC74.2 225.28,36.27 v2(225.28,36.09)
LAN_ACTLED_YEL#: length 29.8
  TOP w0.102: QL1.6 309.71,89.24 308.56,90.4 308.56,96.71 v1(311.14,99.29) 316.35,104.5 316.35,109.29 319.2,112.13 RL14.1
LAN_ACTLED_YEL_R#: length 15.1
  TOP w0.102: RL14.2 320.11,118.67 320.38,118.93 320.38,123.37 320.89,123.88 v1(321.56,123.88) 325.32,123.88 JLOM1.10
LAN_DISABLE#_R: length 4.8
  TOP w0.102: RL7.2 328.43,83.28 RL9.1 RL5.1 326.6,83.28 v1(325.46,84.42) 324.98,84.9 UL1.3
LAN_MDIN0: length 7.2
  TOP w0.089: UL1.14 323.05,89.74 323.19,89.87 323.19,90.3 323.82,90.93 324.84,90.93 v4(325.42,91.52) 327.13,93.23 327.13,93.61 RL72.1
LAN_MDIN0_L: length 18.1
  TOP w0.089: v2(328.2,101.69) 327.93,101.42 327.66,101.42 327.17,100.94 327.17,95.97 RL72.2
  BOTTOM w0.089: TL1.11 326.08,108.66 325.99,108.57 325.8,108.57 325.71,108.49 325.71,101.92 326.19,101.44 327.94,101.44 v2(328.2,101.69)
LAN_MDIN1: length 6.2
  TOP w0.089: RL74.1 324.49,93.58 324.49,93.4 v4(322.88,91.79) 321.45,90.36 UL1.18
LAN_MDIN1_L: length 20.3
  TOP w0.089: v2(331.63,104.99) 331.38,104.75 329.66,104.75 324.51,99.59 324.51,95.97 RL74.2
  BOTTOM w0.089: v2(331.63,104.99) 331.38,104.75 331.06,104.75 330.85,104.96 330.85,105.88 331.71,106.75 331.71,108.49 331.8,108.57 331.99,108.57 332.08,108.66 TL1.5
LAN_MDIN2: length 5.5
  TOP w0.089: RL76.1 321.79,93.62 321.79,92.79 320.46,91.45 v4(320.46,90.84) 320.46,90.15 320.25,89.95 UL1.21
LAN_MDIN2_L: length 20.3
  TOP w0.089: RL76.2 321.84,95.97 321.84,100.23 326.5,104.89 328.35,104.89 v2(328.58,105.12)
  BOTTOM w0.089: v2(328.58,105.12) 328.31,104.85 327.99,104.85 327.75,105.09 327.75,106.14 328.71,107.1 328.71,108.49 328.8,108.57 328.99,108.57 329.08,108.66 TL1.8
LAN_MDIN3: length 5.1
  TOP w0.089: UL1.24 319.05,89.77 319.26,89.98 319.26,90.46 319,90.72 v4(319,91.43) 319,93.61 RL78.1
LAN_MDIN3_L: length 27.6
  TOP w0.089: v2(335.31,106.26) 335.11,106.06 326.4,106.06 319.05,98.7 319.05,95.97 RL78.2
  BOTTOM w0.089: TL1.2 335.08,108.66 334.99,108.57 334.8,108.57 334.71,108.49 334.71,106.23 334.87,106.07 335.11,106.07 v2(335.31,106.26)
LAN_MDIP0: length 7.2
  TOP w0.089: UL1.13 323.45,90.18 323.93,90.66 324.95,90.66 v4(326.86,92.58) 327.4,93.12 327.4,93.53 RL71.1
LAN_MDIP0_L: length 18.1
  TOP w0.089: v2(328.2,100.93) 327.97,101.15 327.77,101.15 327.44,100.83 v4(327.44,98.06) 327.44,95.97 RL71.2
  BOTTOM w0.089: TL1.12 325.08,108.66 325.17,108.57 325.35,108.57 325.44,108.49 325.44,101.81 326.08,101.17 327.96,101.17 v2(328.2,100.93)
LAN_MDIP1: length 6.2
  TOP w0.089: UL1.17 321.85,89.97 321.8,90.02 321.8,90.33 v4(324.17,92.7) 324.76,93.29 324.76,93.56 RL73.1
LAN_MDIP1_L: length 20.3
  TOP w0.089: RL73.2 324.78,95.97 v4(324.78,97.88) 324.78,99.48 329.77,104.48 331.38,104.48 v2(331.63,104.23)
  BOTTOM w0.089: TL1.6 331.08,108.66 331.17,108.57 331.36,108.57 331.44,108.49 331.44,106.86 330.58,105.99 330.58,104.85 330.95,104.48 331.38,104.48 v2(331.63,104.23)
LAN_MDIP2: length 5.5
  TOP w0.089: RL75.1 322.06,93.52 322.06,92.67 v4(321.65,92.26) 320.73,91.34 320.73,90.03 320.73,90.02 320.65,89.95 UL1.20
LAN_MDIP2_L: length 20.3
  TOP w0.089: RL75.2 322.11,95.97 322.11,100.12 v4(324.23,102.24) 326.61,104.62 328.31,104.62 v2(328.58,104.36)
  BOTTOM w0.089: TL1.9 328.08,108.66 328.17,108.57 328.36,108.57 328.44,108.49 328.44,107.21 327.48,106.25 327.48,104.98 327.87,104.58 328.35,104.58 v2(328.58,104.36)
LAN_MDIP3: length 5.1
  TOP w0.089: UL1.23 319.45,89.75 319.53,89.83 319.53,90.57 319.27,90.83 v4(319.27,92.85) 319.27,93.53 RL77.1
LAN_MDIP3_L: length 27.6
  TOP w0.089: RL77.2 319.31,95.97 319.31,98.59 326.51,105.79 v4(333.54,105.79) 335.15,105.79 v2(335.31,105.63)
  BOTTOM w0.089: TL1.3 334.08,108.66 334.17,108.57 334.36,108.57 334.44,108.49 334.44,106.11 334.76,105.8 335.14,105.8 v2(335.31,105.63)
LAN_TEST_EN: length 2.2
  TOP w0.102: RL12.1 316.71,86.45 316.9,86.64 v1(317.1,86.64) 317.41,86.64 317.56,86.5 UL1.30
LAN_WAKE#: length 201.6
  TOP w0.102: RL70.2 RH93.1 220.27,18.26 219.06,19.47 218.82,19.47 v1(217.06,21.23) 216.52,21.77 v2(216.49,21.77) ; v2(325.66,83.6) 324.76,84.5 UL1.2
  TOP w0.104: UE1.L3 v2(314.92,31.95)
  IN1 w0.099: v2(300.71,47.87) 300.05,47.87 298.98,48.95 298.98,50.04 299.74,50.8 v2(299.74,51.67)
  IN2 w0.102: v2(325.66,83.6) 325.66,78.04 324.4,76.78 324.4,70.48 313.08,59.16 304.91,59.16 299.74,53.99 v2(299.74,51.67)
  IN3 w0.102: v2(276.95,16.7) 276.34,16.09 265.71,16.09 265.19,15.56 254.29,15.56 253.67,16.18 243.8,16.18 243.15,16.83 235.02,16.83 233.83,18.02 229.9,18.02 229.33,18.58 226.93,18.58 226.31,19.2 224.36,19.2 222.2,21.36 219.76,21.36 219.75,21.36 216.9,21.36 v2(216.49,21.77)
  BOTTOM w0.089: v2(216.49,21.77) 215.87,22.39 UH1.BG44
  BOTTOM w0.102: v2(314.92,31.95) 314.67,31.95 314.33,32.28 311.14,32.28 310.94,32.48 310.94,34.65 311.32,35.03 311.32,37.96 310.62,38.66 309.63,38.66 309.29,39 309.29,44 308.22,45.08 305.61,45.08 305.05,45.64 302.86,45.64 300.71,47.8 v2(300.71,47.87) 300.53,48.05 290.35,48.05 286.45,44.15 286.45,36.55 283.37,33.48 282.62,33.48 278.94,29.79 278.94,28.47 276.75,26.29 276.75,16.9 v2(276.95,16.7)
LCD_CBL_DET#: length 182.4
  TOP w0.102: RC370.1 214.53,32.86 214.09,32.42 v1(212.2,32.42) 211.92,32.42 v2(211.43,32.91)
  IN2 w0.122: v2(170.06,91.6) 170.06,90.81 174.88,86 174.88,60.31 175.03,60.16 175.03,50.48 174.69,50.15 174.69,44.67 175.29,44.07 194.73,44.07 195.77,43.03 203.45,43.03 204.79,41.69 204.79,36.71 206.39,35.11 206.39,34.2 206.83,33.76 208.47,33.76 209.05,33.19 209.05,32.6 209.3,32.34 210.86,32.34 v2(211.43,32.91)
  BOTTOM w0.089: UH1.AW24 v2(211.43,32.91)
  BOTTOM w0.102: v2(170.06,91.6) 170.06,92.68 144.2,118.55 127.53,118.55 117.59,108.61 105.51,108.61 104.15,107.25 JEDP1.40
LCD_TST: length 283.8
  TOP w0.102: 313.46,30.95 311.73,29.22 v2(310.67,29.22) 310.54,29.08 RE20.1
  TOP w0.104: 313.46,30.95 313.63,31.12 314.09,31.12 UE1.M2
  IN1 w0.099: v2(310.67,29.22) 310.64,29.24 310.64,31.96 308.09,34.52 308.09,45.21 305.67,47.62 305.67,50.49 v2(305.09,51.08)
  BOTTOM w0.102: v2(305.09,51.08) 302.78,53.39 298.4,53.39 297.31,52.3 290.96,52.3 283.88,45.22 283.88,39.42 281.11,36.65 272.79,36.65 272.74,36.6 270.02,36.6 269.4,35.98 250.35,35.98 248.48,37.85 243.94,37.85 241.83,39.96 240.65,39.96 238.31,42.3 236.23,42.3 221.53,57 214.71,57 210.93,60.77 210.93,73.47 198.55,85.85 v1(189.61,85.85) 174.75,85.85 167.9,92.7 167.9,93.6 143.52,117.97 127.61,117.97 117.73,108.1 110.66,108.1 109.65,107.09 JEDP1.29
LCD_VCC_TEST_EN: length 228.3
  TOP w0.104: v2(302.44,52.24) 303.75,50.94 v1(303.93,50.94) 304.12,50.94 305.66,49.4 305.66,47.86 305.73,47.79 305.73,45.29 305.42,44.98 305.42,42.21 306.86,40.77 310.81,40.77 311.7,39.88 311.7,38.61 312.98,37.34 313.29,37.34 313.48,37.15 UE1.E1
  BOTTOM w0.102: v2(302.44,52.24) 301.97,52.72 298.05,52.72 297.4,52.07 291.06,52.07 284.11,45.12 284.11,39.33 280.54,35.75 250.26,35.75 248.39,37.62 242.66,37.62 238.28,42.01 236.2,42.01 221.44,56.77 214.61,56.77 210.7,60.68 210.7,65.26 209.41,66.55 208.44,66.55 207.41,67.57 207.41,69.12 192.31,84.23 170.5,84.23 159.99,94.74 159.99,98.77 147.15,111.61 DV3.2
LCDVDD_MONITOR: length 3.3
  BOTTOM w0.102: QV21.2 155.29,92.4 v1(154.23,91.34) 153.86,90.97 RV630.2
LDO_3V:
  vias: v2(170.61,7.39)
LED_10_GRN#: length 59.5
  TOP w0.102: v2(345.92,124.51) 345.49,124.51 344.45,123.47 344.45,113.69 341.02,110.26 323.46,110.26 v1(313.98,100.77) 309.04,95.83 309.04,92.51 309.51,92.04 QL2.6
  BOTTOM w0.102: v2(345.92,124.51) RL19.1
LED_10_GRN_R#: length 11
  BOTTOM w0.102: RL19.2 343.84,124.51 343.48,124.87 v1(343,124.87) 339.9,124.87 338.04,123 335.55,123 JLOM1.11
LED_100_ORG#: length 64.9
  TOP w0.102: v2(345.94,125.4) 346.38,124.97 346.38,124.36 346.1,124.08 345.46,124.08 344.8,123.42 344.8,113.47 340.97,109.64 323.8,109.64 v1(310.91,96.75) 310.19,96.03 v2(310.19,94.51) ; QL1.3 v2(311.59,88.29)
  IN1 w0.099: v2(310.19,94.51) 310.19,94.51 311.32,93.37 311.32,88.56 v2(311.59,88.29)
  BOTTOM w0.102: v2(345.94,125.4) RL20.1
LED_100_ORG_R#: length 8
  BOTTOM w0.102: RL20.2 v1(340.89,125.4) 339.92,125.4 338.4,123.88 JLOM1.13
LED_MASK#: length 145.6
  TOP w0.102: v2(344.72,110.77) 343.16,109.21 324.92,109.21 v1(318.45,102.74) 312.61,96.9 312.61,93.06 312.24,92.69 QL2.2 311.15,92.69 310.82,92.35 310.82,92.13 309.67,90.98 309.67,90.53 310.24,89.95 310.68,89.95 310.94,89.69 QL1.5 QL1.2
  TOP w0.104: UE1.A12 322.52,40.52 322.57,40.57 322.57,40.73 v2(323.77,41.93)
  IN3 w0.102: v2(323.77,41.93) 323.77,43.17 323.64,43.29 323.64,47.24 325.37,48.97 325.37,50.81 324.69,51.49 324.69,56.42 323.03,58.07 323.03,60.54 323.47,60.98 324.23,60.98 325.83,62.59 328.27,62.59 329.05,61.81 339.87,61.81 341.79,63.73 341.79,64.14 341.36,64.57 341.36,66.8 343.1,68.53 343.1,75.86 342.3,76.66 342.3,108.34 v2(344.72,110.77)
  BOTTOM w0.102: RE21.1 325.04,42.32 324.91,42.19 324.02,42.19 v2(323.77,41.93) ; UZ10.1 344.84,110.88 v2(344.72,110.77)
LG1_ISL88738: length 5
  IN1 w0.762: 18.64,29.79 13.95,29.79 13.75,30
  vias: v1(12.9,30.89) v2(12.43,30.37) v2(13.03,30.38) v2(19.22,30.29) v2(19.85,30.29)
LG2_ISL88738: length 14.8
  TOP w0.102: v2(14.71,17.13) v1(14.07,17.13)
  IN3 w0.762: 11.87,29.39 12.08,29.19 12.08,24.55 13.81,22.81 15.4,22.81 16.06,22.15 16.06,17.91 16.07,17.89
  vias: v2(10.78,30.58) v2(11.12,30.1) v2(14.74,16.49)
LID_CL#: length 131.7
  TOP w0.102: RE26.1 v2(322.63,23.47) 322.6,23.44 322.6,23.16 322.53,23.09 322.32,23.09 321.25,22.02 319.83,22.02 319.43,21.61 318.81,21.61 316.26,19.06 316.26,10.2 v3(317.46,9) 317.46,7.76 319.82,5.4 321.83,5.4 322.69,6.26 v2(322.69,6.88)
  IN3 w0.102: v2(344.85,111.66) 345.13,111.38 345.13,89.48 344.72,89.08 344.72,82.45 344.47,82.19 344.47,70.13 343.81,69.47 343.81,66.37 343.34,65.9 343.34,64.12 340.58,61.36 339.99,61.36 339.99,61.35 338.96,60.32 338.96,58.46 338.15,57.64 338.15,50.7 333.08,45.64 333.08,39.1 331.64,37.66 331.64,27.95 329.65,25.96 326.13,25.96 325.21,25.04 323.44,25.04 322.58,24.19 322.58,23.51 v2(322.63,23.47)
  BOTTOM w0.102: v2(322.69,6.88) 322.54,7.03 JLED1.2 ; v2(344.85,111.66) 344.98,111.53 UZ10.2
LID_CL#_PCH: length 1.3
  TOP w0.102: v2(210.51,26.76) 210.65,26.89 T268.1
  BOTTOM w0.089: v2(210.51,26.76) 210.51,26.84 UH1.AV34
LID_CL_SIO#: length 7.7
  TOP w0.102: 320.66,28.8 320.26,28.41 CE8.1 RE25.2 320.26,27.03 320.73,26.57 v1(322.25,26.57) 322.63,26.19 RE26.2
  TOP w0.104: 320.66,28.8 320.66,29.69 UE1.N11
LINE1_L: length 4.8
  TOP w0.203: 345.2,39.36 345.01,39.17 UA1.22
  TOP w0.381: CA43.1 v1(345.7,41.38) 345.2,40.88 345.2,39.36
LINE1_R: length 4.1
  TOP w0.203: UA1.21 345.37,38.77 345.71,39.11
  TOP w0.381: CA44.1 345.71,40.12 v1(345.71,39.79) 345.71,39.11
LM393_P: length 120.5
  TOP w0.508: PR950.2 11.05,48.79 v1(12.9,48.79) 13.66,48.03 v2(14.52,48.03) 14.71,47.85 PC949.2 14.64,47.3 PU903.5
  IN2 w0.508: v2(37.38,108.75) 37.4,108.74 38.91,108.74 39.42,108.23 39.42,106.45 37.64,104.67 29.89,104.67 29.07,103.85 27.54,103.85 26.34,102.64 26.34,101.75 25.89,101.31 18.96,101.31 16.29,98.63 16.29,90.43 17.67,89.04 17.67,80.4 16.07,78.8 10.66,78.8 8.93,77.08 8.93,66.09 10.92,64.1 12.25,64.1 14.19,66.03 19.64,66.03 20.75,64.92 20.75,61.11 14.52,54.89 v2(14.52,48.03)
  BOTTOM w0.381: PU1201.8 40.31,103.09 PC1201.2
  BOTTOM w0.508: PD1801.1 v2(37.38,108.75) 37.38,105.57 38.41,104.55 39.54,104.55 39.81,104.28 PC1201.2
LOM_ACTLED_YEL#: length 11.8
  TOP w0.102: UL1.26 317.61,88.1 317.45,88.26 317.45,88.74 v2(317.27,88.92) ; v1(310.29,86.23) QL1.1 v2(310.29,88.27)
  IN1 w0.102: v2(310.29,88.27) 311.42,87.15 312.21,87.15 313.99,88.92 v2(317.27,88.92)
LOM_CABLE_DETECT#: length 67.7
  TOP w0.102: UL2.4 313.26,91.81 v2(313.1,91.97)
  TOP w0.104: v2(305.22,52.45) 305.94,51.73 305.94,50.22 306.42,49.73 306.42,47.9 RE505.1 306.42,47.47 306.42,44.64 306.32,44.54 306.32,42.51 306.51,42.32 309.04,42.32 309.48,41.87 310.18,41.87 310.59,41.46 311.09,41.46 311.17,41.38 311.17,41.38 312.42,40.13 312.42,39.53 313.23,38.71 313.27,38.71 313.6,38.39 314.04,38.39 314.48,37.95 UE1.D2
  IN3 w0.102: v2(305.22,52.45) 305.81,53.05 305.81,88.91 308.87,91.97 v2(313.1,91.97)
LOM_SPD10LED_GRN#: length 11.3
  TOP w0.102: QL2.1 311.34,92.04 311.24,91.94 311.24,91.24 RL30.2 311.84,91.27 312.1,91.53 313.67,91.53 314.04,91.16 UL2.2 316.68,91.16 v1(317.4,90.44) 317.65,90.19 317.65,88.79 317.94,88.5 UL1.25
LOM_SPD100LED_ORG#: length 9.8
  TOP w0.102: QL1.4 311.59,88.89 311.76,88.72 312.15,88.72 RL29.2 313.48,90.04 314.73,90.04 315.2,90.51 UL2.1 316.89,89.89 316.89,88.45 v1(317.08,88.26) 317.64,87.7 UL1.27
LPS_PROTECT#: length 1
  BOTTOM w0.102: PR1248.2 47.4,98.85 47.29,98.96 PT1.1
LPSS_UART2_RXD: length 14.1
  BOTTOM w0.089: UH1.BD20 213.81,33.93 214.53,33.93 214.69,34.09 216.1,34.09 216.15,34.04 217.46,34.04 218.64,35.21 219.84,35.21
  BOTTOM w0.102: 219.84,35.21 219.9,35.27 v1(223.59,35.27) 223.7,35.27 224.04,34.94 224.56,34.94 225.07,35.45 RH361.2 225.92,34.66 RH376.2
LPSS_UART2_TXD: length 80.9
  TOP w0.102: RH330.2 210.64,10.45 RH621.2 ; RH330.2 211.48,11.73 211.01,12.2 RH360.2 ; RH330.2 211.74,11.04 212.51,11.04 v2(212.77,11.3) ; v2(232.51,9.24) 232.51,9.56 232,10.07 232,12.35 233.96,14.31 233.96,14.98 234.92,15.94 234.92,16.94 235.13,17.14 235.13,20.18 236.54,21.6 236.54,24.77 237.03,25.25 237.03,30.07 236.11,30.98 236.11,33.15 v1(236.69,33.73) v2(237.63,34.67)
  IN2 w0.102: v2(232.51,9.24) 232.23,9.52 223.34,9.52 221.56,11.3 v2(212.77,11.3)
  BOTTOM w0.089: 219.82,35.46 219.75,35.39 218.54,35.39 217.38,34.23 216.23,34.23 216.18,34.28 214.61,34.28 214.49,34.15 UH1.BE20
  BOTTOM w0.102: 219.82,35.46 222.87,35.46 223.33,35.92 223.33,36.93 223.59,37.2 226.18,37.2 227.88,35.5 232.72,35.5 RH624.1 234.28,36.06 235.9,36.06 236.09,36.25 236.55,36.25 237.63,35.17 v2(237.63,34.67)
LX1_ISL88738:
  vias: v1(15.15,32.31) v2(13.15,32.19) v2(14.63,24.61) v2(14.64,23.86) v2(15.1,25.03) v2(15.78,24.95) v2(16.61,25.02) v2(16.61,24.36) v2(16.61,23.67) v2(16.65,23.01) v2(17.27,25.02) v2(17.27,24.36) v2(17.32,23.7) v2(17.28,23.01) v2(17.9,25.02) v2(17.9,24.36) v2(17.92,23.02) v2(17.95,23.7) v2(18.54,25.02) v2(18.54,24.36) v2(18.51,23.06) v2(18.56,23.7)
LX2_ISL88738: length 15.6
  TOP w0.102: v2(19.22,14.44) v1(19.22,13.73)
  IN3 w0.762: 14.59,14.88 12.09,17.39 12.09,21.81 10.49,23.41 10.49,28.07
  vias: v2(10.18,28.75) v2(10.77,28.75) v2(16.37,16.41) v2(16.56,15.77) v2(16.56,15.14) v2(16.56,14.44) v2(17,16.41) v2(17.19,15.77) v2(17.19,15.14) v2(17.19,14.44) v2(17.64,16.41) v2(17.83,15.77) v2(17.83,15.14) v2(17.83,14.44) v2(18.33,16.41) v2(18.53,15.77) v2(18.53,15.14) v2(18.53,14.44) v2(19.03,16.41) v2(19.22,15.77) v2(19.22,15.14)
LX_1.8VALW: length 0.5
  BOTTOM w0.102: 122.54,3.7 v1(122.54,3.2)
LX_1VS_VCCIO:
  vias: v1(143.57,57.12)
LX_3V:
  vias: v1(93.01,4.91) v2(85.64,5.77) v2(86.25,5.77) v2(91.11,5.99) v2(91.74,5.99)
LX_5V:
  vias: v2(124.43,128.74) v2(124.48,129.36) v2(124.48,128.09) v2(125.09,129.35) v2(125.07,128.7) v2(125.09,128.05) v2(125.29,134.1) v2(125.92,134.1) v2(125.96,127.4) v2(125.96,126.77) v2(125.96,126.13) v2(126.6,127.4) v2(126.6,126.77) v2(126.6,126.13) v2(127.23,127.4) v2(127.23,126.77) v2(127.23,126.13) v3(125.03,126.72)
LX_+1VALWP: length 0
  BOTTOM w0.254: 166.52,5.07 v2(166.48,5.07)
  vias: v1(170.43,4.53) v2(170.35,5.05) v2(170.94,5.04)
LX_DDR: length 0.8
  TOP w0.102: v1(48.8,7.39) 49.32,7.91 v2(49.32,7.98)
  vias: v2(49.3,8.71)
M2280_DEVSLP: length 174.6
  TOP w0.102: v1(351.31,7.45) v2(351.31,6.92) RN37.2
  IN2 w0.102: v2(206.56,26.43) 206.7,26.43 207.53,25.6 208.1,25.6 208.34,25.36 208.34,24.93 209.51,23.76 209.51,22.11 209.2,21.8 209.2,21.39 209.4,21.18 209.95,21.18 210.09,21.32 211.32,21.32 211.72,20.93 212.75,20.93 213.58,20.09 215.56,20.09 216.63,19.02 221,19.02 221.89,19.92 227.03,19.92 227.82,20.71 232,20.71 232.75,19.96 246.66,19.96 247.69,21 250.63,21 251.28,21.64 252.12,21.64 252.99,20.77 260.6,20.77 264.83,16.54 273.96,16.54 274.25,16.26 275.12,16.26 275.37,16.52 275.37,16.93 276.01,17.58 277.3,17.58 277.55,17.32 279.94,17.32 280.87,18.26 287.54,18.26 290.39,21.11 316.48,21.11 316.56,21.18 332.81,21.18 337.26,16.73 340.12,16.73 340.59,16.27 340.59,12.93 339.37,11.71 339.37,10.36 340.55,9.18 349.05,9.18 v2(351.31,6.92)
  BOTTOM w0.089: v2(206.56,26.43) 206.56,26.5 206.09,26.97 UH1.AH35
  BOTTOM w0.102: JNGFF3.38 351.3,6.91 v2(351.31,6.92)
M2280_PCIE_SATA#: length 173.9
  IN2 w0.102: v2(340.18,16.1) 340,15.93 337,15.93 333.74,19.19 333.05,19.19 331.29,20.95 318.55,20.95 314.03,16.43 298.41,16.43 293.96,20.88 290.48,20.88 287.63,18.03 280.97,18.03 280.04,17.1 277.45,17.1 277.2,17.35 276.11,17.35 275.6,16.84 275.6,16.42 275.1,15.93 268.42,15.93 268.03,16.31 264.73,16.31 260.7,20.35 254.73,20.35 254.54,20.54 247.88,20.54 246.85,19.51 232.51,19.51 231.77,20.25 228.06,20.25 227.23,19.43 222.04,19.43 221.18,18.57 214.39,18.57 212.76,20.2 207.37,20.2 207.14,20.42 204.89,20.42 v2(203.87,21.44)
  BOTTOM w0.089: UH1.AJ43 206.13,23.47 204.47,23.47 204.37,23.37 204.37,21.94 v2(203.87,21.44) 203.87,21.35 203.49,20.97 203.48,20.97 203.31,20.8 203.31,20.32 203.37,20.26 203.37,18.43 203.59,18.21 205.23,18.21 205.5,17.94 205.5,17.35 205.29,17.13 205.29,16.2 203.88,14.79 203.88,13.88
  BOTTOM w0.102: RH317.2 RH318.2 203.98,13.44 203.88,13.54 203.88,13.88 ; v2(340.18,16.1) v1(342.27,14.02) 343.55,12.73 JNGFF3.69
M3042_DEVSLP: length 192.7
  IN2 w0.102: v2(211.01,16.84) 211.26,16.84 211.36,16.75 234.43,16.75 236.14,15.04 252.87,15.04 253.59,14.31 335.76,14.31 v2(338.43,11.64)
  BOTTOM w0.089: v2(211.01,16.84) 210.51,16.84 208.77,18.59 208.77,19.64 209.26,20.13 209.26,20.6 209.67,21.01 UH1.AR47
  BOTTOM w0.102: JNGFF2.38 333.9,60 333.96,59.94 333.96,58.53 332.73,57.3 329.32,57.3 328.7,56.68 328.7,50.14 328.82,50.01 328.82,40.37 332.31,36.89 332.31,34.78 334.04,33.04 334.04,23.4 337.56,19.88 337.56,18.94 338.43,18.07 v1(338.43,15.25) v2(338.43,11.64)
M3042_PCIE#_SATA: length 181.6
  TOP w0.102: RH344.2 209.2,12.98 v1(209.74,13.51) 209.87,13.65 v2(209.87,14.04) ; v2(333.37,10.97) 334.62,10.97 335.02,10.57 339.84,10.57 v2(339.89,10.62)
  TOP w0.104: UE1.J12 322.92,33.55 324.28,33.55 v2(324.63,33.2)
  IN2 w0.102: v2(339.89,10.62) 340.82,11.55 340.82,17.1 335.05,22.87 333.08,22.87 331.58,24.37 327.73,24.37 325.32,26.78 325.32,32.66 324.79,33.2 v2(324.63,33.2) ; v2(209.87,14.04) 209.91,14.04 210.53,14.66 215.35,14.66 215.68,14.33 220.2,14.33 222.13,12.39 222.13,12.28 223.8,10.61 238.11,10.61 238.32,10.82 243.32,10.82 243.52,10.61 255.31,10.61 258.26,13.56 268.55,13.56 268.65,13.46 278.24,13.46 279.61,12.09 283.61,12.09 284.37,12.85 318.44,12.85 320.96,10.32 332.72,10.32 v2(333.37,10.97)
  BOTTOM w0.089: UH1.AM46 207.94,21.32 207.94,20.79 207.91,20.76 207.91,20.31 207.75,20.14 207.75,20.11 207.73,20.1 207.73,19.84 207.75,19.83 207.75,17.92 208.4,17.27 208.4,16.07 209.87,14.6 v2(209.87,14.04)
M_ID2#: length 12.8
  BOTTOM w0.102: JCRT1.4 363.65,94.51 363.01,94.51 360.98,92.48 v1(360.98,87.48) 360.98,86.64 360.31,85.97 CV135.1
MASK_BASE_LEDS#: length 2.2
  BOTTOM w0.102: UZ10.4 348.39,112.18 v1(348.82,111.75) 349.17,111.4 QZ7.5
MASK_SATA_LED#: length 52.4
  TOP w0.104: UE1.L6 v2(317.32,31.95)
  IN1 w0.099: v2(317.32,31.95) 317.38,31.95 317.76,32.33 318.35,32.33 318.5,32.48 318.5,33.71 318.31,33.9 317.86,33.9 317.74,34.02 317.74,34.79 318.81,35.86 318.81,38.56 319.11,38.87 319.11,39.36 319.75,40 320.79,40 321.54,40.75 321.54,41 321.91,41.37 322.12,41.37 323.32,42.57 324.45,42.57 326.17,44.29 326.17,44.69 v2(326.12,44.74)
  IN3 w0.102: v2(326.12,44.74) 326.21,44.83 326.21,46.28 325.6,46.89 325.6,50.9 324.92,51.58 324.92,59.03 v2(324.99,59.11)
  BOTTOM w0.102: v2(324.99,59.11) 324.82,59.28 v1(322.06,59.28) 319.64,59.28 319.19,58.83 309.8,58.83 309.42,59.21 308.54,59.21 QZ2.5
ME_FWP: length 178.1
  TOP w0.102: RH100.1 211.21,8.09 v1(211.51,8.39) v2(212.12,9)
  TOP w0.104: UE1.G12 v2(322.92,35.95)
  IN2 w0.102: v2(338.39,9.94) 338.3,10.03 333.34,10.03 332.2,8.89 315.98,8.89 314.77,10.11 306.84,10.11 306.5,9.77 304.9,9.77 304.52,10.15 301.76,10.15 300.99,10.92 297.9,10.92 296.87,11.95 284.54,11.95 282.56,9.97 279.51,9.97 277.6,11.87 267.23,11.87 266.38,11.02 259.65,11.02 256.59,7.96 250.59,7.96 250.17,8.38 239.95,8.38 239.34,7.77 235.26,7.77 234.43,6.94 229.69,6.94 228.91,7.71 227.9,7.71 227.75,7.56 215.88,7.56 214.98,8.46 212.66,8.46 v2(212.12,9)
  BOTTOM w0.102: v2(322.92,35.95) 324.32,35.95 326.01,37.63 329.13,37.63 329.7,38.2 330.67,38.2 332.02,36.85 332.02,34.74 333.82,32.94 333.82,23.31 337.33,19.79 337.33,18.84 338.02,18.15 338.02,10.31 v2(338.39,9.94) ; v2(212.12,9) 211.87,8.74 SW1.1
ME_FWP_PCH: length 67.3
  TOP w0.102: RH100.2 209.43,8.27 v2(208.94,8.76) ; v2(228.14,7.31) 227.96,7.49 227.96,12.53 228.52,13.09 228.8,13.09 230.81,15.1 230.81,18.23 231.14,18.56 231.14,22.2 232.34,23.4 232.34,25.51 232.74,25.91 232.74,28.41 232.72,28.41 230.77,30.36 v1(230.77,32.47) 230.77,34.21 230.5,34.48 230.5,38.11 229.05,39.57 v2(228.17,39.57)
  IN2 w0.102: v2(228.14,7.31) 228.12,7.33 215.78,7.33 214.88,8.23 209.47,8.23 v2(208.94,8.76)
  BOTTOM w0.089: 221.72,40.42 RH328.1
  BOTTOM w0.102: v2(208.94,8.76) 208.25,8.76 207.87,8.38 SW1.3 ; 221.72,40.42 221.73,40.43 222.1,40.43 222.43,40.1 227.63,40.1 v2(228.17,39.57)
ME_RESET#: length 2.6
  BOTTOM w0.102: v1(220.05,51.59) RH70.1 219.69,50.46 219.48,50.25 UC3.2
ME_SUS_PWR_ACK: length 156.6
  TOP w0.102: v2(232.52,23.01) 232.57,23.06 232.57,25.41 232.97,25.81 232.97,28.5 232.84,28.64 232.82,28.64 231.31,30.14 v1(231.31,39.03) 231.31,40.91 v2(231.31,40.92) ; 323.6,39.55 323.8,39.55 v2(323.9,39.65)
  TOP w0.104: UE1.B13 323.6,39.55
  IN1 w0.089: 223.61,25.78 219.71,25.78 v2(219.1,25.17)
  IN1 w0.099: v2(232.52,23.01) 232.21,23.31 231.11,23.31 230.93,23.5 227.9,23.5 226.03,25.37 224.76,25.37 224.34,25.78 223.61,25.78
  BOTTOM w0.089: v2(219.1,25.17) 219.29,25.36 219.74,25.36 RH444.2
  BOTTOM w0.102: v2(231.31,40.92) 231.41,40.81 238.18,40.81 242.28,36.71 244.57,36.71 246.44,34.84 266.63,34.84 267.24,34.23 271.88,34.23 272.27,33.84 279.92,33.84 285.03,38.95 285.03,44.74 290.9,50.62 302.45,50.62 304.17,48.89 311.59,48.89 313.09,50.39 314.24,50.39 315.49,51.64 320.95,51.64 321.64,50.95 323.74,50.95 323.98,50.71 323.98,48.47 321.84,46.33 321.84,44.86 322.39,44.31 322.39,43.77 323.36,42.79 323.36,40.31 323.9,39.77 v2(323.9,39.65)
ME_SUS_PWR_ACK_R: length 6.4
  BOTTOM w0.089: RH444.1 218.89,25.81 218.48,26.21 217,26.21 216.72,26.49 215.43,26.49 214.85,25.92 213.97,25.92 213.89,25.84 213.77,25.84 213.72,25.79 UH1.BC37
MEC_XTAL1: length 5.8
  TOP w0.102: YE1.1 312.54,44.32 v1(312.54,43.69) 312.8,43.43 CE28.1
  TOP w0.104: UE1.A1 313.45,40.62 313.45,41.05 312.83,41.67 312.83,42.66 CE28.1
MEC_XTAL2: length 2.8
  TOP w0.102: YE1.2 313.66,44.9 CE29.1 RE290.2
MEC_XTAL2_R: length 2.7
  TOP w0.102: 314.58,42.3 RE290.1
  TOP w0.104: 314.58,42.3 315.3,41.58 315.3,40.37 UE1.A3
MEDIACARD_IRQ#: length 318
  TOP w0.102: v2(12.95,73.1) 12.93,73.08 14.99,73.08 RR19.1 v1(15.09,71.92) 15.09,71.72 15.67,71.14 15.67,71.05 16.43,70.29 UR1.32
  IN2 w0.102: v2(174.04,76.22) 174.04,60.38 174.2,60.21 174.2,50.6 174.14,50.54 174.14,44.42 177.81,40.75 180.98,40.75 186,35.74 190.08,35.74 190.88,34.94 190.88,33.13 191.71,32.3 200.6,32.3 201.08,31.83 205.47,31.83 206.26,31.04 207.11,31.04 207.27,31.2 212.25,31.2 212.79,30.66 v2(212.95,30.66)
  IN3 w0.102: v2(174.04,76.22) 173.02,77.24 173.02,77.29 140.36,109.95 140.36,111.93 136.27,116.03 130.2,116.03 125.7,120.52 102.75,120.52 101.77,121.5 87.1,121.5 86.47,120.88 81.85,120.88 80.43,122.3 77.58,122.3 76.07,120.79 76.07,118.2 67.75,109.88 59.33,109.88 57.69,108.24 39.85,108.24 30.03,118.06 24.47,118.06 22.91,116.5 22.91,116.02 23.1,115.83 23.1,114.96 21.69,113.55 21.69,107.28 20.75,106.34 20.75,104.8 20.93,104.62 20.93,104.18 20.93,104.17 20.93,103.84 20.93,103.33 20.93,101.29 21.58,100.64 21.58,89.63 22.05,89.16 22.05,85.46 22.45,85.06 22.45,81.44 22.19,81.18 19.99,78.98 18.17,78.98 12.95,73.76 v2(12.95,73.1)
  BOTTOM w0.089: UH1.BB26 v2(212.95,30.66)
