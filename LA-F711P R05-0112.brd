# Allegro board LA-F711P R05-0112.brd (continued)
## Nets (continued)
+0.9V_LAN: CL3.1 CL4.1 CL8.1 CL9.1 CL10.1 CL11.1 CL12.1 LL1.2 UL1.8 UL1.11 UL1.16 UL1.22 UL1.37 UL1.40 UL1.43 UL1.46 UL1.47
+1.0V_ALW_PCH: CH29.1 PJP3.2 RH171.1 RH238.1 RH240.1 RH241.1 RH254.2 RH255.1 RH256.1 RH257.1 RH258.1 RH259.1 RH260.1 RH286.1 RH287.1 RH288.1 RH289.1 RH290.1
+1.0V_AMPHYPLL: CH267.1 CH324.1 RH289.2 UH1.C49 UH1.D49 UH1.E49
+1.0V_AZPLL: CH32.1 CH46.1 RH241.2 UH1.D1 UH1.E1
+1.0V_BCLKPLL2: CC330.1 LC2.1 RH259.2
+1.0V_BCLKPLL2_R: CC311.1 CH31.1 LC2.2 UH1.B1 UH1.B2 UH1.B3
+1.0V_CLPLLEBB: CC328.1 CH66.1 RH290.2 UH1.W31
+1.0V_DSW: CH35.1 RH255.2 UH1.BG45 UH1.BG46
+1.0V_DUSB: CH38.1 RH286.2 UH1.W22 UH1.W23
+1.0V_MPHY: CH34.1 CH47.1 PJP3.1 UH1.U26 UH1.U29 UH1.V25 UH1.V27 UH1.V28 UH1.V30 UH1.V31
+1.0V_OC: CH44.1 RH260.2 UH1.V19
+1.0V_OCPLL1: CC332.1 CH20.1 LC3.1 RH240.2
+1.0V_OCPLL1_R: CC331.1 LC3.2 UH1.C1 UH1.C2
+1.0V_PRIM: CH36.1 CZ100.1 CZ105.1 PJP302.2 RC216.1 RH254.1 UH1.AA22 UH1.AA23 UH1.AB20 UH1.AB22 UH1.AB23 UH1.AB27 UH1.AB28 UH1.AB30 UH1.AD20 UH1.AD23 UH1.AD27 UH1.AD28 UH1.AD30 UH1.AF23 UH1.AF27 UH1.AF30 UZ19.1 UZ19.2 UZ19.7 UZ21.1 UZ21.2 UZ21.7
+1.0V_PRIM_CNV_HVLO: RH257.2 UH1.AE17
+1.0V_PRIM_FUSE: RH256.2 UH1.AD31
+1.0V_PRIM_XDP: CC28.1 CC29.1 JXDP1.43 JXDP1.44 RC115.2 RC138.1 RC216.2
+1.0V_SRC: RH258.2 UH1.W19 UH1.W20
+1.0V_VCCSFR: CC192.2 CC333.2 RC304.2 UC1.H28 UC1.J28
+1.0V_VCCST: CC191.2 CC193.2 CC194.2 PC1702.2 PJP1.1 PR1704.1 PR1705.2 PR1706.1 PR1707.1 RC71.1 RC79.1 RC80.1 RC152.1 RC157.1 RC166.1 RC218.1 RC304.1 RE59.1 RE90.1 RZ151.2 UC1.H30
+1.0V_VCCST_C: CZ101.1 PJP1.2 UZ21.6
+1.0V_VCCSTG: CC186.2 CC195.2 CC334.1 CC335.1 PJP2.1 RC83.1 RC135.2 RC326.2 RH312.2 RH314.2 RH315.2 RZ151.1 UC1.H29
+1.0V_VCCSTG_C: CZ106.1 PJP2.2 UZ19.6
+1.0V_XTAL: CH45.1 RH238.2 UH1.P2 UH1.P3
+1.0VALWP: PC308.1 PC309.1 PC310.1 PC311.1 PC315.1 PC316.1 PC2036.1 PC2055.1 PJP302.1 PL301.2 PR313.1
+1.0VS_VCCIO: CC187.1 CC188.1 CC189.1 CC272.1 PJP401.2 QE11.1 RC1.2 RC2.1 RC132.1 RC439.2 UC1.AG12 UC1.G15 UC1.G17 UC1.G19 UC1.G21 UC1.H15 UC1.H16 UC1.H17 UC1.H19 UC1.H20 UC1.H21 UC1.H26 UC1.H27 UC1.J15 UC1.J16 UC1.J17 UC1.J19 UC1.J20 UC1.J21 UC1.J26 UC1.J27
+1.2V_DDR_B+: PC200.1 PC201.1 PC202.1 PC203.1 PJP202.2 PU200.10
+1.2V_DDRP: PC208.1 PC209.1 PC210.1 PC211.1 PC212.1 PC213.1 PC214.1 PC216.1 PC217.1 PC223.1 PC2050.1 PJP200.1 PL201.2 PR204.1 PU200.7 PU200.8
+1.2V_LDO: CR5.1 CR6.1 CR7.1 UR1.10 UR1.14
+1.2V_MEM: CC81.1 CC82.1 CC83.1 CC84.1 CC161.1 CC163.1 CC164.1 CC165.1 CC166.1 CC167.1 CC168.1 CC170.1 CC171.1 CC172.1 CC185.1 CD1.1 CD2.1 CD3.1 CD4.1 CD5.1 CD6.1 CD7.1 CD8.1 CD9.1 CD10.1 CD11.1 CD12.1 CD13.1 CD14.1 CD15.1 CD16.1 CD17.1 CD32.1 CD33.1 CD34.1 CD35.1 CD36.1 CD37.1 CD38.1 CD39.1 CD40.1 CD41.1 CD42.1 CD43.1 CD44.1 CD45.1 CD46.1 CD47.1 CD48.1 CD49.1 CD63.1 CD64.1 CZ102.2 JDIMM1.12 JDIMM1.33 JDIMM1.54 JDIMM1.75 JDIMM1.96 JDIMM1.111 JDIMM1.112 JDIMM1.117 JDIMM1.118 JDIMM1.123 JDIMM1.124 JDIMM1.129 JDIMM1.130 JDIMM1.135 JDIMM1.136 JDIMM1.141 JDIMM1.142 JDIMM1.147 JDIMM1.148 JDIMM1.153 JDIMM1.154 JDIMM1.159 JDIMM1.160 JDIMM1.163 JDIMM1.178 JDIMM1.199 JDIMM1.220 JDIMM1.241 JDIMM2.12 JDIMM2.33 JDIMM2.54 JDIMM2.75 JDIMM2.96 JDIMM2.111 JDIMM2.112 JDIMM2.117 JDIMM2.118 JDIMM2.123 JDIMM2.124 JDIMM2.129 JDIMM2.130 JDIMM2.135 JDIMM2.136 JDIMM2.141 JDIMM2.142 JDIMM2.147 JDIMM2.148 JDIMM2.153 JDIMM2.154 JDIMM2.159 JDIMM2.160 JDIMM2.163 JDIMM2.178 JDIMM2.199 JDIMM2.220 JDIMM2.241 PJP200.2 RD11.1 RD15.1 RD28.1 RZ119.1 UC1.AA6 UC1.AE12 UC1.AF5 UC1.AF6 UC1.AG5 UC1.AG9 UC1.AJ12 UC1.AL11 UC1.AP6 UC1.AP7 UC1.AR6 UC1.AR12 UC1.AT12 UC1.AW6 UC1.AY6 UC1.J5 UC1.J6 UC1.K6 UC1.K12 UC1.L6 UC1.L12 UC1.R6 UC1.T6 UC1.W6 UC1.Y12 UD1.5 UZ26.1 UZ26.2 UZ26.7
+1.2V_RUN: LT601.1 LT602.1 LT603.1 LT604.1 LT605.1 PJP504.2
+1.2V_VDD_A1: CT611.1 CT612.1 CT627.1 LT604.2 UT9.13
+1.2V_VDD_A2: CT45.1 CT46.1 CT626.1 LT603.2 UT9.47
+1.2V_VDD_DM_D1: CT614.1 CT615.1 CT616.1 CT617.1 CT618.1 CT628.1 LT605.2 UT9.1 UT9.10 UT9.16 UT9.30 UT9.38
+1.2V_VDD_R1: CT44.1 CT48.1 CT625.1 LT602.2 UT9.6
+1.2V_VDD_R2: CT47.1 CT610.1 CT629.1 LT601.2 UT9.7
+1.2V_VIN: PC508.1 PJP503.1 PU502.8
+1.8V_3.3V_ALW_VTR3: CE21.1 PJP20.2 PJP21.2 RE340.2 RE549.1 UE1.N5
+1.8V_ALW_PCHRES: RH247.1 RH250.1 RH294.1 RH295.1 RH296.1
+1.8V_PHVLDO: RH239.1 UH1.AF19 UH1.AF20
+1.8V_PRIM: CE22.1 CZ544.1 PJP20.1 PJP502.2 RH242.1 RH247.2 RH604.2 RH605.2 RH607.2 RH613.1 RH614.1 UZ8.1 UZ8.2 UZ61.5
+1.8V_PRIM_PCH: CH21.1 CH22.1 RH239.2 RH242.2 RZ376.1 RZ378.1 RZ543.2 UH1.AG19 UH1.AG20 UH1.AN15 UH1.AR15 UH1.BB11
+1.8V_RUN: CA65.1 CA66.1 PJP42.2 RA3.2
+1.8V_RUN_AUDIO: CA57.1 CA58.1 CA69.1 RA3.1 UA1.36 UA1.40
+1.8V_RUN_CARD: CR19.2 CR20.2 JSD1.14 UR1.13
+1.8V_RUN_UZ8: CZ120.1 PJP42.1 UZ8.7 UZ8.8
+1.8VALWP: PC501.1 PC503.1 PC504.1 PJP502.1 PL501.2 PR501.1
+1.24V_DPHY: RH237.1 UH1.AJ22 UH1.AJ23
+1.24V_DPHY_MAR: CH30.1 T75.1(TP-1) UH1.BG5
+1.24V_LDOSRAM: RH237.2 T74.1(TP-1) UH1.AK22 UH1.AK23
+1VALWP_B+: PC303.1 PC305.1 PC306.1 PC2039.1 PJP301.2 PL302.2 PU301.2 PU301.3 PU301.4 PU301.5
+1VS_VCCIOP: PC401.1 PC410.1 PC411.1 PC412.1 PJP401.1 PL401.2 PR414.1 PU401.1
+2.5V_MEM: CD18.1 CD19.1 CD20.1 CD21.1 CD50.1 CD51.1 CD52.1 CD53.1 JDIMM1.257 JDIMM1.259 JDIMM2.257 JDIMM2.259 PJP506.2
+2.5V_VIN: PC514.1 PJP505.2 PU503.8
+2.8V_FHV0: RH287.2 UH1.AF31
+2.8V_FHV1: RH288.2 UH1.AG31
+3.3V_1.8V_AZIO: CC329.1 LC1.1 RH292.2 RH295.2
+3.3V_1.8V_AZIO_R: CC310.1 CC327.1 LC1.2 UH1.BB14
+3.3V_1.8V_GPPA: RH95.2 RH291.2 RH294.2 RH327.2 RH340.2 UH1.AN32
+3.3V_1.8V_GPPD: RH293.2 RH296.2 UH1.AN24
+3.3V_1.8V_SPI: RH246.2 RH250.2 UH1.AN44
+3.3V_ALW: CE16.1 CE52.1 CE53.1 CE59.1 CE60.1 CE61.1 CV17.1 CZ57.1 CZ58.1 CZ68.1 CZ73.1 CZ82.1 CZ91.1 CZ93.1 CZ104.1 JAPS1.3 JAPS1.7 JKBTP1.15 JLED1.1 JUSH1.14 JUSH1.15 JUSH1.16 PC206.1 PC313.1 PJP21.1 PJP22.1 PJP102.2 PJP391.1 PJP501.1 PJP503.2 PJP505.1 PL502.1 PR1.1 PR4.2 PR28.2 PR29.1 PR107.1 PR113.1 PR205.2 PR405.1 PR417.1 PR418.1 PR517.2 PR607.1 PR933.1 PR1224.2 PR1225.2 PR1230.2 PR1231.2 PR1232.2 PR1233.2 PR1234.2 PR1235.2 PR1259.2 PR2013.1 PU200.13 PU301.15 QH7.3 QZ2.2 RC241.1 RE5.2 RE8.2 RE10.2 RE11.2 RE12.2 RE21.2 RE25.1 RE35.2 RE37.2 RE38.2 RE43.2 RE63.2 RE68.2 RE69.1 RE71.1 RE72.1 RE73.1 RE74.1 RE75.1 RE79.1 RE83.2 RE84.2 RE91.2 RE92.2 RE300.1 RE301.2 RE302.2 RE303.2 RE343.2 RE362.2 RE365.2 RE505.2 RE526.1 RE532.1 RE561.2 RH431.2 RH432.1 RH434.2 RPE7.5 RPE7.6 RPE7.7 RPE7.8 RPE9.5 RPE9.6 RPE9.7 RPE9.8 RPE11.5 RPE11.6 RPE11.7 RPE11.8 RPE12.5 RPE12.6 RPE12.7 RPE12.8 RT68.2 RV1656.1 RZ8.1 RZ9.1 RZ369.1 RZ377.1 RZ380.1 RZ381.1 RZ518.1 UE3.5 UE4.5 UE5.5 UE6.5 UV24.5 UZ2.1 UZ2.2 UZ2.6 UZ2.7 UZ3.1 UZ3.2 UZ3.6 UZ3.7 UZ4.6 UZ4.7 UZ6.5 UZ10.5 UZ34.5 UZ35.5
+3.3V_ALW2: PR104.2 RE57.2
+3.3V_ALW_DSW_R: QH7.1 RH439.2
+3.3V_ALW_PCH: DH3.2 JAPS1.1 JSPI1.16 PJP38.2 RC74.1 RC133.1 RC137.2 RC557.2 RH56.1 RH57.1 RH61.1 RH67.1 RH77.1 RH78.1 RH80.1 RH81.1 RH86.1 RH101.1 RH185.1 RH203.2 RH204.2 RH279.1 RH309.1 RH310.1 RH311.1 RH329.2 RH330.1 RH371.2 RH376.1 RH400.2 RH440.1 RH553.2 RH555.2 RPH6.5 RPH6.6 RPH6.7 RPH6.8 RPH7.5 RPH7.6 RPH7.7 RPH7.8 RZ69.1 RZ368.1 RZ375.1 RZ379.1 UH7.5
+3.3V_ALW_PCH_UZ3: CZ112.1 PJP38.1 UZ3.13 UZ3.14
+3.3V_ALW_PCHRES: RH246.1 RH279.2 RH291.1 RH292.1 RH293.1 RH298.1 RH299.1 RH300.1 RH302.1 RH303.1 RH304.1 RH305.1 RH306.1
+3.3V_ALW_UE1: CE13.1 CE14.1 CE15.1 CE19.1 CE20.1 CE23.1 PJP22.2 RE314.2 UE1.B7 UE1.G8 UE1.H1 UE1.K2 UE1.M9
+3.3V_ALW_UZ12: CZ51.1 CZ52.1 PJP391.2 UZ12.1
+3.3V_ALWP: PC106.1 PC107.1 PC108.1 PC109.1 PC110.1 PC129.1 PC2040.1 PJP102.1 PL100.2 PR108.2 PU100.14
+3.3V_CAM: CV22.1 CV23.1 CZ1.1 JEDP1.11 QZ1.1
+3.3V_CPS: CT117.1 CT118.1 LT11.2 UT9.27 UT9.52
+3.3V_DSW: CH63.1 RH92.2 RH93.2 RH94.2 RH243.2 RH434.1 RH439.1 RH440.2 RH602.2 UH1.BE48 UH1.BE49
+3.3V_EC_PLL: CE17.1 CE18.1 RE314.1 UE1.F1
+3.3V_FUSE: RH300.2 UH1.AT44
+3.3V_HDD: CN10.1 CN11.1 CN16.1 CN17.1 JSATA1.9 JSATA1.10 PJP34.2 RN3.1 RN6.1 RN8.2 RN10.2 RN12.1 RN14.1 RN16.1 RN18.1 RN20.1 UN7.10 UN7.20
+3.3V_HDD_M2: CN60.1 CN61.1 CN62.1 CN63.1 CN64.1 JNGFF3.2 JNGFF3.4 JNGFF3.12 JNGFF3.14 JNGFF3.16 JNGFF3.18 JNGFF3.70 JNGFF3.72 JNGFF3.74 PJP31.1 RN37.1 RZ99.1
+3.3V_LAN: CL15.1 CL18.1 CL19.1 JLOM1.9 JLOM1.12 PJP37.2 RL1.2 RL2.2 RL4.2 RL5.2 RL6.2 RL8.2 RL29.1 RL30.1 RL70.1 UL2.5
+3.3V_LAN_OUT: CL7.1 CL28.1 CL29.1 CL30.1 RL8.1 UL1.4 UL1.5 UL1.15 UL1.19 UL1.29
+3.3V_LAN_UZ2: CZ111.1 PJP37.1 UZ2.8 UZ2.9
+3.3V_M_TPM: CZ59.1 CZ60.1 RZ366.2 RZ367.1 RZ368.2 RZ369.2
+3.3V_MMI_AUX: CR1.1 CR2.1 CR27.1 CR28.1 R274.2 RR3.1 RR19.2 UR1.27
+3.3V_MMI_IN: CR3.1 CR4.1 CR25.1 CR26.1 PJP14.2 R274.1 UR1.11
+3.3V_PDA_VOUT: CT83.1 UT5.H2
+3.3V_PGPPBC: RH304.2 UH1.AN26 UH1.AP26
+3.3V_PGPPEF: CH62.1 RH303.2 UH1.AE35 UH1.AE36
+3.3V_PGPPG: RH305.2 UH1.AN21
+3.3V_PGPPHK: CH64.1 RH306.2 UH1.AC35 UH1.AC36
+3.3V_PHVC: RH299.2 UH1.AW9
+3.3V_PHVLDO: CH37.1 CH67.1 CH323.1 RH298.2 UH1.AY8 UH1.BB7
+3.3V_PRTC: CH33.1 CH65.1 RH297.2 UH1.BC49 UH1.BD49
+3.3V_PUSB2: RH302.2 UH1.V23
+3.3V_RTC_LDO: PD3.3 PR105.2
+3.3V_RUN: CA7.1 CH10.1 CN1.1 CN2.1 CN3.1 CV7.1 CV61.1 CV62.1 CV100.1 CV106.1 CZ67.1 CZ72.1 JEDP1.10 JESPI.1 JESPI.2 JUSH1.19 LGA1.2 LGA1.3 LGA1.9 LGA1.10 LV14.1 LV30.1 PJP14.1 PJP18.1 PJP31.2 PJP34.1 PJP35.1 PJP39.2 PR1716.1 QH4.2 QH4.5 QV3.2 QV3.5 QV5.2 QZ1.3 RC370.2 RD4.1 RD6.1 RD8.1 RD10.1 RD19.1 RD20.1 RD22.1 RD24.1 RD26.1 RE48.1 RE51.1 RE67.2 RE547.2 RH76.1 RH90.1 RH123.2 RH124.2 RH125.2 RH126.2 RH127.2 RH131.2 RH132.2 RH133.2 RH199.2 RH207.1 RH214.1 RH221.2 RH222.2 RH223.2 RH224.2 RH225.2 RH267.2 RH316.1 RH318.1 RH319.1 RH324.1 RH331.1 RH333.2 RH339.1 RH344.1 RH345.1 RH348.1 RH355.1 RH360.1 RH361.1 RH373.2 RH374.2 RH375.1 RH378.1 RH380.1 RH402.1 RN2.1 RN4.1 RN226.1 RT397.1 RV8.2 RV18.1 RV19.2 RV20.2 RV71.2 RV79.2 RV81.2 RV83.2 RV106.2 RV107.2 RV124.1 RV326.1 RV620.1 RV621.1 RV622.1 RV632.2 RZ89.1 RZ99.2 RZ362.1 RZ365.2 RZ542.2 UC3.5 UV6.14 UV6.26 UV9.1 UV9.6 UV9.12 UV9.25 UV9.32 UV9.36 UZ5.6 UZ5.7
+3.3V_RUN_AUDIO: CA67.1 CA68.1 LA12.2 LA14.2 PJP16.2 PJP18.2 RA18.2 RA59.1 RA61.1
+3.3V_RUN_AUDIO_DVDD: CA10.1 CA61.1 LA14.1 UA1.1
+3.3V_RUN_AUDIO_IO: CA55.1 CA56.1 LA12.1 UA1.9
+3.3V_RUN_AUDIO_UZ5: CZ128.1 PJP16.1 UZ5.8 UZ5.9
+3.3V_RUN_CARD: CR17.2 CR18.2 JSD1.4 UR1.12
+3.3V_RUN_DIMM1: CD27.1 CD28.1 JDIMM1.255 RD10.2
+3.3V_RUN_DIMM2: CD59.1 CD60.1 JDIMM2.255 RD26.2
+3.3V_RUN_UT9: LT11.1 RT131.2 RT135.2 RT137.2 RT139.2 RT141.2 RT246.1 RT303.1 RT304.2 RT305.2 RT308.2 RT397.2 RT398.2
+3.3V_RUN_UZ3: CZ115.1 PJP39.1 UZ3.8 UZ3.9
+3.3V_SPI: CH9.1 CH270.1 DH3.1 JSPI1.15 RH30.1 RH185.2 RH335.1 RH600.1 RH601.1 RH615.1 UC5.8 UC6.8
+3.3V_TBTA_FLASH: CT70.1 CT84.1 JDB1.1 RT50.1 RT51.1 RT52.1 RT53.1 RT66.2 RT67.2 RT76.2 RT95.2 RT98.2 RT106.2 RT107.2 RT378.2 RT379.2 UT5.G1 UT6.8
+3.3V_TP: CZ83.1 CZ90.1 JKBTP1.9 PJP35.2 RZ18.1 RZ19.1 RZ20.1 RZ21.1 RZ116.1 RZ117.1
+3.3V_VDD_DCI: CT119.1 RT303.2 UT9.49
+3.3V_VDD_DCIN: PC9.1 PC10.1 PD1801.3 PR17.1 PR27.2 PR1206.1 PR1208.1 PU1.5 PU2.3
+3.3V_VDD_PIC: CT91.1 CT92.1 PC1204.1 PD1801.2 PJP7.1 PR1214.1 PR1226.1 PR1236.2 PR1237.1 PR1240.1 PR1253.1 PR1254.2 PU1200.5 QT1.2 QT1.5 RT398.1 UT7.5
+3.3V_VDD_PIC_PDA: CT74.1 PJP7.2 UT5.B1 UT5.H1
+3.3V_VGA: LV14.2 UV6.1
+3.3V_WLAN: CZ6.1 CZ7.1 CZ8.1 CZ9.1 CZ27.1 CZ28.1 CZ29.1 CZ30.1 CZ31.1 CZ32.1 CZ33.1 CZ34.1 CZ35.1 CZ36.1 JNGFF1.2 JNGFF1.4 JNGFF1.72 JNGFF1.74 PJP36.2 RZ96.2
+3.3V_WLAN_UZ4: CZ122.1 PJP36.1 RZ96.1 UZ4.8 UZ4.9
+3.3V_WWAN: CZ4.1 CZ5.1 CZ17.1 CZ18.1 CZ19.1 CZ20.1 CZ21.1 CZ23.1 CZ24.1 CZ25.1 CZ26.1 CZ154.1 CZ155.1 JNGFF2.2 JNGFF2.4 JNGFF2.70 JNGFF2.72 JNGFF2.74 PJP41.2 RZ43.2 UZ29.1 UZ29.6 UZ29.10
+3.3V_WWAN_UZ2: CZ119.1 CZ124.1 PJP41.1 UZ2.13 UZ2.14
+5V_ALW: CI6.1 CI7.1 CI9.1 CI11.1 CI12.1 CI19.1 CI31.1 CI33.1 CI34.1 CZ64.1 CZ69.1 DT1.2 JLED1.6 JUSH1.18 LED3.2 PC1814.1 PC1824.1 PC1908.1 PC1918.1 PC2008.1 PC2018.1 PJP8.1 PJP103.2 PJP402.1 PL405.1 PR7.1 PR1745.1 PR1754.1 PR1800.1 PR1804.1 PR1900.1 PR1904.1 PR2000.1 PR2004.1 PR2007.1 PU1800.2 PU1800.15 PU1801.2 PU1801.15 PU1900.2 PU1900.15 PU1901.2 PU1901.15 PU2000.2 PU2000.15 PU2001.15 RA53.2 RI13.2 RV9.2 UI1.5 UI2.5 UI3.1 UI3.7 UI3.8 UZ2.4 UZ3.4 UZ4.1 UZ4.2 UZ4.4 UZ5.4 UZ8.4 UZ19.3 UZ21.3 UZ23.1 UZ23.2 UZ23.4 UZ26.3
+5V_ALW2: PC126.1 PU102.15
+5V_ALW_PDA: CT22.1 CT75.1 CT76.1 CT77.1 CT78.1 PJP8.2 UT5.A11 UT5.B11 UT5.C11 UT5.D11 UT5.H10
+5V_ALWP: PC120.1 PC121.1 PC122.1 PC123.1 PC124.1 PC130.1 PJP103.1 PL101.2 PR117.2 PU102.14
+5V_HDD: CN8.1 CN9.1 JSATA1.15 JSATA1.16 JSATA1.17 PJP32.2 PJP33.1 RN1.1 RZ102.2 RZ108.2
+5V_HDD_UZ23: CZ129.1 PJP32.1 RZ102.1 UZ23.7 UZ23.8
+5V_PD_VDD: CT88.1 CT89.1 DT1.1 DT2.1 RT111.1 RT393.1 UT7.1
+5V_RUN: CE32.1 CV39.1 CZ66.1 CZ71.1 CZ92.1 DE1.1 JFAN1.4 JKBTP1.16 JUSH1.20 PJP17.1 PJP33.2 PJP40.2 QV8.3 RV6.2 RZ108.1 RZ370.1 UV2.1 UV4.1 UZ5.1 UZ5.2
+5V_RUN_AUDIO: CA59.1 CA60.1 CA63.1 CA64.1 LA5.2 LA13.2 PJP15.1 PJP17.2
+5V_RUN_AUDIO_UZ5: CZ125.1 PJP15.2 UZ5.13 UZ5.14
+5V_RUN_CHG: QZ4.1 RZ370.2
+5V_RUN_PVDD_L: CA45.1 CA46.1 CA47.1 CA48.1 LA13.1 UA1.41 UA1.46
+5V_RUN_UZ4: CZ116.1 PJP40.1 UZ4.13 UZ4.14
+5V_TBT_VBUS: CT93.1 DT2.2 DT3.1
+5V_TBTA_VBUS_D: DT3.2 UT8.3
+5V_TSP: CV18.1 CV19.1 CZ2.1 JEDP1.1 QV8.1
+5V_USB_CHG_PWR: CI14.1 CI17.1 CI32.1 CI43.1 CI44.1 JUSB1.1 UI3.12
+DV33_18: CR22.1 UR1.18
+GND_CHASSIS: CL22.2 RL15.2 RL16.2 RL17.2 RL18.2
+VBUS_DC_SS: PD903.2 PD1202.2 PD1202.3 PQ1202.5 PQ1213.5
+VCC1V8A_TBTA_LDO: CT73.1 UT5.K1
+VCC1V8D_TBTA_LDO: CT72.1 RT97.1 UT5.A2
+VCC_CORE: PC800.1 PC801.1 PC802.1 PC803.1 PC804.1 PC805.1 PC806.1 PC819.1 PC820.1 PC821.1 PC822.1 PC823.1 PC824.1 PC825.1 PC826.1 PC827.1 PC828.1 PC829.1 PC830.1 PC831.1 PC832.1 PC833.1 PC851.1 PC852.1 PC1021.1 PC1022.1 PC1041.1 PC1042.1 PC1043.1 PC1044.1 PC1045.1 PC1046.1 PC1047.1 PC1048.1 PC1049.1 PC1050.1 PC1051.1 PC1052.1 PC1053.1 PC1054.1 PC1055.1 PC1056.1 PC1074.1 PC1075.1 PC1076.1 PC1077.1 PC1078.1 PC1079.1 PC1080.1 PC1081.1 PC1082.1 PC1083.1 PC1084.1 PC1085.1 PC1086.1 PC1087.1 PC1103.1 PC1104.1 PC1105.1 PC1106.1 PC1107.1 PC1108.1 PC1109.1 PC1111.1 PC1112.1 PC1113.1 PC1114.1 PC1115.1 PC1116.1 PC1132.1 PC1133.1 PC1134.1 PC1135.1 PC1136.1 PC1137.1 PC1138.1 PC1139.1 PC1140.1 PC1141.1 PC1142.1 PC1143.1 PC1144.1 PC1145.1 PC1146.1 PC1162.1 PC1163.1 PC1164.1 PC1165.1 PC1166.1 PC1167.1 PC1168.1 PC1169.1 PC1170.1 PC1171.1 PC1172.1 PC1173.1 PC1174.1 PC1175.1 PC1176.1 PC1177.1 PC1178.1 PC1179.1 PC1180.1 PC1181.1 PC2026.1 PL1802.4 PL1803.4 PL1900.4 PL1901.4 PR1721.1 RC140.1 UC1.AA13 UC1.AA31 UC1.AA32 UC1.AA33 UC1.AA34 UC1.AA35 UC1.AA36 UC1.AA37 UC1.AA38 UC1.AB29 UC1.AB30 UC1.AB31 UC1.AB32 UC1.AB35 UC1.AB36 UC1.AB37 UC1.AB38 UC1.AC13 UC1.AC14 UC1.AC29 UC1.AC30 UC1.AC31 UC1.AC32 UC1.AC33 UC1.AC34 UC1.AC35 UC1.AC36 UC1.AD13 UC1.AD14 UC1.AD31 UC1.AD32 UC1.AD33 UC1.AD34 UC1.AD35 UC1.AD36 UC1.AD37 UC1.AD38 UC1.AE13 UC1.AE14 UC1.AE30 UC1.AE31 UC1.AE32 UC1.AE35 UC1.AE36 UC1.AE37 UC1.AE38 UC1.AF29 UC1.AF30 UC1.AF31 UC1.AF32 UC1.AF33 UC1.AF34 UC1.AF35 UC1.AF36 UC1.AF37 UC1.AF38 UC1.AG14 UC1.AG31 UC1.AG32 UC1.AG33 UC1.AG34 UC1.AG35 UC1.AG36 UC1.AH13 UC1.AH14 UC1.AH29 UC1.AH30 UC1.AH31 UC1.AH32 UC1.AJ14 UC1.AJ29 UC1.AJ30 UC1.AJ31 UC1.AJ32 UC1.AJ33 UC1.AJ34 UC1.AJ35 UC1.AJ36 UC1.AK31 UC1.AK32 UC1.AK33 UC1.AK34 UC1.AK35 UC1.AK36 UC1.AK37 UC1.AK38 UC1.AL13 UC1.AL29 UC1.AL30 UC1.AL31 UC1.AL32 UC1.AL35 UC1.AL36 UC1.AL37 UC1.AL38 UC1.AM13 UC1.AM14 UC1.AM29 UC1.AM30 UC1.AM31 UC1.AM32 UC1.AM33 UC1.AM34 UC1.AM35 UC1.AM36 UC1.AN13 UC1.AN14 UC1.AN31 UC1.AN32 UC1.AN33 UC1.AN34 UC1.AN35 UC1.AN36 UC1.AN37 UC1.AN38 UC1.AP13 UC1.AP30 UC1.AP31 UC1.AP32 UC1.AP35 UC1.AP36 UC1.AP37 UC1.AP38 UC1.K13 UC1.K14 UC1.L13 UC1.L14 UC1.N13 UC1.N14 UC1.N30 UC1.N31 UC1.N32 UC1.N35 UC1.N36 UC1.N37 UC1.N38 UC1.P13 UC1.P14 UC1.P29 UC1.P30 UC1.P31 UC1.P32 UC1.P33 UC1.P34 UC1.P35 UC1.P36 UC1.R13 UC1.R31 UC1.R32 UC1.R33 UC1.R34 UC1.R35 UC1.R36 UC1.R37 UC1.R38 UC1.T29 UC1.T30 UC1.T31 UC1.T32 UC1.T35 UC1.T36 UC1.T37 UC1.T38 UC1.U29 UC1.U30 UC1.U31 UC1.U32 UC1.U33 UC1.U34 UC1.U35 UC1.U36 UC1.V13 UC1.V14 UC1.V31 UC1.V32 UC1.V33 UC1.V34 UC1.V35 UC1.V36 UC1.V37 UC1.V38 UC1.W13 UC1.W14 UC1.W29 UC1.W30 UC1.W31 UC1.W32 UC1.W35 UC1.W36 UC1.W37 UC1.W38 UC1.Y29 UC1.Y30 UC1.Y31 UC1.Y32 UC1.Y33 UC1.Y34 UC1.Y35 UC1.Y36
+VCC_FUSEPRG: RC326.1 UC1.G30
+VCC_GT: PC848.1 PC849.1 PC1001.1 PC1002.1 PC1003.1 PC1004.1 PC1005.1 PC1006.1 PC1007.1 PC1008.1 PC1009.1 PC1010.1 PC1011.1 PC1012.1 PC1013.1 PC1014.1 PC1015.1 PC1016.1 PC1017.1 PC1018.1 PC1019.1 PC1023.1 PC1024.1 PC1025.1 PC1026.1 PC1027.1 PC1028.1 PC1029.1 PC1030.1 PC1031.1 PC1032.1 PC1088.1 PC1089.1 PC1090.1 PC1091.1 PC1092.1 PC1093.1 PC1094.1 PC1095.1 PC1096.1 PC1097.1 PC1098.1 PC1099.1 PC2027.1 PC2028.1 PC2029.1 PC2030.1 PC2031.1 PL2000.4 PR1725.2 UC1.AT14 UC1.AT31 UC1.AT32 UC1.AT33 UC1.AT34 UC1.AT35 UC1.AT36 UC1.AT37 UC1.AT38 UC1.AU14 UC1.AU29 UC1.AU30 UC1.AU31 UC1.AU32 UC1.AU35 UC1.AU36 UC1.AU37 UC1.AU38 UC1.AV29 UC1.AV30 UC1.AV31 UC1.AV32 UC1.AV33 UC1.AV34 UC1.AV35 UC1.AV36 UC1.AW14 UC1.AW31 UC1.AW32 UC1.AW33 UC1.AW34 UC1.AW35 UC1.AW36 UC1.AW37 UC1.AW38 UC1.AY29 UC1.AY30 UC1.AY31 UC1.AY32 UC1.AY35 UC1.AY36 UC1.AY37 UC1.AY38 UC1.BA13 UC1.BA14 UC1.BA29 UC1.BA30 UC1.BA31 UC1.BA32 UC1.BA33 UC1.BA34 UC1.BA35 UC1.BA36 UC1.BB13 UC1.BB14 UC1.BB31 UC1.BB32 UC1.BB33 UC1.BB34 UC1.BB35 UC1.BB36 UC1.BB37 UC1.BB38 UC1.BC29 UC1.BC30 UC1.BC31 UC1.BC32 UC1.BC35 UC1.BC36 UC1.BC37 UC1.BC38 UC1.BD13 UC1.BD14 UC1.BD29 UC1.BD30 UC1.BD31 UC1.BD32 UC1.BD33 UC1.BD34 UC1.BD35 UC1.BD36 UC1.BE31 UC1.BE32 UC1.BE33 UC1.BE34 UC1.BE35 UC1.BE36 UC1.BE37 UC1.BE38 UC1.BF13 UC1.BF14 UC1.BF29 UC1.BF30 UC1.BF31 UC1.BF32 UC1.BF35 UC1.BF36 UC1.BF37 UC1.BF38 UC1.BG29 UC1.BG30 UC1.BG31 UC1.BG32 UC1.BG33 UC1.BG34 UC1.BG35 UC1.BG36 UC1.BH33 UC1.BH34 UC1.BH35 UC1.BH36 UC1.BH37 UC1.BH38 UC1.BJ16 UC1.BJ17 UC1.BJ19 UC1.BJ20 UC1.BJ21 UC1.BJ23 UC1.BJ24 UC1.BJ26 UC1.BJ27 UC1.BJ37 UC1.BJ38 UC1.BK16 UC1.BK17 UC1.BK19 UC1.BK20 UC1.BK21 UC1.BK23 UC1.BK24 UC1.BK26 UC1.BK27 UC1.BL15 UC1.BL16 UC1.BL17 UC1.BL23 UC1.BL24 UC1.BL25 UC1.BL26 UC1.BL27 UC1.BL28 UC1.BL36 UC1.BL37 UC1.BM15 UC1.BM16 UC1.BM17 UC1.BM36 UC1.BM37 UC1.BN15 UC1.BN16 UC1.BN17 UC1.BN36 UC1.BN37 UC1.BN38 UC1.BP15 UC1.BP16 UC1.BP17 UC1.BP37 UC1.BP38 UC1.BR15 UC1.BR16 UC1.BR17 UC1.BR37 UC1.BT15 UC1.BT16 UC1.BT17 UC1.BT37
+VCC_SA: PC807.1 PC808.1 PC809.1 PC810.1 PC811.1 PC812.1 PC813.1 PC815.1 PC816.1 PC817.1 PC818.1 PC834.1 PC835.1 PC836.1 PC837.1 PC838.1 PC839.1 PC840.1 PC841.1 PC842.1 PC843.1 PC844.1 PL2001.4 PR1714.1 UC1.J30 UC1.K29 UC1.K30 UC1.K31 UC1.K32 UC1.K33 UC1.K34 UC1.K35 UC1.L31 UC1.L32 UC1.L35 UC1.L36 UC1.L37 UC1.L38 UC1.M29 UC1.M30 UC1.M31 UC1.M32 UC1.M33 UC1.M34 UC1.M35 UC1.M36
+VCC_SFR_OC: CC209.2 CC210.2 CC322.1 CZ103.1 RZ119.2 UC1.BH13 UC1.BJ13 UC1.G11 UZ26.6
+VCCK_12: CV103.1 CV104.1 CV105.1 UV6.4 UV6.25
+VCCRTCEXT: CH68.1 UH1.BF47 UH1.BG47
+VDD_DAC_33: LV30.2 UV6.20
+VDDA_AVDD1: CA8.1 CA9.1 LA5.1 UA1.26
+VSS_PLL: CE17.2 CE18.2 UE1.G1
GND: CA5.2 CA6.2 CA7.2 CA10.2 CA12.2 CA13.1 CA19.2 CA22.2 CA23.2 CA24.2 CA31.2 CA33.2 CA45.2 CA46.2 CA47.2 CA48.2 CA49.2 CA53.2 CA54.2 CA55.2 CA56.2 CA59.2 CA60.2 CA61.2 CA62.2 CA63.2 CA64.2 CA65.2 CA66.2 CA67.2 CA68.2 CA69.2 CA72.2 CA73.2 CA74.2 CA75.2 CA76.2 CC28.2 CC29.2 CC32.2 CC33.2 CC81.2 CC82.2 CC83.2 CC84.2 CC161.2 CC163.2 CC164.2 CC165.2 CC166.2 CC167.2 CC168.2 CC170.2 CC171.2 CC172.2 CC185.2 CC186.1 CC187.2 CC188.2 CC189.2 CC191.1 CC192.1 CC193.1 CC194.1 CC195.1 CC209.1 CC210.1 CC269.2 CC272.2 CC300.2 CC301.2 CC302.2 CC303.2 CC304.2 CC305.2 CC306.2 CC307.2 CC308.2 CC310.2 CC311.2 CC316.2 CC318.2 CC319.2 CC320.2 CC322.2 CC323.2 CC324.2 CC325.2 CC327.2 CC328.2 CC329.2 CC330.2 CC331.2 CC332.2 CC333.1 CC334.2 CC335.2 CD1.2 CD2.2 CD3.2 CD4.2 CD5.2 CD6.2 CD7.2 CD8.2 CD9.2 CD10.2 CD11.2 CD12.2 CD13.2 CD14.2 CD15.2 CD16.2 CD17.2 CD18.2 CD19.2 CD20.2 CD21.2 CD22.2 CD23.2 CD24.2 CD25.2 CD26.2 CD27.2 CD28.2 CD29.2 CD32.2 CD33.2 CD34.2 CD35.2 CD36.2 CD37.2 CD38.2 CD39.2 CD40.2 CD41.2 CD42.2 CD43.2 CD44.2 CD45.2 CD46.2 CD47.2 CD48.2 CD49.2 CD50.2 CD51.2 CD52.2 CD53.2 CD54.2 CD55.2 CD56.2 CD57.2 CD58.2 CD59.2 CD60.2 CD61.2 CD63.2 CD64.2 CE3.2 CE4.2 CE8.2 CE10.2 CE11.2 CE12.2 CE13.2 CE14.2 CE15.2 CE16.2 CE19.2 CE20.2 CE21.2 CE22.2 CE23.2 CE25.2 CE28.2 CE29.2 CE30.2 CE31.2 CE32.2 CE36.2 CE38.2 CE40.2 CE47.2 CE52.2 CE53.2 CE54.2 CE57.2 CE59.2 CE60.2 CE61.2 CE62.2 CE63.2 CE64.2 CE65.2 CE66.2 CH4.1 CH5.1 CH9.2 CH10.2 CH13.2 CH14.2 CH20.2 CH21.2 CH22.2 CH29.2 CH30.2 CH31.2 CH32.2 CH33.2 CH34.2 CH35.2 CH36.2 CH37.2 CH38.2 CH40.1 CH41.1 CH44.2 CH45.2 CH46.2 CH47.2 CH62.2 CH63.2 CH64.2 CH65.2 CH66.2 CH67.2 CH68.2 CH266.2 CH267.2 CH268.1 CH270.2 CH321.2 CH322.2 CH323.2 CH324.2 CH340.2 CH341.2 CH342.2 CH343.2 CH344.2 CH345.2 CH346.2 CH347.2 CH348.2 CI1.2 CI3.2 CI6.2 CI7.2 CI8.2 CI9.2 CI10.2 CI11.2 CI12.2 CI14.2 CI17.2 CI19.2 CI31.2 CI32.2 CI33.2 CI34.2 CI43.2 CI44.2 CI45.2 CI46.2 CI47.2 CI48.2 CL3.2 CL4.2 CL7.2 CL8.2 CL9.2 CL10.2 CL11.2 CL12.2 CL13.2 CL14.2 CL15.2 CL16.2 CL17.2 CL18.2 CL19.2 CL20.2 CL21.2 CL22.1 CL28.2 CL29.2 CL30.2 CMOS1.1 CN1.2 CN2.2 CN3.2 CN8.2 CN9.2 CN10.2 CN11.2 CN16.2 CN17.2 CN60.2 CN61.2 CN62.2 CN63.2 CN64.2 CR1.2 CR2.2 CR3.2 CR4.2 CR5.2 CR6.2 CR7.2 CR15.2 CR17.1 CR18.1 CR19.1 CR20.1 CR21.2 CR22.2 CR25.2 CR26.2 CR27.2 CR28.2 CT22.2 CT44.2 CT45.2 CT46.2 CT47.2 CT48.2 CT70.2 CT71.2 CT72.2 CT73.2 CT74.2 CT75.2 CT76.2 CT77.2 CT78.2 CT82.2 CT83.2 CT84.2 CT85.2 CT86.2 CT87.2 CT88.2 CT89.2 CT90.2 CT91.2 CT92.2 CT93.2 CT94.2 CT99.2 CT100.2 CT101.2 CT102.2 CT117.2 CT118.2 CT119.2 CT122.2 CT189.2 CT190.2 CT610.2 CT611.2 CT612.2 CT614.2 CT615.2 CT616.2 CT617.2 CT618.2 CT625.2 CT626.2 CT627.2 CT628.2 CT629.2 CV7.2 CV11.2 CV12.2 CV14.2 CV15.2 CV16.2 CV17.2 CV18.2 CV19.2 CV20.2 CV21.2 CV22.2 CV23.2 CV24.2 CV25.2 CV39.2 CV40.2 CV41.2 CV61.2 CV62.2 CV75.2 CV100.2 CV101.2 CV102.2 CV103.2 CV104.2 CV105.2 CV106.2 CV126.2 CV127.2 CV128.2 CV129.2 CV130.2 CV131.2 CV132.2 CV133.2 CV134.2 CV135.2 CV631.2 CV632.2 CV633.2 CV634.2 CV635.2 CV636.2 CV1635.2 CV1638.2 CZ1.2 CZ2.2 CZ3.2 CZ4.2 CZ5.2 CZ6.2 CZ7.2 CZ8.2 CZ9.2 CZ17.2 CZ18.2 CZ19.2 CZ20.2 CZ21.2 CZ23.2 CZ24.2 CZ25.2 CZ26.2 CZ27.2 CZ28.2 CZ29.2 CZ30.2 CZ31.2 CZ32.2 CZ33.2 CZ34.2 CZ35.2 CZ36.2 CZ37.2 CZ39.2 CZ40.2 CZ41.2 CZ50.2 CZ51.2 CZ52.2 CZ53.2 CZ54.2 CZ55.2 CZ56.2 CZ57.2 CZ58.2 CZ59.2 CZ60.2 CZ61.2 CZ62.2 CZ63.2 CZ64.2 CZ66.2 CZ67.2 CZ68.2 CZ69.2 CZ71.2 CZ72.2 CZ73.2 CZ75.2 CZ80.2 CZ81.2 CZ82.2 CZ83.2 CZ84.2 CZ85.2 CZ86.2 CZ87.2 CZ88.2 CZ89.2 CZ90.2 CZ91.2 CZ92.2 CZ93.2 CZ100.2 CZ101.2 CZ102.1 CZ103.2 CZ104.2 CZ105.2 CZ106.2 CZ109.2 CZ110.2 CZ111.2 CZ112.2 CZ113.2 CZ114.2 CZ115.2 CZ116.2 CZ117.2 CZ118.2 CZ119.2 CZ120.2 CZ121.2 CZ122.2 CZ124.2 CZ125.2 CZ126.2 CZ127.2 CZ128.2 CZ129.2 CZ130.2 CZ154.2 CZ155.2 CZ197.2 CZ198.2 CZ544.2 CZ1200.2 DA1.1 DA2.1 DA3.1 DA6.1 DA7.1 DE1.2 DI1.3 DI2.1 DI3.1 DI4.3 DI5.1 DI6.3 DT4.1 DT5.1 DT6.1 DT9.1 DT10.1 DT13.1 DT14.1 DT17.1 DT18.1 DT39.3 DT40.3 DV4.1 DV5.1 DV6.1 H1.1(TP-1) H2.1(TP-1) H3.1(TP-1) H4.1(TP-1) H7.1(TP-1) H8.1(TP-1) H9.1(TP-1) H10.1(TP-1) H11.1(TP-1) H13.1(TP-1) H14.1(TP-1) H16.1(TP-1) H17.1(TP-1) H18.1(TP-1) H21.1(TP-1) H22.1(TP-1) H23.1(TP-1) H34.1(TP-1) H35.1(TP-1) JAPS1.8 JAPS1.10 JAPS1.12 JAPS1.14 JAPS1.19 JAPS1.20 JCRT1.5 JCRT1.6 JCRT1.7 JCRT1.8 JCRT1.10 JCRT1.16 JCRT1.17 JDB1.6 JDB1.7 JDB1.8 JDEG1.10 JDEG1.11 JDEG1.12 JDIMM1.1 JDIMM1.2 JDIMM1.5 JDIMM1.6 JDIMM1.9 JDIMM1.10 JDIMM1.14 JDIMM1.15 JDIMM1.18 JDIMM1.19 JDIMM1.22 JDIMM1.23 JDIMM1.26 JDIMM1.27 JDIMM1.30 JDIMM1.31 JDIMM1.35 JDIMM1.36 JDIMM1.39 JDIMM1.40 JDIMM1.43 JDIMM1.44 JDIMM1.47 JDIMM1.48 JDIMM1.51 JDIMM1.52 JDIMM1.56 JDIMM1.57 JDIMM1.60 JDIMM1.61 JDIMM1.64 JDIMM1.65 JDIMM1.68 JDIMM1.69 JDIMM1.72 JDIMM1.73 JDIMM1.77 JDIMM1.78 JDIMM1.81 JDIMM1.82 JDIMM1.85 JDIMM1.86 JDIMM1.89 JDIMM1.90 JDIMM1.93 JDIMM1.94 JDIMM1.98 JDIMM1.99 JDIMM1.102 JDIMM1.103 JDIMM1.106 JDIMM1.107 JDIMM1.167 JDIMM1.168 JDIMM1.171 JDIMM1.172 JDIMM1.175 JDIMM1.176 JDIMM1.180 JDIMM1.181 JDIMM1.184 JDIMM1.185 JDIMM1.188 JDIMM1.189 JDIMM1.192 JDIMM1.193 JDIMM1.196 JDIMM1.197 JDIMM1.201 JDIMM1.202 JDIMM1.205 JDIMM1.206 JDIMM1.209 JDIMM1.210 JDIMM1.213 JDIMM1.214 JDIMM1.217 JDIMM1.218 JDIMM1.222 JDIMM1.223 JDIMM1.226 JDIMM1.227 JDIMM1.230 JDIMM1.231 JDIMM1.234 JDIMM1.235 JDIMM1.238 JDIMM1.239 JDIMM1.243 JDIMM1.244 JDIMM1.247 JDIMM1.248 JDIMM1.251 JDIMM1.252 JDIMM1.261 JDIMM1.262 JDIMM2.1 JDIMM2.2 JDIMM2.5 JDIMM2.6 JDIMM2.9 JDIMM2.10 JDIMM2.14 JDIMM2.15 JDIMM2.18 JDIMM2.19 JDIMM2.22 JDIMM2.23 JDIMM2.26 JDIMM2.27 JDIMM2.30 JDIMM2.31 JDIMM2.35 JDIMM2.36 JDIMM2.39 JDIMM2.40 JDIMM2.43 JDIMM2.44 JDIMM2.47 JDIMM2.48 JDIMM2.51 JDIMM2.52 JDIMM2.56 JDIMM2.57 JDIMM2.60 JDIMM2.61 JDIMM2.64 JDIMM2.65 JDIMM2.68 JDIMM2.69 JDIMM2.72 JDIMM2.73 JDIMM2.77 JDIMM2.78 JDIMM2.81 JDIMM2.82 JDIMM2.85 JDIMM2.86 JDIMM2.89 JDIMM2.90 JDIMM2.93 JDIMM2.94 JDIMM2.98 JDIMM2.99 JDIMM2.102 JDIMM2.103 JDIMM2.106 JDIMM2.107 JDIMM2.167 JDIMM2.168 JDIMM2.171 JDIMM2.172 JDIMM2.175 JDIMM2.176 JDIMM2.180 JDIMM2.181 JDIMM2.184 JDIMM2.185 JDIMM2.188 JDIMM2.189 JDIMM2.192 JDIMM2.193 JDIMM2.196 JDIMM2.197 JDIMM2.201 JDIMM2.202 JDIMM2.205 JDIMM2.206 JDIMM2.209 JDIMM2.210 JDIMM2.213 JDIMM2.214 JDIMM2.217 JDIMM2.218 JDIMM2.222 JDIMM2.223 JDIMM2.226 JDIMM2.227 JDIMM2.230 JDIMM2.231 JDIMM2.234 JDIMM2.235 JDIMM2.238 JDIMM2.239 JDIMM2.243 JDIMM2.244 JDIMM2.247 JDIMM2.248 JDIMM2.251 JDIMM2.252 JDIMM2.261 JDIMM2.262 JEDP1.4 JEDP1.6 JEDP1.8 JEDP1.15 JEDP1.23 JEDP1.24 JEDP1.25 JEDP1.27 JEDP1.28 JEDP1.39 JEDP1.41 JEDP1.42 JEDP1.43 JEDP1.44 JEDP1.45 JESPI.9 JESPI.11 JESPI.12 JFAN1.1 JFAN1.5 JFAN1.6 JHDMI1.2 JHDMI1.5 JHDMI1.8 JHDMI1.11 JHDMI1.17 JHDMI1.20 JHDMI1.21 JHDMI1.22 JHDMI1.23 JIR1.2 JIR1.3 JIR1.7 JIR1.8 JKBTP1.1 JKBTP1.4 JKBTP1.6 JKBTP1.12 JKBTP1.18 JKBTP1.19 JKBTP1.21 JKBTP1.22 JLED1.3 JLED1.7 JLED1.8 JLOM1.14 JLOM1.15 JNGFF1.1 JNGFF1.7 JNGFF1.18 JNGFF1.19 JNGFF1.33 JNGFF1.39 JNGFF1.45 JNGFF1.51 JNGFF1.57 JNGFF1.63 JNGFF1.69 JNGFF1.75 JNGFF1.76 JNGFF1.77 JNGFF2.3 JNGFF2.5 JNGFF2.11 JNGFF2.27 JNGFF2.33 JNGFF2.39 JNGFF2.45 JNGFF2.51 JNGFF2.57 JNGFF2.71 JNGFF2.73 JNGFF2.76 JNGFF2.77 JNGFF3.1 JNGFF3.3 JNGFF3.9 JNGFF3.15 JNGFF3.21 JNGFF3.27 JNGFF3.33 JNGFF3.39 JNGFF3.45 JNGFF3.51 JNGFF3.57 JNGFF3.71 JNGFF3.73 JNGFF3.75 JNGFF3.76 JNGFF3.77 JRTC1.2 JRTC1.3 JRTC1.4 JSATA1.1 JSATA1.4 JSATA1.7 JSATA1.12 JSATA1.14 JSATA1.18 JSATA1.21 JSATA1.22 JSATA1.23 JSATA1.24 JSD1.3 JSD1.6 JSD1.10 JSD1.13 JSD1.17 JSD1.20 JSD1.21 JSD1.22 JSD1.23 JSD1.24 JSD1.25 JSD1.26 JSIM1.5 JSIM1.10 JSIM1.11 JSIM1.12 JSIM1.13 JSIM1.14 JSIM1.15 JSIM1.16 JSPI1.18 JSPI1.19 JSPI1.20 JSPI1.21 JSPI1.22 JSPK1.5 JSPK1.6 JTAG1.2 JUSB1.4 JUSB1.7 JUSB1.10 JUSB1.11 JUSB1.12 JUSB1.13 JUSB2.4 JUSB2.7 JUSB2.10 JUSB2.11 JUSB2.12 JUSB2.13 JUSB3.4 JUSB3.7 JUSB3.10 JUSB3.11 JUSB3.12 JUSB3.13 JUSBC1.1 JUSBC1.2 JUSBC1.3 JUSBC1.4 JUSBC1.5 JUSBC1.6 JUSBC1.A1 JUSBC1.A12 JUSBC1.B1 JUSBC1.B12 JUSH1.6 JUSH1.7 JUSH1.10 JUSH1.24 JUSH1.25 JUSH1.27 JUSH1.28 JXDP1.2 JXDP1.7 JXDP1.8 JXDP1.13 JXDP1.14 JXDP1.19 JXDP1.20 JXDP1.25 JXDP1.26 JXDP1.31 JXDP1.32 JXDP1.37 JXDP1.38 JXDP1.49 JXDP1.50 JXDP1.59 LGA1.5 LGA1.6 LGA1.7 LGA1.8 PBATT1.7 PBATT1.8 PBATT1.9 PBATT1.10 PC1.2 PC2.1 PC3.2 PC5.2 PC7.2 PC8.2 PC9.2 PC10.2 PC11.2 PC100.2 PC103.2 PC104.2 PC105.2 PC106.2 PC107.2 PC108.2 PC109.2 PC110.2 PC111.2 PC112.2 PC115.2 PC116.2 PC117.2 PC118.2 PC119.2 PC120.2 PC121.2 PC122.2 PC123.2 PC124.2 PC125.2 PC126.2 PC128.2 PC129.2 PC130.2 PC133.2 PC134.2 PC135.2 PC136.2 PC137.2 PC138.2 PC139.2 PC140.2 PC200.2 PC201.2 PC202.2 PC203.2 PC204.2 PC206.2 PC207.2 PC209.2 PC210.2 PC211.2 PC212.2 PC213.2 PC214.2 PC216.2 PC217.2 PC218.2 PC219.2 PC221.2 PC222.2 PC223.2 PC302.2 PC303.2 PC305.2 PC306.2 PC308.2 PC309.2 PC310.2 PC311.2 PC312.2 PC313.2 PC314.2 PC315.2 PC316.2 PC401.2 PC403.2 PC404.2 PC405.2 PC407.2 PC408.2 PC409.2 PC410.2 PC411.2 PC412.2 PC415.2 PC501.2 PC502.1 PC504.2 PC505.2 PC506.2 PC508.2 PC510.2 PC511.2 PC513.2 PC514.2 PC516.2 PC800.2 PC801.2 PC802.2 PC803.2 PC804.2 PC805.2 PC806.2 PC807.2 PC808.2 PC809.2 PC810.2 PC811.2 PC812.2 PC813.2 PC815.2 PC816.2 PC817.2 PC818.2 PC819.2 PC820.2 PC821.2 PC822.2 PC823.2 PC824.2 PC825.2 PC826.2 PC827.2 PC828.2 PC829.2 PC830.2 PC831.2 PC832.2 PC833.2 PC834.2 PC835.2 PC836.2 PC837.2 PC838.2 PC839.2 PC840.2 PC841.2 PC842.2 PC843.2 PC844.2 PC848.2 PC849.2 PC851.2 PC852.2 PC902.2 PC903.2 PC904.2 PC905.2 PC906.2 PC909.2 PC911.2 PC913.2 PC914.2 PC915.2 PC916.2 PC921.2 PC922.2 PC926.2 PC927.2 PC928.2 PC929.2 PC931.1 PC932.1 PC933.2 PC935.2 PC936.2 PC937.1 PC938.2 PC939.2 PC940.2 PC941.2 PC942.2 PC943.2 PC944.2 PC946.2 PC947.2 PC949.1 PC950.1 PC951.2 PC952.2 PC953.2 PC954.2 PC955.2 PC956.2 PC957.2 PC958.2 PC959.2 PC1001.2 PC1002.2 PC1003.2 PC1004.2 PC1005.2 PC1006.2 PC1007.2 PC1008.2 PC1009.2 PC1010.2 PC1011.2 PC1012.2 PC1013.2 PC1014.2 PC1015.2 PC1016.2 PC1017.2 PC1018.2 PC1019.2 PC1021.2 PC1022.2 PC1023.2 PC1024.2 PC1025.2 PC1026.2 PC1027.2 PC1028.2 PC1029.2 PC1030.2 PC1031.2 PC1032.2 PC1041.2 PC1042.2 PC1043.2 PC1044.2 PC1045.2 PC1046.2 PC1047.2 PC1048.2 PC1049.2 PC1050.2 PC1051.2 PC1052.2 PC1053.2 PC1054.2 PC1055.2 PC1056.2 PC1074.2 PC1075.2 PC1076.2 PC1077.2 PC1078.2 PC1079.2 PC1080.2 PC1081.2 PC1082.2 PC1083.2 PC1084.2 PC1085.2 PC1086.2 PC1087.2 PC1088.2 PC1089.2 PC1090.2 PC1091.2 PC1092.2 PC1093.2 PC1094.2 PC1095.2 PC1096.2 PC1097.2 PC1098.2 PC1099.2 PC1103.2 PC1104.2 PC1105.2 PC1106.2 PC1107.2 PC1108.2 PC1109.2 PC1111.2 PC1112.2 PC1113.2 PC1114.2 PC1115.2 PC1116.2 PC1132.2 PC1133.2 PC1134.2 PC1135.2 PC1136.2 PC1137.2 PC1138.2 PC1139.2 PC1140.2 PC1141.2 PC1142.2 PC1143.2 PC1144.2 PC1145.2 PC1146.2 PC1162.2 PC1163.2 PC1164.2 PC1165.2 PC1166.2 PC1167.2 PC1168.2 PC1169.2 PC1170.2 PC1171.2 PC1172.2 PC1173.2 PC1174.2 PC1175.2 PC1176.2 PC1177.2 PC1178.2 PC1179.2 PC1180.2 PC1181.2 PC1201.1 PC1204.2 PC1205.2 PC1206.2 PC1207.2 PC1208.2 PC1209.2 PC1211.2 PC1212.2 PC1213.2 PC1214.2 PC1215.2 PC1216.2 PC1217.2 PC1702.1 PC1704.2 PC1706.1 PC1708.1 PC1710.1 PC1718.1 PC1722.2 PC1723.1 PC1727.2 PC1729.2 PC1730.1 PC1731.2 PC1732.2 PC1800.2 PC1801.2 PC1802.2 PC1803.2 PC1804.2 PC1805.2 PC1806.2 PC1807.2 PC1808.2 PC1809.2 PC1810.2 PC1811.2 PC1812.1 PC1814.2 PC1816.2 PC1817.2 PC1818.2 PC1819.2 PC1820.2 PC1821.2 PC1822.1 PC1824.2 PC1826.2 PC1828.2 PC1900.1 PC1901.2 PC1902.2 PC1903.2 PC1904.2 PC1905.2 PC1906.2 PC1908.2 PC1910.2 PC1911.2 PC1912.2 PC1913.2 PC1914.2 PC1915.2 PC1916.1 PC1918.2 PC1920.2 PC1922.2 PC2000.1 PC2001.2 PC2002.2 PC2003.2 PC2004.2 PC2005.2 PC2006.2 PC2008.2 PC2010.2 PC2011.2 PC2012.2 PC2013.2 PC2014.2 PC2015.2 PC2016.1 PC2018.2 PC2020.1 PC2021.1 PC2022.2 PC2023.2 PC2024.2 PC2026.2 PC2027.2 PC2028.2 PC2029.2 PC2030.2 PC2031.2 PC2032.1 PC2033.1 PC2034.1 PC2035.1 PC2036.2 PC2037.2 PC2038.2 PC2039.2 PC2040.2 PC2048.2 PC2049.2 PC2050.2 PC2051.2 PC2052.2 PC2053.2 PC2054.2 PC2055.2 PD1.1 PD2.1 PD4.1 PD6.2 PD906.2 PH1703.2 PH1704.2 PJP19.2 PJPDC1.4 PJPDC1.5 PJPDC1.6 PJPDC1.7 PQ1.1 PQ1.4 PQ3.3 PQ6.3 PQ7.3 PQ903.1 PQ903.2 PQ903.3 PQ909.3 PQ1201.1 PQ1201.4 PQ1204.1 PQ1204.4 PQ1207.1 PQ1207.4 PQ1208.1 PQ1208.4 PQ1209.1 PQ1209.4 PQ1210.1 PQ1210.4 PQ1212.3 PQ1214.1 PQ1214.4 PQ1216.3 PQ1302.3 PQ1302.4 PQ1302.5 PR8.1 PR13.2 PR14.2 PR24.2 PR30.2 PR103.2 PR116.2 PR206.2 PR207.1 PR209.2 PR212.2 PR302.2 PR316.2 PR403.2 PR416.2 PR419.2 PR420.2 PR427.1 PR505.2 PR506.2 PR509.2 PR510.2 PR514.2 PR516.2 PR609.2 PR925.2 PR927.2 PR930.2 PR932.2 PR945.2 PR948.2 PR953.2 PR960.1 PR1210.2 PR1217.2 PR1219.2 PR1222.2 PR1227.2 PR1246.2 PR1247.2 PR1249.2 PR1262.2 PR1700.1 PR1713.1 PR1718.1 PR1720.1 PR1722.2 PR1729.1 PR1732.1 PR1733.2 PR1736.2 PR1755.2 PR1756.2 PR1758.2 PR1759.2 PR1760.2 PR1761.2 PR1762.2 PR1769.2 PR1770.2 PR1803.2 PR1807.2 PR1903.2 PR1907.2 PR2003.2 PR2006.2 PU1.3 PU2.2 PU100.7 PU100.8 PU100.18 PU100.21 PU102.7 PU102.8 PU102.18 PU102.21 PU200.4 PU200.9 PU200.15 PU301.7 PU301.8 PU301.18 PU301.21 PU401.6 PU401.15 PU401.16 PU401.17 PU501.2 PU502.4 PU502.9 PU503.4 PU503.9 PU901.33 PU903.3 PU1200.3 PU1201.4 PU1700.53 PU1800.4 PU1800.10 PU1800.14 PU1800.18 PU1801.4 PU1801.10 PU1801.14 PU1801.18 PU1900.4 PU1900.10 PU1900.14 PU1900.18 PU1901.4 PU1901.10 PU1901.14 PU1901.18 PU2000.4 PU2000.10 PU2000.14 PU2000.18 PU2001.2 PU2001.4 PU2001.10 PU2001.14 PU2001.18 QE2.1 QE2.4 QE12.3 QE17.3 QH6.3 QN1.1 QN1.4 QN6.3 QV2.3 QV4.3 QV7.3 QV19.3 QV21.3 QZ4.3 QZ16.1 QZ17.1 QZ17.4 QZ18.1 QZ18.4 RA35.2 RA36.2 RA37.2 RA45.2 RA51.2 RA52.1 RC5.1 RC6.1 RC7.1 RC75.2 RC114.2 RC122.2 RC136.2 RC139.2 RC141.2 RC171.1 RC178.2 RC179.2 RC181.2 RC219.1 RC319.1 RC321.2 RC322.2 RC323.2 RC324.2 RC325.2 RC436.2 RC437.2 RC438.2 RC440.2 RC441.2 RC442.2 RC443.2 RC558.2 RD5.2 RD7.2 RD9.2 RD16.2 RD18.2 RD21.2 RD23.2 RD25.2 RD29.2 RD31.2 RE20.2 RE55.2 RE56.2 RE58.2 RE65.2 RE77.2 RE85.2 RE86.2 RE93.2 RE95.1 RE313.2 RE342.2 RE541.1 RE550.2 RE702.2 RH1.1 RH65.2 RH70.2 RH74.2 RH83.2 RH110.2 RH193.2 RH268.2 RH308.2 RH313.2 RH317.1 RH322.1 RH323.1 RH325.1 RH326.1 RH334.1 RH364.2 RH365.2 RH372.2 RH377.1 RH379.2 RH401.2 RH424.2 RH435.1 RH554.2 RH556.2 RH603.2 RH606.2 RH608.2 RH609.1 RH610.1 RH611.1 RH612.1 RH617.1 RH618.1 RH621.1 RH622.1 RH626.2 RH627.2 RH628.2 RH629.2 RH630.2 RH631.2 RH632.2 RH633.2 RH634.2 RH635.2 RH636.1 RH637.1 RI14.1 RL3.2 RL9.2 RL12.2 RL13.2 RN5.2 RN7.1 RN9.1 RN11.1 RN13.1 RN15.1 RN17.1 RN19.2 RN21.2 RPE10.5 RPE10.6 RPE10.7 RPE10.8 RPH8.5 RPH8.6 RPH8.7 RPH8.8 RR4.2 RT63.2 RT64.2 RT65.2 RT71.2 RT81.2 RT82.2 RT86.2 RT96.2 RT99.2 RT100.2 RT101.2 RT103.2 RT130.2 RT136.2 RT138.2 RT140.2 RT142.2 RT300.2 RT377.2 RT393.2 RT414.2 RT415.2 RT416.2 RT417.2 RT418.2 RT419.2 RV1.2 RV2.2 RV3.1 RV21.2 RV50.2 RV74.2 RV76.2 RV77.2 RV80.2 RV82.2 RV84.2 RV102.2 RV116.2 RV117.2 RV118.2 RV123.1 RV624.2 RV626.2 RV629.2 RZ7.2 RZ10.1 RZ25.2 RZ38.1 RZ40.1 RZ62.2 RZ334.2 RZ360.2 SW1.4 SW1.5 SW3.1 SW3.3 UA1.49 UC1.A3 UC1.A4 UC1.A6 UC1.A9 UC1.A10 UC1.A12 UC1.A14 UC1.A16 UC1.A18 UC1.A20 UC1.A22 UC1.A24 UC1.A26 UC1.A28 UC1.A30 UC1.A34 UC1.AA12 UC1.AA29 UC1.AA30 UC1.AB6 UC1.AB33 UC1.AB34 UC1.AC1 UC1.AC2 UC1.AC3 UC1.AC4 UC1.AC5 UC1.AC6 UC1.AC12 UC1.AC37 UC1.AC38 UC1.AD6 UC1.AD7 UC1.AD8 UC1.AD9 UC1.AD10 UC1.AD11 UC1.AD12 UC1.AD29 UC1.AD30 UC1.AE6 UC1.AE33 UC1.AE34 UC1.AF1 UC1.AF2 UC1.AF3 UC1.AF4 UC1.AF12 UC1.AF13 UC1.AF14 UC1.AG6 UC1.AG7 UC1.AG8 UC1.AG10 UC1.AG11 UC1.AG13 UC1.AG29 UC1.AG30 UC1.AH6 UC1.AH12 UC1.AH33 UC1.AH34 UC1.AH35 UC1.AH36 UC1.AJ1 UC1.AJ2 UC1.AJ3 UC1.AJ4 UC1.AJ5 UC1.AJ6 UC1.AJ13 UC1.AJ37 UC1.AJ38 UC1.AK4 UC1.AK29 UC1.AK30 UC1.AL4 UC1.AL7 UC1.AL8 UC1.AL9 UC1.AL10 UC1.AL12 UC1.AL14 UC1.AL33 UC1.AL34 UC1.AM1 UC1.AM2 UC1.AM3 UC1.AM4 UC1.AM5 UC1.AM12 UC1.AM37 UC1.AM38 UC1.AN5 UC1.AN6 UC1.AN12 UC1.AN29 UC1.AN30 UC1.AP8 UC1.AP9 UC1.AP10 UC1.AP11 UC1.AP12 UC1.AP33 UC1.AP34 UC1.AR1 UC1.AR2 UC1.AR3 UC1.AR4 UC1.AR5 UC1.AR13 UC1.AR14 UC1.AR29 UC1.AR30 UC1.AR31 UC1.AR32 UC1.AR33 UC1.AR34 UC1.AR35 UC1.AR36 UC1.AR37 UC1.AR38 UC1.AT6 UC1.AT29 UC1.AT30 UC1.AU6 UC1.AU7 UC1.AU8 UC1.AU9 UC1.AU10 UC1.AU11 UC1.AU12 UC1.AU33 UC1.AU34 UC1.AV37 UC1.AV38 UC1.AW1 UC1.AW2 UC1.AW3 UC1.AW4 UC1.AW5 UC1.AW12 UC1.AW29 UC1.AW30 UC1.AY12 UC1.AY14 UC1.AY33 UC1.AY34 UC1.B3 UC1.B9 UC1.B37 UC1.BA6 UC1.BA7 UC1.BA8 UC1.BA9 UC1.BA10 UC1.BA11 UC1.BA12 UC1.BA37 UC1.BA38 UC1.BB1 UC1.BB2 UC1.BB3 UC1.BB4 UC1.BB5 UC1.BB6 UC1.BB12 UC1.BB29 UC1.BB30 UC1.BC6 UC1.BC12 UC1.BC13 UC1.BC14 UC1.BC33 UC1.BC34 UC1.BD6 UC1.BD7 UC1.BD8 UC1.BD9 UC1.BD10 UC1.BD11 UC1.BD12 UC1.BD37 UC1.BD38 UC1.BE1 UC1.BE2 UC1.BE3 UC1.BE4 UC1.BE5 UC1.BE6 UC1.BE29 UC1.BE30 UC1.BF6 UC1.BF12 UC1.BF33 UC1.BF34 UC1.BG6 UC1.BG12 UC1.BG13 UC1.BG14 UC1.BG37 UC1.BG38 UC1.BH1 UC1.BH2 UC1.BH3 UC1.BH4 UC1.BH5 UC1.BH6 UC1.BH7 UC1.BH8 UC1.BH9 UC1.BH10 UC1.BH11 UC1.BH12 UC1.BH14 UC1.BJ12 UC1.BJ14 UC1.BJ15 UC1.BJ18 UC1.BJ22 UC1.BJ25 UC1.BJ29 UC1.BJ30 UC1.BJ31 UC1.BJ32 UC1.BJ33 UC1.BJ34 UC1.BJ35 UC1.BJ36 UC1.BK6 UC1.BK13 UC1.BK14 UC1.BK15 UC1.BK18 UC1.BK22 UC1.BK25 UC1.BK29 UC1.BL6 UC1.BL13 UC1.BL14 UC1.BL18 UC1.BL19 UC1.BL20 UC1.BL21 UC1.BL22 UC1.BL29 UC1.BL33 UC1.BL35 UC1.BL38 UC1.BM2 UC1.BM3 UC1.BM5 UC1.BM6 UC1.BM7 UC1.BM8 UC1.BM9 UC1.BM11 UC1.BM12 UC1.BM13 UC1.BM14 UC1.BM18 UC1.BM21 UC1.BM22 UC1.BM23 UC1.BM24 UC1.BM25 UC1.BM26 UC1.BM27 UC1.BM28 UC1.BM29 UC1.BM33 UC1.BM35 UC1.BM38 UC1.BN2 UC1.BN4 UC1.BN7 UC1.BN12 UC1.BN14 UC1.BN18 UC1.BN19 UC1.BN20 UC1.BN21 UC1.BN24 UC1.BN29 UC1.BN30 UC1.BN31 UC1.BN34 UC1.BP7 UC1.BP12 UC1.BP14 UC1.BP18 UC1.BP21 UC1.BP24 UC1.BP25 UC1.BP26 UC1.BP29 UC1.BP33 UC1.BP34 UC1.BR7 UC1.BR9 UC1.BR12 UC1.BR14 UC1.BR18 UC1.BR21 UC1.BR24 UC1.BR25 UC1.BR26 UC1.BR29 UC1.BR34 UC1.BR36 UC1.BR38 UC1.BT3 UC1.BT4 UC1.BT5 UC1.BT8 UC1.BT12 UC1.BT14 UC1.BT18 UC1.BT21 UC1.BT24 UC1.BT26 UC1.BT29 UC1.BT32 UC1.BT35 UC1.BT36 UC1.C2 UC1.C5 UC1.C8 UC1.C9 UC1.C11 UC1.C13 UC1.C15 UC1.C17 UC1.C19 UC1.C21 UC1.C23 UC1.C25 UC1.C27 UC1.C29 UC1.C31 UC1.C37 UC1.D3 UC1.D6 UC1.D9 UC1.D10 UC1.D12 UC1.D14 UC1.D16 UC1.D18 UC1.D20 UC1.D22 UC1.D24 UC1.D26 UC1.D28 UC1.D30 UC1.D33 UC1.D38 UC1.E4 UC1.E9 UC1.E34 UC1.E35 UC1.E38 UC1.F2 UC1.F3 UC1.F4 UC1.F5 UC1.F8 UC1.F9 UC1.F11 UC1.F13 UC1.F15 UC1.F17 UC1.F19 UC1.F21 UC1.F23 UC1.F25 UC1.F27 UC1.F29 UC1.F31 UC1.F36 UC1.G4 UC1.G5 UC1.G6 UC1.G8 UC1.G9 UC1.G10 UC1.G12 UC1.G14 UC1.G16 UC1.G18 UC1.G20 UC1.G22 UC1.G23 UC1.G24 UC1.G26 UC1.G28 UC1.H11 UC1.H12 UC1.H18 UC1.H22 UC1.H25 UC1.H32 UC1.H35 UC1.J4 UC1.J7 UC1.J10 UC1.J18 UC1.J22 UC1.J25 UC1.J32 UC1.J33 UC1.J36 UC1.K1 UC1.K2 UC1.K3 UC1.K4 UC1.K5 UC1.K7 UC1.K8 UC1.K9 UC1.K10 UC1.K11 UC1.K38 UC1.L29 UC1.L30 UC1.L33 UC1.L34 UC1.M6 UC1.M12 UC1.M13 UC1.M14 UC1.N1 UC1.N2 UC1.N3 UC1.N4 UC1.N5 UC1.N6 UC1.N7 UC1.N8 UC1.N9 UC1.N10 UC1.N11 UC1.N12 UC1.N33 UC1.N34 UC1.P6 UC1.P12 UC1.P37 UC1.P38 UC1.R12 UC1.R29 UC1.R30 UC1.T1 UC1.T2 UC1.T3 UC1.T4 UC1.T5 UC1.T7 UC1.T8 UC1.T9 UC1.T10 UC1.T11 UC1.T12 UC1.T13 UC1.T14 UC1.T33 UC1.T34 UC1.U6 UC1.U37 UC1.U38 UC1.V6 UC1.V12 UC1.V29 UC1.V30 UC1.W1 UC1.W2 UC1.W3 UC1.W4 UC1.W5 UC1.W12 UC1.W33 UC1.W34 UC1.Y7 UC1.Y8 UC1.Y9 UC1.Y10 UC1.Y11 UC1.Y13 UC1.Y14 UC1.Y37 UC1.Y38 UC3.3 UC5.4 UC5.9 UC6.4 UD1.3 UE1.A6 UE1.A13 UE1.C4 UE1.E6 UE1.H4 UE3.3 UE4.3 UE5.3 UE6.3 UH1.A2 UH1.A3 UH1.A4 UH1.A5 UH1.A8 UH1.A28 UH1.A33 UH1.A37 UH1.A45 UH1.A46 UH1.A47 UH1.A48 UH1.AA5 UH1.AA19 UH1.AA20 UH1.AA25 UH1.AA27 UH1.AA28 UH1.AA30 UH1.AA31 UH1.AA49 UH1.AB19 UH1.AB25 UH1.AB31 UH1.AC4 UH1.AC12 UH1.AC17 UH1.AC33 UH1.AC38 UH1.AC46 UH1.AD1 UH1.AD2 UH1.AD19 UH1.AD22 UH1.AD25 UH1.AD49 UH1.AE4 UH1.AE12 UH1.AE33 UH1.AE38 UH1.AE46 UH1.AF22 UH1.AF25 UH1.AF28 UH1.AG1 UH1.AG22 UH1.AG23 UH1.AG25 UH1.AG27 UH1.AG28 UH1.AG30 UH1.AG49 UH1.AH12 UH1.AH17 UH1.AH33 UH1.AH38 UH1.AJ19 UH1.AJ20 UH1.AJ25 UH1.AJ27 UH1.AJ28 UH1.AJ30 UH1.AJ31 UH1.AK4 UH1.AK19 UH1.AK20 UH1.AK25 UH1.AK27 UH1.AK28 UH1.AK30 UH1.AK31 UH1.AK46 UH1.AL12 UH1.AL17 UH1.AL21 UH1.AL24 UH1.AL26 UH1.AL29 UH1.AL33 UH1.AL38 UH1.AM1 UH1.AM18 UH1.AM32 UH1.AM49 UH1.AN12 UH1.AN16 UH1.AN34 UH1.AN38 UH1.AP4 UH1.AP46 UH1.AR12 UH1.AR16 UH1.AR34 UH1.AR38 UH1.AT1 UH1.AT16 UH1.AT18 UH1.AT21 UH1.AT24 UH1.AT26 UH1.AT29 UH1.AT32 UH1.AT34 UH1.AT45 UH1.AV11 UH1.AV39 UH1.AW4 UH1.AW10 UH1.AW40 UH1.AW46 UH1.B47 UH1.B48 UH1.B49 UH1.BA5 UH1.BA6 UH1.BA12 UH1.BA14 UH1.BA44 UH1.BB9 UH1.BB41 UH1.BB43 UH1.BC8 UH1.BC10 UH1.BC13 UH1.BC15 UH1.BC19 UH1.BC24 UH1.BC26 UH1.BC31 UH1.BC35 UH1.BC40 UH1.BC45 UH1.BD43 UH1.BE44 UH1.BF1 UH1.BF2 UH1.BF3 UH1.BF48 UH1.BF49 UH1.BG2 UH1.BG3 UH1.BG4 UH1.BG17 UH1.BG22 UH1.BG25 UH1.BG28 UH1.BG33 UH1.BG37 UH1.BG48 UH1.C4 UH1.C5 UH1.C12 UH1.C25 UH1.C30 UH1.C48 UH1.D8 UH1.D12 UH1.D16 UH1.D17 UH1.D30 UH1.D33 UH1.E8 UH1.E10 UH1.E13 UH1.E15 UH1.E17 UH1.E19 UH1.E22 UH1.E24 UH1.E26 UH1.E31 UH1.E33 UH1.E35 UH1.E40 UH1.E42 UH1.F41 UH1.F43 UH1.F47 UH1.G6 UH1.G44 UH1.H8 UH1.J4 UH1.J9 UH1.J10 UH1.J26 UH1.J29 UH1.J40 UH1.J46 UH1.J47 UH1.J48 UH1.K11 UH1.K39 UH1.M5 UH1.M16 UH1.M18 UH1.M21 UH1.M24 UH1.M32 UH1.M34 UH1.M49 UH1.N12 UH1.N16 UH1.N34 UH1.N35 UH1.N37 UH1.N38 UH1.P4 UH1.P26 UH1.P29 UH1.P46 UH1.R3 UH1.R4 UH1.R12 UH1.R16 UH1.R26 UH1.R29 UH1.R34 UH1.R38 UH1.T4 UH1.T5 UH1.T7 UH1.T17 UH1.T18 UH1.T32 UH1.T49 UH1.U12 UH1.U15 UH1.U17 UH1.U21 UH1.U24 UH1.U33 UH1.U38 UH1.V4 UH1.V20 UH1.V22 UH1.V46 UH1.W25 UH1.W27 UH1.W28 UH1.W30 UH1.Y9 UH1.Y10 UH1.Y12 UH1.Y17 UH1.Y33 UH1.Y38 UH7.3 UI1.2 UI2.2 UI3.14 UI3.17 UL1.49 UL2.3 UN7.3 UN7.21 UR1.33 UT5.A1 UT5.A6 UT5.A7 UT5.A8 UT5.B7 UT5.B8 UT5.D8 UT5.E5 UT5.E6 UT5.E7 UT5.E8 UT5.F5 UT5.F6 UT5.F7 UT5.F8 UT5.G5 UT5.G6 UT5.G7 UT5.G8 UT5.H4 UT5.H5 UT5.H8 UT5.L1 UT6.4 UT7.2 UT8.2 UT9.53 UV2.2 UV4.2 UV6.24 UV6.33 UV9.18 UV9.24 UV9.31 UV9.49 UV24.2 UZ2.11 UZ2.15 UZ3.11 UZ3.15 UZ4.11 UZ4.15 UZ5.11 UZ5.15 UZ6.3 UZ8.5 UZ8.9 UZ10.3 UZ12.9 UZ12.16 UZ12.23 UZ12.32 UZ12.33 UZ19.5 UZ21.5 UZ23.5 UZ23.9 UZ26.5 UZ29.5 UZ29.11 UZ29.20 UZ29.21 UZ34.3 UZ35.3 UZ61.3 YH2.2 YH2.4 YL1.2 YL1.4
GNDA: CA1.1 CA2.2 CA3.2 CA4.2 CA8.2 CA9.2 CA25.2 CA35.2 CA41.2 CA51.2 CA52.2 CA57.2 CA58.2 DA2.2 JHP1.5 JHP1.7 PJP19.1 RA35.1 RA36.1 RA37.1 RA44.2 UA1.25 UA1.38
VBAT1_ISL88738: PC950.2 PR940.2 PU901.31
VBUS1_ECOK: PR1220.2 PR1222.1 PR1257.1 UE1.M6
VBUS2_ECOK: PR20.2 PR24.1 PR1242.1 UE1.N3
VCC_GT_B+: PC1805.1 PC2001.1 PC2002.1 PC2003.1 PC2004.1 PC2005.1 PC2006.1 PC2021.2 PC2022.1 PC2023.1 PJP2000.1 PU2000.8 PU2000.9
VCC_GT_SENSE: PR1725.1 PR1728.2 UC1.AH38
VCC_IO_SENSE: PR415.1 UC1.H14
VCC_SA_B+: PC2010.1 PC2011.1 PC2012.1 PC2013.1 PC2014.1 PC2015.1 PC2020.2 PC2024.1 PC2052.1 PJP2001.1 PU2001.8 PU2001.9
VCC_SA_SENSE: PR1710.1 PR1714.2 UC1.M38
VCC_SENSE: PR1721.2 PR1723.1 RC140.2 RC221.2 UC1.AG37
VCCDSW_EN: CE66.1 RH445.1 UE1.M7
VCCDSW_EN_GPIO: DH1.2 QH6.2 RH431.1 RH445.2
VCCDSW_EN_Q: DH1.1 DH2.2 RH442.1
VCCMPHY_SENSE: PR314.2 T76.1(TP-1) UH1.K47
VCCST_PWRGD: CC301.1 RC71.2 RC78.1 RE308.1 UE4.4
VCCST_PWRGD_CPU: RC78.2 UC1.H13
VCCST_PWRGD_EC: RE308.2 RE552.2 UE1.K10
VCCSTG_EN: RZ120.1 RZ320.2 UZ19.4 UZ35.4
VDD_ISL88738: PC933.1 PR915.2 PR918.2 PR919.1 PU901.18
VDDP_ISL88738: PC932.2 PR915.1 PU901.8
VIN_1.8VALW: PC502.2 PJP501.2 PL502.2 PU501.4
VIN_1VS_VCCIO: PC404.1 PC405.1 PC407.1 PC408.1 PC2038.1 PJP402.2 PL405.2 PU401.10 PU401.11 PU401.12
VSS_A36: RC178.1 UC1.A36
VSS_A37: RC179.1 UC1.A37
VSS_GT_SENSE: PR1735.2 PR1736.1 UC1.AH37
VSS_IO_SENSE: PR416.1 UC1.J14
VSS_SA_SENSE: PR1700.2 PR1708.1 UC1.M37
VSS_SENSE: PR1726.1 PR1729.2 RC141.1 RC221.1 UC1.AG38
VSSMPHY_SENSE: PR315.2 T77.1(TP-1) UH1.K46
32KHZ_OUT: CE54.1 UE1.F3
81215_ALERT: PR1717.2 PU1700.41
81215_SCLK: PR1715.1 PU1700.42
81215_SDIO: PR1719.1 PU1700.40
81215_VR_HOT: PR1712.1 PU1700.39
+AC_IN: PC1202.1 PC1210.2 PJP1202.2 PQ1206.1 PQ1206.2 PQ1206.3 PQ1213.1 PQ1213.2 PQ1213.3 PQ1215.3 PR1205.1 PR1228.1 PR1251.1 PR1255.1
+BL_PWR_SRC: CV11.1 CV24.1 CV25.1 CV634.1 DV11.2 JEDP1.17 JEDP1.18 JEDP1.19 PJP13.2 RZ90.2
+BL_PWR_SRC_P: CV15.1 PJP13.1 QV1.1 QV1.2 QV1.5 QV1.6 RZ90.1
+CHARGER_SRC: PC902.1 PC903.1 PC904.1 PC905.1 PC906.1 PC909.1 PC911.1 PC951.1 PC952.1 PC953.1 PC954.1 PJP901.2 PL901.1 PQ902.5
+COINCELL: JRTC1.1 PC2.2 PR2.1
+CRT_VCC: CV101.1 CV102.1 CV134.1 JCRT1.9 RV119.2 RV120.2 RV121.2 RV122.2 UV4.3 UV6.17
+DC_IN: PC6.2 PC7.1 PC11.1 PD6.1 PL4.2 PL2002.2 PQ9.1 PQ9.2 PQ9.3 PR12.1 PR13.1 PR1201.1 PU2.1
+DC_IN_SS: PC8.1 PD5.2 PD5.3 PD904.2 PQ4.5 PQ9.5 PR14.1
+DCIN_JACK: PC5.1 PJPDC1.2 PJPDC1.3 PL4.1 PL2002.1
+DDR_VREF_A_CA: CD25.1 CD26.1 JDIMM1.164 RD15.2 RD16.1 RD17.1
+DDR_VREF_B_CA: CD57.1 CD58.1 JDIMM2.164 RD28.2 RD29.1 RD30.1
+DDR_VREF_B_DQ: CD62.1 RD30.2 UC1.BR13
+DDR_VREF_CA: CD31.1 RD17.2 UC1.BN13
+EC_DEBUG_VCC: JDEG1.1 RE71.2
+EDP_VDD: PJP12.2 RZ93.2 UV24.1
+LCDVDD: CV12.1 CV16.1 CV20.1 CV21.1 CV636.1 DV12.2 JEDP1.30 JEDP1.31 PJP12.1 RV7.2 RV623.1 RZ93.1
+LINE1-VREFO-L: RA57.1 UA1.31
+LINE1-VREFO-R: RA58.1 UA1.30
+MIC2-VREFO: RA5.1 RA6.1 UA1.29
+PBATT: PL1.2 PL2.2 PQ906.5 PR940.1
+PECI_VREF: CE25.1 RE59.2 UE1.J11
+PWR_SRC: CV13.2 CZ3.1 JIR1.5 JIR1.6 LZ2.1 PC133.1 PC134.1 PC135.1 PC136.1 PC137.1 PC138.1 PC139.1 PC140.1 PC913.1 PC914.1 PC915.1 PC916.1 PC921.1 PC922.1 PC928.1 PC929.1 PC956.1 PC957.1 PC958.1 PC959.1 PC1800.1 PC1801.1 PC1802.1 PC1803.1 PC2037.1 PC2051.1 PD901.2 PJP100.1 PJP101.1 PJP202.1 PJP301.1 PJP2000.2 PL302.1 PL1800.1 PL1801.1 PQ1302.2 PR102.2 PR917.1 PR929.2 QV1.4 QV18.3 RV4.2
+PWR_SRC_AC: PD906.1 PJP901.1 PL901.2 PR901.4
+PWR_SRC_R: JUSH1.1 LZ2.2
+REGCTL_PNP10: LL1.1 UL1.7
+RREF: RR4.1 UR1.9
+RSVD_VCC3P3_1: RL6.1 UL1.1
+RTC_CELL: PC3.1 PD3.1 QE15.3 RA54.2 RE31.1 RE32.2 RE324.2 RE507.2 RE508.2 RE551.2
+RTC_CELL_PCH: CE63.1 QE15.1 RE546.1 RE551.1 RH198.1 RH200.1 RH201.1 RH297.1
+RTC_CELL_VBAT: CE11.1 RE32.1 UE1.A2
+SDC_IN: PC4.1 PC1203.1 PD5.1 PD1202.1 PQ4.1 PQ4.2 PQ4.3 PQ5.3 PQ1202.1 PQ1202.2 PQ1202.3 PQ1203.3 PR10.1 PR11.1 PR901.1 PR943.2 PR944.1 PR1202.1 PR1207.1
+SDREG2: CR15.1 UR1.24
+SIM_PWR: CZ37.1 CZ41.1 JNGFF2.36 JSIM1.1 RZ335.1
+TBTA_LDO_BMC: CT71.1 UT5.E1
+TBTA_VBUS: CT99.1 CT100.1 CT101.1 CT102.1 CT189.1 CT190.1 DT4.2 DT4.3 JUSBC1.A4 JUSBC1.A9 JUSBC1.B4 JUSBC1.B9 PC1208.1 PC1215.1 PL1201.1 PL1202.1
+TBTA_VBUS_1: CT82.1 CT94.1 PC1209.1 PC1216.1 PJP1202.1 PL1201.2 PL1202.2 PQ1206.5 PR1227.1 PR1239.1 UT5.A10 UT5.B10 UT5.H11 UT5.J10 UT5.J11 UT5.K11 UT8.1
+USB_EX2_PWR: CI1.1 CI3.1 CI45.1 CI46.1 JUSB2.1 UI1.1
+USB_EX3_PWR: CI8.1 CI10.1 CI47.1 CI48.1 JUSB3.1 UI2.1
+UZ12_TPM: CZ50.1 CZ75.1 RZ89.2 RZ367.2 UZ12.8
+UZ12_VHIO: CZ53.1 CZ54.1 CZ55.1 RZ365.1 RZ366.1 UZ12.14 UZ12.22
+VCHGR: PC935.1 PC936.1 PQ906.1 PQ906.2 PQ906.3 PR917.4
+VHDMI_VCC: CV40.1 CV41.1 JHDMI1.18 RV22.2 RV23.2 UV2.3
+VR_CAP: CE31.1 UE1.C10 UE1.J1
+Z4012: PD3.2 PR2.2
AC1_DISC#: PR939.1 PR1244.1 RT72.2
AC1_DISC#_R: RT72.1 UT5.G11
AC_DIS: PQ909.2 PR927.1 RE83.1 UE1.H12
AC_DISC#: PC1217.1 PQ1210.6 PQ1211.3 PQ1211.6 PR25.1 PR1223.1 PR1231.1 PR1245.1 UE1.E13
AC_PRESENT: RH243.1 UE1.K8 UH1.BG42
ACAV_IN: PR946.2 PR953.1 UE1.C7
ACAV_IN1: PQ909.1 PR918.1 PR925.1 PR928.1 PR942.1
ACIN_ISL88738: PC955.1 PR944.2 PR945.1 PU901.19
ACOK_ISL88738: PR928.2 PU901.24
ADJ_1.2V: PC509.2 PR510.1 PR512.2 PU502.3
ADP_ISL88738: PR943.1 PU901.16
ALW_PWRGD_3V_5V: DH2.1 PR119.2 PR120.2 UZ6.2
ALWON: PD100.2 PR114.1 UE1.A5
AR_DET#: RH400.1 RH401.1 UH1.BB16
AUD_AZACPU_SCLK: RH38.1 UC1.G27
AUD_AZACPU_SCLK_R: RH38.2 UH1.AM3
AUD_AZACPU_SDI: RC66.1 UC1.G29
AUD_AZACPU_SDI_R: RC66.2 UH1.AN3
AUD_AZACPU_SDO: RH39.1 UC1.G25
AUD_AZACPU_SDO_R: RH39.2 UH1.AM2
AUD_HP_NB_SENSE: DA2.3 JHP1.6 RA60.2
AUD_HP_OUT_L: LA15.1 RA7.2 RA57.2
AUD_HP_OUT_L1: CA3.1 DA1.2 JHP1.1 LA15.2
AUD_HP_OUT_R: LA16.1 RA8.2 RA58.2
AUD_HP_OUT_R1: CA2.1 DA1.3 JHP1.2 LA16.2
AUD_PC_BEEP: CA27.2 CA28.2 UA1.16
AUD_PWR_EN: RH345.2 UH1.BD8 UZ5.3 UZ5.5
AUD_SENSE_A: CA41.1 RA59.2 RA60.1 UA1.13
AUD_SENSE_B: RA61.2 UA1.14
AUX_EN_WOWL: DZ9.2 RZ70.1 RZ379.2 UE1.D3
BAT1_LED#: RZ28.1 UE1.D10
BAT2_LED#: QZ2.1 RZ361.1 UE1.D11
BAT2_LED#_R: QZ2.3 QZ2.6 QZ3.2
BATT_WHITE#: JLED1.4 QZ3.3 RZ361.2
BATT_YELLOW#: JLED1.5 RZ28.2
BBS_BIT6: RH311.2 UH1.BA26
BC_CLK_ECE1117: CZ87.1 JKBTP1.11 UE1.D13
BC_DAT_ECE1117: CZ86.1 JKBTP1.13 RE365.1 UE1.D12
BC_INT#_ECE1117: CZ85.1 JKBTP1.14 UE1.E2
BCM5882_ALERT#: JUSH1.13 RE532.2 UE1.G10
BEEP: RA13.2 UE1.H11
BEEP_R: CA28.1 CA62.1 RA13.1 RA45.1
BGATE_ISL88738: PC937.2 PQ906.4 PU901.32
BIA_PWM: DV1.1 LV1.2 RV1.1
BIA_PWM_EC: DV1.2 UE1.N1
BIA_PWM_PCH: DV1.3 UH1.AU48
BIOS_REC: RH76.2 UH1.AR42
BL_PWR_MONITOR: QV19.2 RV625.2
BL_PWR_SRC_ON: CV13.1 CV14.1 QV1.3 RV4.1 RV5.1
BLUE: CV131.1 DV6.2 JCRT1.3 LV18.2
BLUE_CRT: CV128.1 LV18.1 RV118.1 UV6.21
BOARD_ID: CE40.1 RE79.2 UE1.J13
BOOT1_ISL88738: PR914.1 PU901.12
BOOT2_ISL88738: PC934.2 PU901.4
BREATH_LED#: QZ7.4 UE1.C11
BREATH_LED#_Q: QZ7.3 RZ32.1
BREATH_WHITE_LED_SNIFF#: LED3.1 RZ32.2
BST_3V: PR100.1 PU100.1
BST_5V: PR111.1 PU102.1
BST_+1VALWP: PC304.1 PU301.1
BST_+1VALWP_R: PC304.2 PR304.1
BT_RADIO_DIS#: DZ2.1 RE11.1 UE1.C2
BT_RADIO_DIS#_R: DZ2.2 JNGFF1.54
C10_PWR_GATE#: RH620.1 RZ542.1 UZ61.4
C10_PWR_GATE#_R: RH619.2 RH620.2 UZ35.1
CAM_MIC_CBL_DET#: JEDP1.14 RH319.2 UH1.AW13
CFG0: JXDP1.9 RC126.1 RC321.1 UC1.BN25
CFG1: JXDP1.11 RC436.1 UC1.BN27
CFG2: JXDP1.15 RC181.1 UC1.BN26
CFG3: JXDP1.17 RC121.2 UC1.BN28
CFG4: JXDP1.27 RC322.1 UC1.BR20
CFG5: JXDP1.29 RC323.1 UC1.BM20
CFG6: JXDP1.33 RC324.1 UC1.BT20
CFG7: JXDP1.35 RC325.1 UC1.BP20
CFG8: JXDP1.10 RC437.1 UC1.BR23
CFG9: JXDP1.12 RC438.1 RC439.1 UC1.BR22
CFG10: JXDP1.16 RC440.1 UC1.BT23
CFG11: JXDP1.18 RC441.1 UC1.BT22
CFG12: JXDP1.28 RC442.1 UC1.BM19
CFG13: JXDP1.30 RC443.1 UC1.BR19
CFG14: JXDP1.34 UC1.BP19
CFG15: JXDP1.36 UC1.BT19
CFG16: JXDP1.6 UC1.BP23
CFG17: JXDP1.4 UC1.BN23
CFG18: JXDP1.24 UC1.BN22
CFG19: JXDP1.22 UC1.BP22
CHR_USB20_N1: LI7.1 UI3.11
CHR_USB20_N1_R: DI5.2 JUSB1.2 LI7.2
CHR_USB20_P1: LI7.4 UI3.10
CHR_USB20_P1_R: DI5.3 JUSB1.3 LI7.3
CLK_CNV_PRX_DTX_N: JNGFF1.21 UH1.BD4
CLK_CNV_PRX_DTX_P: JNGFF1.23 UH1.BE3
CLK_CNV_PTX_DRX_N: JNGFF1.71 UH1.BC5
CLK_CNV_PTX_DRX_P: JNGFF1.73 UH1.BB6
CLK_DDC2_CRT: JCRT1.15 RV120.1 UV6.15
CLK_PCIE_N0: JNGFF2.53 UH1.AJ6
CLK_PCIE_N1: JNGFF1.49 UH1.AH9
CLK_PCIE_N3: JNGFF3.53 UH1.AE6
CLK_PCIE_N4: UH1.AC2 UL1.45
CLK_PCIE_N5: UH1.AB2 UR1.6
CLK_PCIE_P0: JNGFF2.55 UH1.AJ7
CLK_PCIE_P1: JNGFF1.47 UH1.AH10
CLK_PCIE_P3: JNGFF3.55 UH1.AE7
CLK_PCIE_P4: UH1.AC3 UL1.44
CLK_PCIE_P5: UH1.AB3 UR1.5
CLK_TP_SIO_I2C_DAT: CZ81.1 RZ23.2 RZ346.2 UE1.E10
CLK_TP_SIO_R: CZ89.1 JKBTP1.7 RZ19.2 RZ23.1
CLKDET#: T258.1(TP-1) UH1.BF35
CLKREQ_CNV: QZ18.2 RH618.2 RZ4.1 UH1.BA17
CLKREQ_CNV_R: JNGFF1.14 QZ18.3 RZ4.2 RZ376.2
CLKREQ_PCIE#0: JNGFF2.52 RH10.2
CLKREQ_PCIE#0_R: RH10.1 RH123.1 UH1.BF31
CLKREQ_PCIE#1: JNGFF1.53 RH11.2
CLKREQ_PCIE#1_R: RH11.1 RH124.1 UH1.BE31
CLKREQ_PCIE#3: JNGFF3.52 RH13.2
CLKREQ_PCIE#3_R: RH13.1 RH126.1 UH1.BB30
CLKREQ_PCIE#4: RH14.2 RL4.1 UL1.48
CLKREQ_PCIE#4_R: RH14.1 RH127.1 UH1.BA30
CLKREQ_PCIE#5: RH15.2 UR1.2
CLKREQ_PCIE#5_R: RH15.1 RH131.1 UH1.AN29
CLKREQ_PCIE#6_R: RH132.1 UH1.AE47
CLKREQ_PCIE#7_R: RH133.1 UH1.AC48
CLKRUN#: T287.1(TP-1) UH1.AV32
CMOUT: PQ1210.2 PQ1210.3 PQ1216.2 PR951.1
CNV_BRI_PRX_DTX: RH614.2 RZ1381.1 UH1.AY2
CNV_BRI_PRX_DTX_R: JNGFF1.22 RZ1381.2
CNV_BRI_PTX_DRX: RH603.1 RH604.1 RZ1384.1 UH1.AV4
CNV_BRI_PTX_DRX_R: JNGFF1.36 RZ1384.2
CNV_COEX1: RH607.1 RH608.1 RZ373.2 UH1.AU9
CNV_COEX2: RZ372.2 UH1.AW2
CNV_COEX3: RZ374.2 UH1.AV6
CNV_DET#: JNGFF1.13 RE562.1 RZ7.1 RZ380.2
CNV_DET#_EC: RE100.2 RE101.2 RE562.2 UE1.L11
CNV_DET#_R: RE101.1 RH623.2 RH624.2
CNV_EN#: RH622.2 RH623.1 UH1.AW21
CNV_PRX_DTX_N0: JNGFF1.15 UH1.BB3
CNV_PRX_DTX_N1: JNGFF1.9 UH1.BA3
CNV_PRX_DTX_P0: JNGFF1.17 UH1.BB4
CNV_PRX_DTX_P1: JNGFF1.11 UH1.BA2
CNV_PTX_DRX_N0: JNGFF1.65 UH1.BE6
CNV_PTX_DRX_N1: JNGFF1.59 UH1.BG6
CNV_PTX_DRX_P0: JNGFF1.67 UH1.BD7
CNV_PTX_DRX_P1: JNGFF1.61 UH1.BF6
CNV_RF_RST: QZ17.5 QZ17.6 RE100.1 RZ377.2
CNV_RF_RST#: QZ17.2 RH617.2 RZ3.1 UH1.BE16
CNV_RF_RST#_R: JNGFF1.10 QZ17.3 RZ3.2 RZ378.2
CNV_RGI_PRX_DTX: RH613.2 RZ1383.1 UH1.AV3
CNV_RGI_PRX_DTX_R: JNGFF1.34 RZ1383.2
CNV_RGI_PTX_DRX: RH605.1 RH606.1 RZ1382.1 UH1.BA4
CNV_RGI_PTX_DRX_R: JNGFF1.32 RZ1382.2
CNV_WT_RCOMP: RH612.2 UH1.BA1
COMP_1PH: PC1709.2 PC1710.2 PU1700.50
COMP_2PH: PC1717.2 PC1721.2 PU1700.33
COMP_4PH: PC1714.1 PR1737.1 PU1700.6
COMP_ISL88738: PC943.1 PR934.1 PU901.28
CONTACTLESS_DET#: DZ8.2 RH90.2 UH1.BG8
CONTACTLESS_DET#_R: DZ8.1 JUSH1.23
CORE_SW1: PC1815.1 PL1802.1 PU1800.11 PU1800.12
CORE_SW2: PC1825.1 PL1803.1 PU1801.11 PU1801.12
CORE_SW3: PC1909.1 PL1900.1 PU1900.11 PU1900.12
