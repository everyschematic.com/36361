# Allegro board LA-F711P R05-0112.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DP_RP_CADET: length 3.3
  TOP w0.102: RV74.1 280.68,39.43 280.22,39.43 v1(279.83,39.04) 278.78,37.99 UV9.10
DP_RP_CEXT: length 5.2
  TOP w0.102: v1(282.89,33.67) 282.75,33.81 281.35,33.81 CV75.1 280.73,33.18 279.65,33.18 278.85,33.99 UV9.2
DP_RP_CFG0: length 4.5
  TOP w0.102: UV9.5 279.43,35.49 279.91,35.97 v1(279.91,36.36) 279.91,36.64 280.18,36.92 RV83.1 RV84.1
DP_RP_CFG1: length 2.9
  TOP w0.102: UV9.40 273.5,31.75 273.85,31.4 RV81.1 272.98,30.83 RV82.1
DP_RP_I2C: length 3.2
  TOP w0.102: RV76.1 280.87,34.25 280.32,33.71 v1(279.78,33.71) 278.99,34.49 UV9.3
DP_RP_PD#: length 2.5
  TOP w0.102: RV89.2 v1(270.01,39.31) 270.06,39.31 270.88,38.49 UV9.26
DP_RP_PEQ: length 3.6
  TOP w0.102: UV9.4 v1(279.88,34.99) 280.76,34.99 RV80.1 RV79.1
DP_RP_REXT: length 6
  TOP w0.102: v1(282.86,39.37) 282.65,39.15 281.36,39.15 RV50.1 280.42,38.21 280.42,37.82 279.09,36.49 UV9.7
DP_RP_RST#: length 4.1
  TOP w0.102: RV621.2 269.58,32.05 269.55,32.08 CV631.1 269.57,32.52 v1(269.57,33.58) 269.57,33.95 269.68,34.06 270.4,34.06 270.47,33.99 UV9.35
DRON: length 120.5
  TOP w0.203: v2(44.55,61.24) 44.62,61.24 45.25,61.87 47.47,61.87 v1(49.96,64.37) 50.87,65.27 50.87,75.05 v2(51.29,75.48) ; v2(52.69,83.43) 52.85,83.59 PU1700.17
  IN2 w0.254: v2(87.19,95.25) 87.15,95.29 84.59,95.29 83.8,96.08 83.8,102.81 83.2,103.42 77.94,103.42 77.31,102.79 77.31,100.43 76.81,99.92 v2(76.27,99.92) 76.27,100.54 74.71,102.09 69.19,102.09 68.64,101.55 68.64,101.09 67.09,99.54 v2(66.74,99.54) 66,99.54 60.59,94.13 56.13,94.13 53.42,91.43 53.42,89.76 54.76,88.42 54.76,87.43 53.1,85.78 52.9,85.78 52.35,85.23 52.35,83.78 v2(52.69,83.43)
  IN3 w0.254: v2(87.19,95.25) 87.19,95.61 87.9,96.32 89.31,96.32 90.28,95.35 v2(96.59,95.35) 96.59,95.72 96.75,95.88 101.53,95.88 106.33,91.08 106.33,88.38 v2(106.07,88.13) ; v2(51.29,75.48) 51.8,75.48 52.55,76.24 52.55,79.11 53.46,80.01 53.46,82.98 53.01,83.43 v2(52.69,83.43)
  BOTTOM w0.254: PU1801.16 76.69,99.5 v2(76.27,99.92) ; v2(87.19,95.25) 87.27,95.32 PU1900.16 ; PU1901.16 96.91,95.71 96.59,95.4 v2(96.59,95.35) ; v2(66.74,99.54) 66.96,99.32 PU1800.16 ; v2(106.07,88.13) 106.69,88.13 106.92,88.35 PU2001.16 ; v2(44.55,61.24) 44.7,61.39 PU2000.16
EC_FPM_EN: length 39.9
  TOP w0.104: UE1.D6 v2(317.32,38.35)
  IN3 w0.102: v2(318.14,26.15) 317.37,26.92 317.37,27.95 313.54,31.78 313.54,34.08 315.02,35.57 315.08,35.57 315.3,35.79 315.3,36.07 315.58,36.35 315.86,36.35 316.14,36.63 316.14,36.91 316.4,37.17 316.68,37.17 316.91,37.4 316.91,37.87 317.32,38.28 v2(317.32,38.35)
  BOTTOM w0.102: JUSH1.5 310.33,8.85 310,9.17 310,9.77 310.57,10.34 310.57,10.83 310.83,11.09 310.83,11.09 311.15,11.41 311.44,11.41 311.69,11.66 313.14,11.66 313.34,11.45 313.84,11.45 v1(314.43,12.05) 317.5,15.12 317.5,25.68 317.97,26.15 v2(318.14,26.15)
EDP_AUXN: length 66.9
  IN1 w0.099: v2(123.86,93.99) 123.86,94.26 123.71,94.41 123.08,94.41 122.81,94.68 122.81,96.98 116.73,103.05 115.65,103.05 115.33,103.38 112.01,103.38 111.07,102.44 107.21,102.44 107.09,102.31 107.09,102.16 v2(107.4,101.85)
  BOTTOM w0.076: UC1.B26 120.33,71.93 120.23,72.03 120.09,72.03 119.99,71.93 119.99,71.44 120.09,71.34 121.19,71.34 121.44,71.08 121.73,71.08 121.74,71.09 121.76,71.09
  BOTTOM w0.097: v2(107.4,101.85) 107.12,102.12 107.12,102.36 CV1.1 ; 121.76,71.09 127.17,71.09 128.87,72.8 130.78,72.8 134.79,76.81 134.79,85.67 125.51,94.96 125.09,94.96 124.46,94.33 124.19,94.33 v2(123.86,93.99)
EDP_AUXN_C: length 3.2
  BOTTOM w0.097: CV1.2 107.12,103.97 107.12,104.26 107.49,104.63 107.49,105.48 107.65,105.64 JEDP1.33
EDP_AUXP: length 66.9
  IN1 w0.099: v2(106.66,101.85) 106.88,102.07 106.88,102.4 107.13,102.65 110.98,102.65 111.92,103.59 115.42,103.59 115.74,103.26 116.82,103.26 123.02,97.07 123.02,94.77 123.17,94.62 123.64,94.62 v2(123.83,94.81)
  BOTTOM w0.076: UC1.C26 119.82,71.53 119.82,71.37 120.02,71.17 121.12,71.17 121.37,70.92 121.73,70.92 121.74,70.91 121.76,70.91
  BOTTOM w0.097: 121.76,70.91 127.24,70.91 128.94,72.61 130.86,72.61 134.98,76.73 134.98,85.75 125.58,95.15 125.01,95.15 124.38,94.51 124.12,94.51 v2(123.83,94.81) ; CV2.1 106.93,102.36 106.93,102.12 v2(106.66,101.85)
EDP_AUXP_C: length 3.2
  BOTTOM w0.097: JEDP1.34 107.15,105.63 107.31,105.48 107.31,104.71 106.94,104.34 106.94,103.98 CV2.2
EDP_COMP: length 5.8
  TOP w0.127: v2(119.07,79.28) 119.16,79.28 120.31,80.43 120.31,81.5 119.91,81.9 119.91,83.13 RC1.1
  BOTTOM w0.305: UC1.D37 119,79.22 v2(119.07,79.28)
EDP_HPD: length 158.2
  TOP w0.089: v2(208.76,40.96) 208.75,40.98 208.75,41.93 208.32,42.36 208.32,43.53 209.84,45.05 209.84,46.19 RH1.2 211.06,47.41 211.06,48.63 211.31,48.88 211.31,50.17
  TOP w0.102: 211.31,50.17 211.31,54.03 206.3,59.04 192.3,59.04 188.92,62.42 185.54,62.42 v1(171.02,76.93) 168.33,79.62 168.33,89.38 v2(169.15,90.19)
  BOTTOM w0.089: UH1.AN6 208.34,41.08 208.49,40.93 208.73,40.93 v2(208.76,40.96)
  BOTTOM w0.102: v2(169.15,90.19) 168.86,90.19 162.84,96.21 162.84,97.95 143.11,117.68 127.63,117.68 117.67,107.72 111.43,107.72 111.15,107.44 JEDP1.26 111.15,105.77 111,105.62 111,104.38 RV7.1
EDP_TXN0: length 67.1
  IN1 w0.099: v2(123.9,91.13) 124.09,91.33 124.47,91.33 124.76,91.62 124.76,97.53 118.41,103.88 116,103.88 115.67,104.2 111.16,104.2 110.73,103.77 106.21,103.77 104.92,102.48 104.92,101.99 v2(104.85,101.92)
  BOTTOM w0.076: 122.62,73.74 122.6,73.74 122.59,73.73 122.58,73.73 122.01,74.3 121.41,74.3 121.19,74.51 119.11,74.51 118.63,74.03 UC1.E29
  BOTTOM w0.097: v2(104.85,101.92) 105.13,102.2 105.13,102.38 CV4.1 ; 122.62,73.74 123.43,73.74 123.63,73.53 127.25,73.53 128.11,74.4 129.1,74.4 130.35,75.64 130.6,75.64 133.21,78.25 133.21,83.14 124.87,91.48 124.24,91.48 v2(123.9,91.13)
EDP_TXN0_C: length 3.5
  BOTTOM w0.097: JEDP1.36 106.15,105.63 106.31,105.48 106.31,105.27 105.18,104.15 105.18,103.99 CV4.2
EDP_TXN1: length 75.6
  IN1 w0.099: v2(125.23,93.07) 125.29,93.13 125.79,93.13 126.08,93.42 126.08,99.06 120.21,104.93 118.54,104.93 117.24,106.22 106.32,106.22 103.77,103.67 v2(101.44,103.67)
  BOTTOM w0.076: UC1.E28 118.28,73.14 118.1,73.14 118.03,73.07 118.03,72.98 118.1,72.9 121.73,72.9 121.87,73.04 122.55,73.04 122.57,73.05 122.58,73.05
  BOTTOM w0.097: CV6.1 101.94,103.4 101.72,103.4 v2(101.44,103.67) ; v2(125.23,93.07) 125.14,93.07 125.04,93.16 125.04,93.43 125.14,93.53 125.85,93.53 134.08,85.29 134.08,77.83 129.88,73.63 128.57,73.63 127.86,72.92 123.22,72.92 123.09,73.05 122.58,73.05
EDP_TXN1_C: length 5
  BOTTOM w0.097: JEDP1.38 105.15,105.78 105.46,105.47 105.46,105.35 104.01,103.89 104.01,103.36 103.83,103.18 103.67,103.18 103.18,103.67 CV6.2
EDP_TXP0: length 67.1
  IN1 w0.099: v2(123.87,92.02) 123.74,92.02 123.64,91.92 123.64,91.67 123.77,91.54 124.39,91.54 124.55,91.7 124.55,97.44 118.33,103.67 115.91,103.67 115.58,103.99 111.25,103.99 110.82,103.56 106.3,103.56 105.13,102.4 105.13,102.22 105.43,101.92 v2(105.59,101.92)
  BOTTOM w0.076: UC1.D29 119.03,74.2 119.18,74.35 121.12,74.35 121.34,74.13 121.94,74.13 122.51,73.56 122.59,73.56 122.6,73.55 122.62,73.55
  BOTTOM w0.097: CV3.1 105.32,102.33 105.32,102.2 v2(105.59,101.92) ; v2(123.87,92.02) 124.22,91.67 124.95,91.67 133.4,83.22 133.4,78.17 130.68,75.46 130.43,75.46 129.18,74.21 128.19,74.21 127.33,73.35 123.55,73.35 123.35,73.55 122.62,73.55
EDP_TXP0_C: length 3.5
  BOTTOM w0.097: CV3.2 105.37,103.94 105.37,104.08 106.49,105.2 106.49,105.48 106.65,105.64 JEDP1.35
EDP_TXP1: length 75.6
  IN1 w0.099: v2(101.44,102.94) 101.44,103.1 101.8,103.46 103.86,103.46 106.41,106.01 117.16,106.01 118.45,104.72 120.13,104.72 125.87,98.97 125.87,93.51 125.7,93.34 125.61,93.34 125.25,93.69 v2(125.25,93.94)
  BOTTOM w0.076: UC1.F28 117.84,73.14 117.84,73.13 117.86,73.11 117.86,72.91 118.04,72.73 121.8,72.73 121.94,72.87 122.55,72.87 122.57,72.86 122.58,72.86
  BOTTOM w0.097: 122.58,72.86 123.02,72.86 123.14,72.74 127.94,72.74 128.65,73.45 129.96,73.45 134.27,77.76 134.27,85.37 125.92,93.71 125.48,93.71 v2(125.25,93.94) ; CV5.1 101.89,103.21 101.72,103.21 v2(101.44,102.94)
EDP_TXP1_C: length 4.9
  BOTTOM w0.097: CV5.2 103.34,103 103.91,103 104.19,103.28 104.19,103.82 105.65,105.27 105.65,105.71 105.65,105.72 JEDP1.37
EN_0.6V: length 4.4
  TOP w0.254: PR212.1 42.54,10.57 42.61,10.49 PC222.1 43.56,10.49 43.61,10.54 PR210.1 44,9.98 v1(44.4,9.59) v2(44.93,9.59)
  BOTTOM w0.254: v2(44.93,9.59) 45.16,9.35 PU200.2
EN_1.2RUN: length 6.7
  TOP w0.102: PR2010.2 153.78,125.63 154.24,125.17 v1(155.88,125.17)
  TOP w0.254: PR2010.2 PR511.2 153.76,126.53 PR509.1 PC510.1 151.51,126.53 150.96,125.99 PU502.5
EN_1.2V: length 4.5
  BOTTOM w0.254: PU200.1 44.71,9.11 44.03,9.8 v1(44.03,9.92) 43.45,10.49 PR208.1 42.6,10.49 42.59,10.48 PC221.1 41.58,10.48 41.57,10.49 PR209.1
EN_1.8VALW: length 4.7
  TOP w0.102: v1(125.52,7.95) PR504.2
  TOP w0.254: v2(122.54,7.21) 122.35,7.41 PC505.1 PR505.1 PR504.2
  BOTTOM w0.254: v2(122.54,7.21) 122.6,7.16 PU501.1
EN_1VS_VCCIO: length 4.7
  TOP w0.102: PR403.1 153.86,58.02 v1(153.86,59.13)
  TOP w0.254: v2(153.03,57.99) 153.04,58 PR403.1 PC415.1 PR402.2
  BOTTOM w0.254: v2(153.03,57.99) 152.79,58.23 PU401.13
EN_+1VALWP:
  vias: v1(166.35,8.42) v2(166.84,8.17)
EN_INVPWR: length 262.1
  TOP w0.102: v2(290.43,40.44) 288.69,40.44 285.01,36.77 285.01,33.67 277.08,25.74 261.84,25.74 261.29,26.3 261.29,34.19 256.57,38.9 252.62,38.9 251.96,39.56 245.04,39.56 241.5,43.1 239.62,43.1 238.12,44.6 237.09,44.6 224.52,57.18 220.62,57.18 215.94,61.85 215.94,62.82 203.86,74.9 184.01,74.9 183.5,74.39 183.5,73.49 182.93,72.92 181.91,72.92 181.53,73.3 v2(180.13,73.3) ; v2(298.11,41.9) 298.1,41.91 298.1,51.71 298.93,52.54 301.51,52.54 302.08,53.11 304.11,53.11 304.21,53.01 305.25,53.01 306.35,51.92 306.35,50.8 308.43,48.72 308.43,48.62 310.42,46.63 310.42,45.65 RE55.1 ; QV2.2 126.52,107.54 v1(126.84,107.22) 129.56,104.5 132.66,104.5 134.9,106.73 140.32,106.73 v2(141.45,105.6)
  TOP w0.104: RE55.1 310,44.78 311.36,43.43 311.36,42.47 313.24,40.59 313.24,40.37 313.58,40.02 314.04,40.02 UE1.B2
  IN1 w0.099: v2(180.13,73.3) 179.24,73.3 178.81,73.74 175.48,73.74 173.5,75.72 170.35,75.72 154.42,91.66 154.42,94.09 142.91,105.6 v2(141.45,105.6)
  BOTTOM w0.102: v2(290.43,40.44) 291.27,41.29 292.46,41.29 292.83,40.92 297.02,40.92 297.76,41.66 298,41.9 v2(298.11,41.9)
EN_LCDPWR: length 5.8
  BOTTOM w0.102: UV24.4 144.78,108.8 RV3.2 144.78,109.34 DV3.1 v1(141.82,110.96)
EN_PD_HV_1: length 77
  TOP w0.254: PQ1214.5 61.49,101.27 61.05,100.82 PR1210.1 PR1211.1 60.83,101.83 v2(61.26,102.26) v1(61.26,104.77) 61.26,105.1 61.48,105.32 PR1254.1
  IN1 w0.254: v2(46.73,98.35) 46.27,98.81 40.78,98.81 34.93,92.96 27.91,92.96 24.68,89.74 24.68,85.7 v2(26.13,84.25)
  BOTTOM w0.254: PR1250.2 48.29,98.39 47.7,98.98 47.7,99.47 47.46,99.71 47.01,99.71 46.73,99.43 v2(46.73,98.35) 46.51,98.35 46.4,98.46 46.14,98.46 46.14,98.46 45.78,98.46 45.45,98.14 45.45,96.64 45.93,96.16 46.39,96.16 47.15,96.93 49.68,96.93 49.83,97.08 49.83,99.8 50.72,100.69 50.72,101.85 51.74,102.87 52.88,102.87 53.51,102.23 55.93,102.23 56.61,102.92 59.51,102.92 60.17,102.26 v2(61.26,102.26) 62.71,103.71 62.71,108.56 62.33,108.94 PR1260.1 ; RT70.2 26.13,84.26 v2(26.13,84.25)
EN_PD_HV_1#: length 3.5
  TOP w0.102: PR1253.2 v1(64.75,100.89)
  TOP w0.254: PQ1214.2 63.39,101.27 63.24,101.43 63.24,101.77 63.39,101.92 PQ1214.3 64.71,101.92 PR1253.2
EN_PD_HV_1_R: length 3.2
  BOTTOM w0.076: v1(29.13,85.88) 29.16,85.91 29.16,85.91 29.68,86.43 30.62,86.43 UT5.C2
  BOTTOM w0.102: 28.77,85.67 28.92,85.67 29.13,85.88 v1(29.13,85.88)
  BOTTOM w0.104: 28.77,85.67 28.54,85.43 RT70.1
ENABLE_DS#: length 9.8
  TOP w0.102: v1(307.08,28.07) 307.08,28.89 RE549.2 308.26,30.07 RE550.1 308.72,30.07 308.9,29.9 310.81,29.9 311.16,30.24 311.82,30.24
  TOP w0.104: 311.82,30.24 313.53,31.95 314.12,31.95 UE1.L2
ENLDO_3V5V: length 268.8
  TOP w0.102: v2(181.58,25.51) 182.13,25.51 182.23,25.62 182.23,26.68 182.99,27.44 182.99,29.93 183.6,30.54 183.6,31.9 175.42,40.08 173.75,40.08 169.28,44.56 169.28,53.21 168.07,54.42 168.07,67.11 167.33,67.84 167.33,75.19 166.11,76.41 166.11,94.08 167.05,95.02 v1(167.05,105.73) 167.05,109.24 v2(167.94,110.13)
  TOP w0.254: v2(121.33,134.24) 121.33,133.7 121.89,133.14 PU102.11
  IN1 w0.099: v2(167.94,110.13) 167.11,110.13 153.79,123.46 127.95,123.46 126.24,125.17 123.47,125.17 121.86,126.78 121.86,133.58 121.33,134.11 v2(121.33,134.24)
  IN2 w0.102: v2(86.81,10.36) 86.81,10.53 88.73,12.45 96.9,12.45 97.48,13.03 109.31,13.03 110.07,12.27 110.51,12.27 111.22,12.98 112.03,12.98 112.74,12.27 134.27,12.27 134.86,11.68 137,11.68 137.2,11.48 138.31,11.48 138.91,12.08 153.88,12.08 154.01,11.94 157.48,11.94 159.75,14.21 171.1,14.21 171.22,14.33 174.65,14.33 175.05,14.73 176.36,14.73 177.33,15.71 179.92,15.71 180.9,16.69 180.9,24.83 v2(181.58,25.51)
  BOTTOM w0.254: v2(86.81,10.36) 86.28,10.89 PR103.1 PR102.1 86.37,9.99 87.11,9.25 PU100.11
ENVDD_PCH: length 139.7
  IN1 w0.122: v2(211.68,22.46) 211.67,22.46 211.44,22.46 210.96,22.94 210.96,23.32 209.32,24.96 208.82,24.96 208.21,25.58 208.03,25.58 208.02,25.57 207.81,25.57 207.19,26.2 207.19,26.43 206.08,27.54 206.08,33.24 206.95,34.11 206.95,34.11 207.18,34.33 207.18,34.34 207.21,34.37 207.21,36.04 v2(207.85,36.67)
  IN2 w0.102: v2(175.29,83.72) 175.22,83.64 175.22,60.3 175.27,60.25 175.27,50.39 174.93,50.05 174.93,44.94 175.56,44.31 194.83,44.31 195.87,43.27 204.45,43.27 205.69,42.04 205.69,40.69 205.81,40.56 205.81,38.07 206.27,37.62 206.84,37.62 207.79,36.67 v2(207.85,36.67)
  BOTTOM w0.089: v2(211.68,22.46) 211.65,22.49 UH1.AV44
  BOTTOM w0.102: v2(175.29,83.72) 170.28,83.72 159.53,94.46 159.53,98.59 147.81,110.31 DV3.3
ESPI_ALERT#: length 162.9
  TOP w0.089: v2(217.86,25.82) v1(217.49,26.19) 217.05,26.63 RH340.1
  TOP w0.102: v2(319.74,34.39) 319.67,34.31 318.95,34.31 318.52,34.74 UE1.H7 ; v2(217.86,25.82) 217.86,25.58 217.53,25.25 214.31,25.25 212.41,26.48 v2(211.02,26.48)
  IN3 w0.089: v2(217.86,25.82) 216.25,24.21 216.25,23.2
  IN3 w0.102: v2(282.05,17.62) 280.24,17.62 279.5,16.89 278.57,16.89 277.47,15.78 267.77,15.78 267.25,15.26 254.16,15.26 253.55,15.87 243.42,15.87 242.94,16.36 237.54,16.36 237.06,15.87 235.54,15.87 233.7,17.72 229.77,17.72 229.21,18.28 224.86,18.28 222.08,21.06 219.88,21.06 219.88,21.05 216.45,21.05 216.09,21.41 216.09,23.04 216.25,23.2
  BOTTOM w0.089: UH1.AW35 211.12,26.48 v2(211.02,26.48)
  BOTTOM w0.102: v2(319.74,34.39) 319.74,34.32 319.07,33.65 319.07,31.56 318.28,30.77 317.4,30.77 316.58,29.95 314.64,29.95 313.77,30.82 310.37,30.82 308.73,32.46 308.73,35.05 308.05,35.73 308.05,36.8 307.46,37.39 307.46,42.81 307.02,43.25 304.85,43.25 304.4,43.7 301.44,43.7 298.92,46.22 292.08,46.22 288.72,42.86 288.72,35.8 281.09,28.18 281.09,25.52 281,25.42 281,19.69 282.05,18.63 v2(282.05,17.62)
ESPI_CLK: length 11.6
  TOP w0.102: 218.52,22.65 v1(218.52,23.06) 218.52,23.32 217.13,24.71 214.72,24.71 214.37,25.06 213.93,25.06 213.55,25.44 213.43,25.44 213.13,25.74 v2(212.68,25.74)
  TOP w0.107: 218.52,22.65 218.52,22.35 218.02,21.85 218.02,21.55 218.77,20.8 218.99,20.8 RH97.1
  BOTTOM w0.089: v2(212.68,25.74) 212.68,25.96 UH1.BB36
ESPI_CLK_5105: length 125.2
  TOP w0.107: v2(228.96,24.66) 227.48,23.18 227.48,22.88 225.75,21.16 225.1,21.16 224.63,21.63 223.73,21.63 223.27,22.08 222.31,22.08 CC316.1 220.66,21.55 RH97.2 ; UE1.G7 318.1,35.97 317.34,35.97 v2(317.32,35.95)
  IN1 w0.099: v2(269.99,21.77) 269.99,21.52 269.62,21.15 252.55,21.15 252.12,21.59 250.78,21.59 250.34,21.15 247.4,21.15 246.64,20.4 243.18,20.4 241.99,21.59 241.11,21.59 239.69,23 239.09,23 238.89,23.21 234.74,23.21 233.8,24.15 231.46,24.15 231.04,24.56 229.05,24.56 v2(228.96,24.66) ; v2(313.55,19.6) 313.55,20.05 314.44,20.94 314.44,24.19 314.33,24.29 314.33,25.48 315.13,26.28 315.13,28.98 315.34,29.19 315.34,32.11 315.6,32.37 315.88,32.37 316.14,32.63 316.14,34.77 v2(317.32,35.95)
  IN3 w0.102: v2(270.59,21.73) 270.74,21.58 271.69,21.58 272.39,20.88 276.93,20.88 277.47,21.42 290.82,21.42 291.72,20.52 295.02,20.52 295.85,21.35 300.75,21.35 302.43,19.68 313.48,19.68 v2(313.55,19.6)
  BOTTOM w0.107: v2(269.99,21.77) 269.99,22.45 269.58,22.86 JESPI.10 269.58,23.53 269.69,23.65 270.2,23.65 270.95,22.9 270.95,22.09 v2(270.59,21.73) ; RE350.1 317.51,35.95 v2(317.32,35.95)
ESPI_CS#: length 145.4
  TOP w0.102: UE1.H6 v2(317.32,34.35) ; v2(279.73,22.03) 279.73,21.97 278.98,21.23 v1(277.15,21.23) 269.19,21.23 268.65,21.77 v2(268.37,21.77)
  IN1 w0.089: 223.61,24.36 223.56,24.36 223.36,24.15 220.71,24.15 220.16,24.7 v2(219.86,24.7)
  IN1 w0.099: 223.61,24.36 224.34,24.36 224.91,23.79 226.26,23.79 227.51,22.54 229.13,22.54 230.24,21.43 236.9,21.43 237.08,21.61 239.8,21.61 240.73,20.68 241.62,20.68 242.81,19.49 247.02,19.49 247.67,20.14 250.66,20.14 v2(251.1,19.7)
  BOTTOM w0.089: UH1.BE38 214.61,25.28 214.99,25.28 216.17,25.28 216.2,25.25 217.72,25.25 218.6,24.38 219.54,24.38 v2(219.86,24.7)
  BOTTOM w0.102: v2(251.1,19.7) 252.33,19.7 254.87,22.24 262.33,22.24 264.3,24.21 264.72,24.21 265.36,24.84 267.54,24.84 268.08,24.31 JESPI.7 268.08,22.29 268.37,22 v2(268.37,21.77) ; v2(317.32,34.35) 317.32,34.31 317.7,33.93 317.7,31.79 316.27,30.36 314.81,30.36 313.9,31.27 310.39,31.27 309.04,32.62 309.04,35.18 308.36,35.86 308.36,37.78 307.77,38.37 307.77,43.03 307.24,43.56 304.98,43.56 304.53,44 301.57,44 299.05,46.53 291.95,46.53 287.97,42.55 287.97,35.92 280.46,28.41 280.46,26.42 279.75,25.7 279.75,22.05 v2(279.73,22.03)
ESPI_IO0: length 127.4
  TOP w0.102: UE1.K5 v2(316.52,32.75) ; v2(277.81,22.03) 276.7,23.14 v1(275.74,23.14) 267,23.14 265.96,22.1 v2(265.96,21.74)
  IN1 w0.099: v2(228.34,28.06) 229.26,28.06 231.96,25.36 236.1,25.36 237.04,24.42 239.39,24.42 239.59,24.21 240.2,24.21 241.61,22.8 264.59,22.8 265.53,23.74 v2(265.53,23.86)
  BOTTOM w0.102: RC366.2 228.49,27.91 v2(228.34,28.06) ; v2(316.52,32.75) 316.52,32.5 316.1,32.08 316.1,31.79 315.84,31.53 315.56,31.53 315.4,31.36 314.68,31.36 314.17,31.88 310.93,31.88 309.93,32.88 309.93,35.27 310.52,35.87 310.52,37.81 310.28,38.05 309.38,38.05 308.68,38.75 308.68,43.75 307.96,44.47 305.36,44.47 304.91,44.92 301.95,44.92 299.43,47.44 290.68,47.44 287.06,43.82 287.06,36.3 279.55,28.79 279.55,27.83 278.17,26.45 278.17,23.22 277.81,22.86 v2(277.81,22.03) ; v2(265.53,23.86) 266.08,23.32 JESPI.3 266.08,22.22 265.96,22.1 v2(265.96,21.74)
ESPI_IO0_R: length 17.4
  IN2 w0.102: v2(212.9,24.42) 212.92,24.42 212.98,24.48 214.65,24.48 215.14,23.99 223.93,23.99 224.65,24.71 226.63,24.71 227.69,25.77 v2(227.78,25.77)
  BOTTOM w0.089: v2(212.9,24.42) 212.88,24.45 UH1.BB39
  BOTTOM w0.102: v2(227.78,25.77) 228.49,26.49 RC366.1
ESPI_IO1: length 128
  TOP w0.102: v2(277.16,22.03) 276.43,22.76 v1(273.57,22.76) 267.25,22.76 266.54,22.05 v2(266.54,21.75) ; UE1.L4 v2(315.72,31.95)
  IN1 w0.099: v2(226.89,28.11) 226.89,27.74 226.99,27.64 226.99,27.59 228.33,26.26 230.64,26.26 231.83,25.06 235.97,25.06 236.92,24.12 239.26,24.12 239.47,23.91 240.07,23.91 241.48,22.5 264.77,22.5 266.12,23.85 v2(266.12,23.89)
  BOTTOM w0.102: v2(315.72,31.95) 315.46,31.95 315.08,31.57 314.76,31.57 314.25,32.08 311.02,32.08 310.14,32.95 310.14,35.2 310.73,35.78 310.73,38.06 310.43,38.36 309.51,38.36 308.99,38.87 308.99,43.88 308.09,44.78 305.48,44.78 304.92,45.34 302.74,45.34 301.43,46.65 300.9,46.65 299.8,47.75 290.55,47.75 286.75,43.94 286.75,36.43 283.5,33.17 282.75,33.17 279.24,29.66 279.24,28.35 277.16,26.26 v2(277.16,22.03) ; RC367.2 226.73,27.95 v2(226.89,28.11) ; v2(266.12,23.89) 266.58,23.43 JESPI.4 266.58,22.11 266.54,22.07 v2(266.54,21.75)
ESPI_IO1_R: length 17.7
  TOP w0.102: v1(226.21,25.59) 226.52,25.89 v2(226.62,25.89)
  IN2 w0.102: v2(212.2,26.07) 212.18,26.05 212.18,25.65 212.67,25.16 215.1,25.16 215.22,25.04 218.22,25.04 218.82,25.63 219.5,25.63 219.77,25.36 226.08,25.36 v2(226.62,25.89)
  BOTTOM w0.089: v2(212.2,26.07) 212.2,25.99 211.98,25.78 UH1.AW37
  BOTTOM w0.102: RC367.1 226.73,26.01 v2(226.62,25.89)
ESPI_IO2: length 114.7
  TOP w0.102: v2(318.12,34.35) 318.12,35.15 UE1.G6 ; v2(280.42,22.03) 279.29,20.9 v1(278.95,20.9) 267.5,20.9 267.13,21.27 v2(267.13,21.77)
  IN1 w0.099: v2(314.17,19.98) 314.34,19.98 315.33,20.97 315.33,23.61 316.91,25.18 316.91,26.45 317.07,26.61 317.07,30.85 317.77,31.55 318.44,31.55 318.7,31.8 318.7,33.79 318.14,34.35 v2(318.12,34.35) ; v2(266.75,23.83) 266.75,23.77 265.18,22.2 241.36,22.2 239.95,23.61 239.34,23.61 239.14,23.81 236.79,23.81 235.85,24.75 231.71,24.75 230.51,25.95 228.2,25.95 v2(226.08,28.08)
  IN3 w0.102: v2(314.17,19.98) 314.17,19.98 313.73,20.42 308.72,20.42 308.61,20.52 302.44,20.52 301.01,21.96 295.6,21.96 294.88,21.23 292.55,21.23 291.76,22.03 v2(280.42,22.03)
  BOTTOM w0.102: v2(226.08,28.08) 225.84,27.84 RC368.2 ; v2(267.13,21.77) 267.13,22.05 267.08,22.1 JESPI.5 267.08,23.52 266.76,23.83 v2(266.75,23.83)
ESPI_IO2_R: length 18.6
  TOP w0.102: v1(224.93,25.63) 225.15,25.86 v2(225.52,25.86)
  IN2 w0.102: v2(210.59,25.51) 210.63,25.51 211.6,26.48 213.09,26.48 213.34,26.73 214.64,26.73 216.02,25.35 217.97,25.35 218.55,25.93 219.63,25.93 219.89,25.67 225.34,25.67 v2(225.52,25.86)
  BOTTOM w0.089: UH1.AV37 210.59,25.79 v2(210.59,25.51)
  BOTTOM w0.102: RC368.1 225.84,26.17 v2(225.52,25.86)
ESPI_IO3: length 128.2
  TOP w0.102: UE1.L5 v2(316.52,31.95) ; v2(267.79,21.77) 267.79,22.1 268.14,22.45 270.76,22.45 271.66,21.56 v1(275,21.56) 278.03,21.56 278.41,21.94 v2(278.41,22.03)
  IN1 w0.099: v2(264.86,23.82) 264.86,23.69 264.27,23.1 241.73,23.1 240.32,24.52 239.72,24.52 239.52,24.72 237.17,24.72 236.23,25.66 232.08,25.66 229.18,28.56 228.23,28.56 v2(227.76,28.09)
  BOTTOM w0.102: v2(316.52,31.95) 316.52,31.41 315.88,30.77 314.98,30.77 314.07,31.67 310.85,31.67 309.66,32.86 309.66,35.39 310.23,35.97 310.23,37.57 310.05,37.75 309.25,37.75 308.38,38.62 308.38,43.63 307.84,44.17 305.23,44.17 304.78,44.61 301.82,44.61 299.3,47.14 291.7,47.14 287.36,42.8 287.36,36.17 279.85,28.66 279.85,27.7 278.79,26.64 278.79,23.2 278.41,22.82 v2(278.41,22.03) ; RC369.2 227.62,27.95 v2(227.76,28.09) ; v2(267.79,21.77) 267.79,22 267.58,22.21 JESPI.6 267.58,24.36 267.45,24.5 265.44,24.5 264.98,24.03 264.98,23.95 v2(264.86,23.82)
ESPI_IO3_R: length 19
  TOP w0.102: v1(226.76,24.37) 227.2,24.81 v2(227.2,25.87)
  IN2 w0.102: v2(227.2,25.87) 227.18,25.87 226.34,25.03 224.32,25.03 223.59,24.29 215.27,24.29 214.73,24.83 212.54,24.83 v2(212.37,24.67)
  BOTTOM w0.089: UH1.BA38 212.21,24.82 v2(212.37,24.67)
  BOTTOM w0.102: v2(227.2,25.87) 227.62,26.29 RC369.1
ESPI_RESET#: length 142.9
  TOP w0.102: UE1.K6 v2(317.32,32.75)
  IN2 w0.102: v2(225.11,24.29) 225.2,24.2 225.34,24.2 225.82,23.72 228.77,23.72 229.62,24.56 233.38,24.56 234.22,23.72 236.51,23.72 237.58,24.79 256.59,24.79 256.84,24.54 261.78,24.54 263.59,22.72 270.53,22.72 271.29,21.96 v2(271.97,21.96) 271.97,22.12 272.68,22.83 278.28,22.83 v2(279.09,22.03)
  BOTTOM w0.089: UH1.BF38 215.2,25.52 215.26,25.47 216.25,25.47 216.28,25.44 217.78,25.44 218.42,24.81 219.25,24.81 219.63,25.19 221.5,25.19 RH95.1 222.35,26.03 RH633.1 224.15,26.03 224.53,25.65 CH348.1 224.56,25.01
  BOTTOM w0.102: RE560.2 270.76,19.94 271.97,21.14 v2(271.97,21.96) ; v2(317.32,32.75) 316.91,32.34 316.91,31.51 315.96,30.56 314.89,30.56 313.99,31.47 310.62,31.47 309.36,32.73 309.36,35.29 308.66,35.99 308.66,37.91 308.07,38.49 308.07,43.41 307.62,43.86 305.1,43.86 304.66,44.31 301.7,44.31 299.17,46.83 291.83,46.83 287.67,42.67 287.67,36.05 280.16,28.54 280.16,27.37 279.09,26.31 v2(279.09,22.03) ; v2(225.11,24.29) 225.11,24.46 224.56,25.01
FB_1.8VALW: length 4.5
  BOTTOM w0.102: PR501.2 v1(120.58,9.94)
  BOTTOM w0.254: PR501.2 120.58,8.91 PC503.2 120.24,7.92 120.1,7.78 PR506.1 119.64,7.39 120,7.04 PU501.6
FB_2PH: length 8
  TOP w0.203: PU1700.34 v2(57.73,74.84) 57.73,74.01 PC1717.1 PR1739.1 58.64,73.08 PC1720.2 57.78,73.07 PR1740.1
FB_4PH: length 5.7
  TOP w0.203: PU1700.5 58.13,87.2 v1(58.35,87.43) 58.64,87.72 PC1714.2 58.64,89.22 PC1716.2 59.5,89.23 PR1731.1 59.51,88.43 PR1734.1
FB_+1VALWP: length 4.3
  TOP w0.254: v2(168.67,8.85) 168.64,8.88 v1(168.64,9.56) 169.12,10.05 PR311.1
  BOTTOM w0.254: PR2008.2 PR306.2 168.67,9.58 v2(168.67,8.85) 168.7,8.83 PU301.14
FFS_INT2: length 100.7
  TOP w0.102: v2(266.3,15.68) 266.3,13.31 265.73,12.74 265.73,11.5 266.87,10.36 266.87,6.65 v1(267.59,5.94) 268.12,5.41 271.98,5.41 272.08,5.31 LGA1.11
  BOTTOM w0.089: UH1.BE14 214.27,37.37 214.49,37.15 215.13,37.15 215.42,36.86 217.01,36.86 217.48,37.33 217.78,37.33 218.09,37.03 218.09,37.02 218.42,36.68 219.02,36.68 219.21,36.88 220.19,36.88 220.47,37.16 220.47,38.21 220.87,38.62 221.72,38.62
  BOTTOM w0.102: v2(266.3,15.68) 266.71,15.27 267.27,15.27 267.78,15.78 267.78,16.14 QN1.2 268.41,16.43 268.41,16.33 268.96,15.79 270.04,15.79 274.88,20.62 274.88,23.37 269.77,28.47 267.22,28.47 265.26,30.43 249.63,30.43 249.27,30.79 245.39,30.79 244.71,31.47 242.62,31.47 236.42,37.66 229.66,37.66 228.65,38.68 227.69,38.68 227.28,39.08 223.88,39.08 223.45,38.65 RH378.2 222.75,39.13 222.24,39.13 221.72,38.62
FFS_INT2_Q: length 5.4
  BOTTOM w0.102: JSATA1.19 264.35,14.34 264.96,14.95 265.57,14.95 265.73,15.11 v1(265.73,15.52) 265.9,15.68 265.9,15.89 266.48,16.47 RN1.2 266.5,16.6 QN1.3
FIVR_EN: length 3.6
  TOP w0.102: RC217.1 RC218.2 RC219.2 v1(55.99,50.37)
FIVR_EN_R: length 21
  TOP w0.102: RC132.2 RC217.2 53.08,47.14 52.16,47.14 v1(51.77,46.75) 50.71,45.69 49.01,45.69 48.47,45.15 48.47,44.13 47.97,43.63 47.97,43.61 47.5,43.14 43.73,43.14 43,42.41 43,41.1 43.67,40.43 JXDP1.45 43.67,37.86 43.74,37.79 RC126.2
GPIO011: length 1.2
  TOP w0.104: UE1.K7 v2(318.12,32.75)
  BOTTOM w0.102: T143.1 318.51,33.14 v2(318.12,32.75)
GPIO100: length 3.1
  TOP w0.102: T144.1 311.51,29.55 313.12,31.16 313.27,31.16
  TOP w0.104: 313.27,31.16 313.66,31.55 UE1.M1
GPP_B23: length 6.1
  TOP w0.089: v1(217.72,28.09) 217.72,28.07 v2(218.19,27.61) 218.3,27.49 RH329.1
  BOTTOM w0.089: UH1.BD33 214.05,27.92 214.72,27.92 214.75,27.95 215.05,27.95 215.25,28.15 217.65,28.15 v2(218.19,27.61)
GPP_C5: length 6.7
  TOP w0.089: v1(220.25,33.15) 220.02,32.91 220.02,32.59 v2(220.01,32.59) 220.02,32.58 RH78.2
  BOTTOM w0.089: UH1.BF24 214.81,32.32 214.91,32.21 215.2,32.21 215.21,32.22 218.6,32.22 218.77,32.4 219.82,32.4 v2(220.01,32.59)
GPP_C23: length 1.1
  TOP w0.089: v2(210.82,34.31) 211.04,34.09 T304.1
  BOTTOM w0.089: UH1.AV21 210.76,34.26 v2(210.82,34.31)
GPP_H12: length 5.5
  TOP w0.089: v2(201.07,18.49) v1(201.07,19.01)
  TOP w0.102: v2(201.07,18.49) RH615.2
  BOTTOM w0.089: UH1.AB47 202.89,21.09 202.59,20.8 202.59,20.42 202.78,20.23 202.78,19.45 202.16,18.83 201.26,18.83 201.07,18.64 v2(201.07,18.49)
GPP_H15: length 5.4
  BOTTOM w0.089: RH601.2 202.33,17.57 v1(202.39,17.63) 202.39,18.78 203.12,19.52 203.12,20.99 203.36,21.23 UH1.AC47
GPP_J1: length 5
  TOP w0.102: RH616.2 211.88,46.48 211.88,45.61 211.73,45.45 v1(211.73,44.94) 211.73,44.39 v2(211.51,44.16)
  BOTTOM w0.089: v2(211.51,44.16) 211.76,43.91 211.76,43.91 211.77,43.9 211.77,43.36 211.57,43.16 211.57,42.69 211.79,42.47 UH1.AY3
GPPJ_RCOMP: length 8.1
  BOTTOM w0.089: RH609.2 218.99,46.04 220.07,46.04 v1(220.43,45.68)
  BOTTOM w0.254: UH1.BD1 UH1.BE1 ; UH1.BE1 214.54,43.64 214.92,44.02 214.97,44.02 216.14,45.18 218.14,45.18 RH609.2 ; UH1.BE1 214.54,43.42 UH1.BE2
GPS_DISABLE#: length 39.5
  TOP w0.102: UE1.H5 316.49,35.18 315.24,35.18 314.92,34.86 v2(314.92,34.35) ; v2(327.63,50.57) 327.63,51.18 328.29,51.84 v1(328.29,52.96) 328.29,56.34 328.6,56.64 328.6,57.79 330.59,59.78 DZ6.1
  IN1 w0.099: v2(327.63,50.57) 326.69,49.63 325.71,49.63 v2(322.24,46.16)
  IN3 w0.102: v2(322.24,46.16) 321.23,45.15 321.23,44.09 318.73,41.59 318.73,36.31 317.57,35.15 317.3,35.15 316.89,34.75 315.34,34.75 314.94,34.35 v2(314.92,34.35)
  BOTTOM w0.102: v2(322.24,46.16) 322.84,46.16 323.13,45.87 RE12.1
GPU_PWR_LEVEL: length 5.9
  TOP w0.089: UE1.E12 322.86,37.15 323.16,36.84 323.45,36.84 323.63,37.03
  TOP w0.102: 323.63,37.03 323.63,37.47 324.98,38.82 324.98,39.67 RE5.1
GPU_SMCLK: length 15.9
  TOP w0.089: UE1.F7 318.55,36.35 318.97,36.77 318.97,38.77 318.8,38.94 318.8,39.12 319,39.32 319,39.71 319.16,39.87 319.61,39.87 319.8,40.06 319.8,40.55 319.99,40.73 319.99,41.13 v2(319.81,41.31)
  TOP w0.102: RPE12.1 326.49,44.21 v2(326.94,44.66)
  IN2 w0.102: v2(319.81,41.31) 319.89,41.31 322.08,43.5 326.44,43.5 326.94,44 v2(326.94,44.66)
GPU_SMDAT: length 16.1
  TOP w0.102: v2(325.13,45.26) 325.72,44.68 325.72,43.89 325.9,43.71 RPE12.2
  TOP w0.104: v2(318.37,45.36) 318.36,45.35 318.21,45.35 317.8,44.94 v1(317.8,44.65) 317.8,42.04 317.53,41.77 317.53,41.58 317.29,41.34 317.29,41.21 317.29,41.2 317.29,40.89 317.29,40.89 317.29,39.98 UE1.B6
  IN2 w0.102: v2(318.37,45.36) 318.92,44.82 321.2,44.82 321.43,44.59 323.34,44.59 323.84,45.09 324.96,45.09 v2(325.13,45.26)
GREEN: length 11.5
  TOP w0.107: v2(358.34,103.3) 358.69,102.95 LV17.2 359.76,102.51 CV130.1 v1(360.92,102.59) 361.41,102.59 362.89,101.12 363.92,101.12 JCRT1.2
  BOTTOM w0.107: v2(358.34,103.3) 357.74,103.91 356.54,103.91 355.82,103.2 DV5.3
GREEN_CRT: length 46.9
  TOP w0.107: UV6.22 330.27,71.43 331.21,72.36 v2(331.21,73.06) ; LV17.1 357.76,101.76 CV127.1 RV117.1 356.08,101.68 v2(355.7,102.06)
  IN1 w0.099: v2(331.21,73.06) 331.21,73.07 331.64,73.5 331.64,80.81 352.89,102.06 v2(355.7,102.06)
GT_SW1: length 1
  BOTTOM w0.102: 49.35,66.31 v1(49.35,67.35)
H_CATERR#: length 12
  BOTTOM w0.076: UC1.BM30 82.66,74.29 80.21,74.29 79.92,74.58 79.6,74.58
  BOTTOM w0.102: 79.6,74.58 79.31,74.29 76.21,74.29 v1(76.17,74.25) 76.1,74.18 76.1,73.24 74.89,72.03 73.29,72.03 73.22,72.1 RC79.2
H_PECI: length 332.6
  TOP w0.102: RE60.2 326.84,34.63 329.04,34.63 329.25,34.84 329.57,34.84 329.92,35.18 330.7,35.18 330.83,35.32 330.83,40.52 329.36,41.99 329.36,45.1 329.84,45.58 329.84,47.43 327.07,50.2 327.07,51.41 327.73,52.07 327.73,55.24 324.85,58.13 324.85,58.66 323.93,59.59 321.36,59.59 319.76,61.19 315.97,61.19 300.73,61.19 v2(296.34,56.79) ; RH73.2 204.99,52.08 205.39,52.48 205.39,53.39 206.51,54.51 v2(206.51,56.67) 205.59,57.59 190.87,57.59 189.52,56.24 187.92,56.24 183.73,60.43 v1(178.44,60.43) 173.5,60.43 169.8,56.72 169.8,55.47 169.22,54.89 v2(169.22,54.89)
  IN3 w0.102: v2(296.34,56.79) 295.82,56.79 282.16,43.14 278.42,43.14 277.12,41.85 277.12,41.41 276.27,40.55 272.14,40.55 271.61,40.02 270.68,40.02 270.63,39.97 269.79,39.97 269.75,39.93 269.66,39.93 267.39,39.25 266.88,38.73 266.01,38.73 265.88,38.61 265.26,38.61 264.84,38.19 263.86,38.19 263.42,37.75 253.45,37.75 252.9,38.29 250.33,38.29 249.46,39.16 244.33,39.16 243.55,39.93 239.64,39.93 234.75,44.81 233.82,44.81 223.15,55.49 218.23,55.49 217.81,55.91 207.27,55.91 v2(206.51,56.67) ; v2(79.41,76.7) 79.41,77.33 77.49,79.25 77.49,80.85 78.73,82.09 81.02,82.09 81.68,82.75 82.35,82.75 82.93,82.17 99.36,82.17 100.35,81.18 116.99,81.18 118.14,82.33 119.36,82.33 121.05,84.02 121.05,84.52 122.43,85.9 130.99,85.9 140.56,76.33 147.5,76.33 165.1,58.73 165.1,55.75 165.96,54.89 169.22,54.89 v2(169.22,54.89)
  BOTTOM w0.076: UC1.BT34 79.58,76.87 v2(79.41,76.7)
H_PM_DOWN: length 166.4
  IN3 w0.102: v2(166.89,52.34) 165.64,52.34 162.21,55.76 162.21,58.74 147.03,73.93 139.71,73.93 137.4,76.24 128.43,76.24 124.3,80.37 123.51,80.37 121.54,78.39 120.82,78.39 120.49,78.73 118.63,78.73 117.32,80.05 114.67,80.05 114.21,80.51 100.52,80.51 100.51,80.51 97.47,80.51 97.35,80.62 79.54,80.62 v2(79.42,80.5)
  BOTTOM w0.089: UH1.AE2 204.61,42.98 204.54,43.05 204.54,45.77 204.21,46.1 204.21,47.17 204.54,47.5 204.54,48.96 202.95,50.55 202.95,51.13 202.73,51.35 202.73,51.99 202.64,52.08 195.28,52.08 194.93,52.44
  BOTTOM w0.102: 194.93,52.44 194,53.36 191.91,53.36 v1(189.08,56.19) 185.24,60.03 177.27,60.03 174.2,56.96 174,56.96 169.38,52.34 v2(166.89,52.34) ; v2(79.42,80.5) 76.3,80.5 75.43,79.64 75.43,78.19 73.31,76.07 73.31,74.35 RC168.1
H_PM_DOWN_R: length 8.8
  BOTTOM w0.076: UC1.BP31 81.31,75.72 80.86,75.72 80.77,75.64 79.68,75.64 79.47,75.85 76.79,75.85 76.46,76.17 v1(76.21,76.17) 75.31,76.17 74.6,75.46
  BOTTOM w0.102: 74.6,75.46 73.86,74.73 RC168.2
H_PM_SYNC: length 159.1
  TOP w0.102: v3(166.32,52.58) 166.59,52.86 v2(166.59,53.12)
  IN3 w0.102: v2(166.59,53.12) 165.36,53.12 162.57,55.91 162.57,58.89 147.17,74.28 139.86,74.28 136.65,77.49 128.08,77.49 124.85,80.72 123.34,80.72 122.42,79.81 122.02,79.81 121.85,79.97 120.48,79.97 120.4,79.9 118.47,79.9 118.21,80.16 117.88,80.16 117.07,80.97 114.89,80.97 114.63,80.71 98.86,80.71 98.26,81.3 94.12,81.3 93.79,80.97 79.21,80.97 78.88,80.64 78.88,80.05 79.91,79.02 v2(79.91,78.05)
  BOTTOM w0.076: UC1.BM34 82.96,77.02 82.63,77.34 82.63,77.83 82.4,78.06 82.19,78.06 82.13,78 81.8,78 81.78,78.03 79.93,78.03 v2(79.91,78.05)
  BOTTOM w0.089: 200.43,52.44 202.87,52.44 203.08,52.24 203.08,51.58 203.3,51.36 203.3,50.7 203.87,50.13 204.34,50.13 204.94,49.53 204.94,49.11 RH156.2
  BOTTOM w0.102: 200.43,52.44 197.27,55.6 193.62,55.6 186.96,62.27 175.67,62.27 169.4,55.99 169.16,55.99 166.59,53.43 v2(166.59,53.12)
H_PM_SYNC_R: length 5.9
  BOTTOM w0.089: UH1.AF3 205.02,42.72 205.02,43.11 204.9,43.24 204.9,46.14
  BOTTOM w0.102: RH156.1 205.14,47.57 204.9,47.33 204.9,47.17 204.77,47.04 v1(204.77,46.7) 204.77,46.26 204.9,46.14
H_PROCHOT#_R: length 8.2
  BOTTOM w0.076: 79.4,74.77 79.5,74.88 80.71,74.88 UC1.BR30
  BOTTOM w0.102: RC84.2 75.16,72.57 75.78,73.19 75.78,74.43 75.98,74.63 v1(78.01,74.63) 79.26,74.63 79.4,74.77
H_PWRGD: length 175.7
  TOP w0.102: v2(170.2,55.88) 170.44,55.88 v3(170.82,56.26)
  IN3 w0.102: v2(75.69,75.79) 75.46,76.02 75.46,81.12 78.06,83.72 80.19,83.72 80.87,84.4 102.6,84.4 104.1,82.89 115.83,82.89 117.57,84.63 117.68,84.63 118.72,85.67 119.33,85.67 121.84,88.19 132.57,88.19 137.39,83.37 143.33,83.37 167.13,59.57 167.13,56.92 168.17,55.88 v2(170.2,55.88)
  BOTTOM w0.076: v2(75.69,75.79) 74.99,75.09 CC300.1
  BOTTOM w0.089: 198.85,52.44 199.03,52.26 202.81,52.26 202.9,52.16 202.9,51.42 203.12,51.2 203.12,50.63 204.72,49.03 204.72,47.42 204.44,47.15 204.44,46.18 204.72,45.9 204.72,43.15 204.83,43.03 204.83,42.74 204.77,42.68 UH1.AE3
  BOTTOM w0.102: UC1.BT31 79.33,75.35 79.09,75.59 75.89,75.59 v2(75.69,75.79) ; 198.85,52.44 196.81,54.48 193.16,54.48 186.5,61.15 176.81,61.15 173.73,58.08 173.06,58.08 170.86,55.88 v2(170.2,55.88)
H_SKTOCC#: length 13.1
  TOP w0.102: v2(71.29,74.85) 71.29,74.33 71.55,74.08 v1(72.03,74.08) 72.97,74.08 73.71,74.82 v2(73.71,75.39)
  BOTTOM w0.076: UC1.BR33 80.66,75.82 80.49,75.82 80.48,75.81 80.23,75.81 80.22,75.82 79.75,75.82 79.54,76.03 79.4,76.03 79.33,76.1
  BOTTOM w0.102: 79.33,76.1 78.6,76.1 77.91,76.78 75.67,76.78 74.86,75.97 74.06,75.97 73.71,75.62 v2(73.71,75.39) ; RC319.2 v2(71.29,74.85)
H_THERMTRIP#: length 445.5
  TOP w0.089: 203.67,50.17 204.77,49.07 RH75.2
  TOP w0.102: v2(141.91,12.74) 141.91,11.76 142.24,11.44 157.61,11.44 159.69,13.52 164.39,13.52 165.12,14.25 170.65,14.25 171.32,14.92 171.32,19.3 172.34,20.32 172.34,20.78 173.83,22.28 175.46,22.28 177.11,23.93 v2(177.16,23.93) ; v2(183.99,21.47) 184.07,21.47 184.98,22.38 184.98,29.71 184.24,30.46 184.24,33.33 176.62,40.94 174.11,40.94 171.33,43.72 171.33,53.82 v2(170.81,54.34) 173.14,56.67 181.25,56.67 182.1,57.52 183.6,57.52 184.45,56.67 184.45,55.23 184.91,54.77 191.4,54.77 192.43,55.8 v1(192.78,55.8) 201.26,55.8 202.46,54.61 202.46,51.38 203.67,50.17 ; RD14.2 61.73,13.65 v2(62.51,12.88) ; v2(320.51,5.92) 320.51,6.08 321.13,6.71 321.13,9.68 321.76,10.31 321.76,11.48 321.22,12.03 QE4.3 ; RC169.1 120.55,85.94 CC323.1 121.19,86.07 RC80.2 121.92,85.82 122.23,85.51 124.62,85.51 125.09,85.05 v2(125.09,84.63)
  TOP w0.104: v2(141.91,12.74) 142.14,12.97 RD27.2
  IN1 w0.099: v2(320.51,5.92) 320.51,6.21 319.68,7.04 312.5,7.04 310.08,4.62 297.99,4.62 297.62,4.99 293.6,4.99 292.68,5.91 292.09,6.5 287.9,6.5 287.1,7.3 277.98,7.3 276.71,8.56 268.71,8.56 266.1,5.96 260.73,5.96 259.26,4.49 255.28,4.49 254.64,3.85 225.38,3.85 223.9,5.33 213.96,5.33 212.02,7.27 210.97,7.27 210.03,8.2 204.47,8.2 203.94,8.73 198.34,8.73 197.77,9.3 196.07,9.3 195.27,10.1 194.44,10.1 183.99,20.55 v2(183.99,21.47)
  IN3 w0.102: v2(62.51,12.88) 62.94,12.45 65.73,12.45 65.99,12.19 81.35,12.19 82.95,13.79 87.41,13.79 88.02,14.4 93.67,14.4 94.2,14.93 99.49,14.93 100.02,14.4 105.66,14.4 105.86,14.2 105.86,14.2 106.83,13.23 110.41,13.23 111.55,12.09 133.65,12.09 135.02,13.46 141.19,13.46 v2(141.91,12.74) ; v2(183.99,21.47) 181.55,21.47 179.68,23.34 177.44,23.34 177.16,23.62 v2(177.16,23.93) ; v2(170.81,54.34) 170.33,54.34 170.32,54.33 165.73,54.33 164.54,55.52 164.54,58.5 147.27,75.77 140.33,75.77 131.47,84.63 v2(125.09,84.63)
H_THERMTRIP#_R: length 11.3
  TOP w0.102: v2(116.36,75.57) 116.83,76.04 116.83,76.09 117.16,76.42 117.31,76.42 117.64,76.76 117.64,76.9 118.41,77.66 118.41,80.16 118.92,80.67 118.92,83.4 v1(119.32,83.8) RC169.2
  BOTTOM w0.102: v2(116.36,75.57) 116.29,75.57 UC1.J31
H_VCCST_PWRGD_XDP: length 5.3
  TOP w0.102: RC124.2 CC307.1 39.92,36.96 v1(40.44,37.37) 41.37,37.37 42.17,38.16 JXDP1.39
HDA_BIT_CLK: length 10.6
  BOTTOM w0.089: RH637.2 220.44,41.89 RH46.2 219.47,41.8 219.17,41.5 CA75.1 219.07,40.94 218.66,40.53 218.66,39.99 218.15,39.48 218.15,38.51 217.89,38.25 215.65,38.25 215.6,38.31 213.83,38.31 UH1.BD11
HDA_BIT_CLK_R: length 148.3
  TOP w0.102: UA1.6 341.12,32.92
  TOP w0.107: v2(343.71,30.38) v1(343.32,29.98) 342.98,29.65 342.15,29.65 341.84,29.96 341.84,30.86 RA17.1 341.12,31.57 341.12,32.92
  IN3 w0.102: v2(343.71,30.38) 342.69,29.36 339.02,29.36 331.49,21.83 317.63,21.83 315.83,23.64 310.45,23.64 309.76,24.33 304.8,24.33 303.97,25.16 303.4,25.16 300.4,28.16 300.4,29.61 298.05,31.97 293.92,31.97 293.45,32.43 285.99,32.43 282.88,29.33 280.63,29.33 278.93,27.62 271.46,27.62 271.04,27.2 269.16,27.2 268.75,26.8 261.59,26.8 261.39,26.59 243.08,26.59 241.7,27.98 238.91,27.98 237.54,29.35 235.9,29.35 233.22,32.03 233.22,33.27 232.07,34.42 231.71,34.42 231.34,34.78 231.34,35.15 228.46,38.03 227.14,38.03 224.27,40.9 v2(224.27,41.17)
  BOTTOM w0.089: 221.72,41.8 RH46.1
  BOTTOM w0.107: 221.72,41.8 CH268.2 222.3,41.8 222.89,41.21 224.23,41.21 v2(224.27,41.17)
HDA_RST#: length 10.6
  BOTTOM w0.089: UH1.BE10 214.23,39.07 214.41,38.89 214.41,38.82 214.54,38.69 215.76,38.69 215.8,38.64 216.24,38.64 216.63,39.03 216.63,39.66 219.17,42.2 219.62,42.2 v1(220.28,42.87) 220.84,43.42 RH50.2 221.26,43.73 RH636.2
HDA_RST#_R: length 152
  TOP w0.102: v2(337.6,22.93) 337.21,22.93 337.11,23.03 v1(337.11,23.84) 337.11,24.57 337.1,24.57 337.1,25.04 336.55,25.6 336.55,26.16 RA50.1
  IN1 w0.099: v2(337.6,22.93) 338.41,22.12 338.41,18.17 336.61,16.37 332.43,16.37 325.05,8.98 315.72,8.98 315.13,8.38 309.76,8.38 309.12,9.02 304.24,9.02 302.69,10.57 301.16,10.57 300.89,10.84 298.72,10.84 298.46,11.1 v2(298.46,11.84)
  BOTTOM w0.102: RH50.1 223.95,43.42 224.27,43.1 224.27,43.09 224.74,42.63 224.74,42.63 224.81,42.56 226.72,42.56 230.44,38.83 236.91,38.83 242.7,33.04 244.93,33.04 245.32,32.65 249.06,32.65 250.1,31.61 266.24,31.61 267.99,29.87 270.03,29.87 276.04,23.85 276.04,17.78 275.69,17.42 275.69,16.3 279.53,12.46 283.41,12.46 284.11,11.76 284.11,10.68 284.36,10.44 289.87,10.44 290.29,10.85 290.29,11.17 291.66,12.53 297.76,12.53 v2(298.46,11.84)
HDA_SDIN0: length 165.3
  TOP w0.102: RA9.1 v2(343.07,30.46)
  IN1 w0.099: v2(290.7,11) 291.22,10.48 292.65,10.48 293.46,11.29 296.75,11.29 297.76,12.3 302.67,12.3 305.22,9.75 306.22,9.75 306.57,10.11 308.35,10.11 309.85,8.61 311.02,8.61 311.62,9.21 324.95,9.21 331.35,15.6 331.35,16.96 334.09,19.71 334.09,19.81 336.93,22.65 336.93,22.84 339.86,25.77 339.86,27.55 342.77,30.46 v2(343.07,30.46)
  BOTTOM w0.089: UH1.BE11 214.41,38.55 214.46,38.5 215.68,38.5 215.72,38.45 216.36,38.45 216.7,38.79 216.7,38.8 216.91,39.01 216.92,39.01 CA73.1 217.71,40.49 219.24,42.03 219.9,42.03 220.79,42.91 221.72,42.91
  BOTTOM w0.102: v2(290.7,11) 290.7,10.77 290.14,10.21 284.26,10.21 283.88,10.59 283.88,11.66 283.32,12.23 279.43,12.23 275.46,16.2 275.46,17.52 275.82,17.87 275.82,23.76 269.93,29.64 267.89,29.64 266.15,31.38 250,31.38 248.96,32.43 245.23,32.43 245.09,32.56 v1(243.75,32.56) 242.86,32.56 236.81,38.6 230.35,38.6 226.63,42.33 224.69,42.33 224.11,42.91 221.72,42.91
HDA_SDIN0_R: length 3.5
  TOP w0.102: UA1.8 341.92,33.74 341.98,33.68 341.98,32.94 v1(342.4,32.52) RA9.2
HDA_SDOUT: length 7.8
  BOTTOM w0.089: RH45.2 RH328.2 220.42,39.87 219.5,38.94 CA76.1
  BOTTOM w0.102: CA76.1 219.06,38.14 218.75,38.14 218.46,37.84 v1(216.96,37.84) 216.69,37.84 216.48,38.05 215.57,38.05 215.54,38.09 215.25,38.09 215.21,38.05 UH1.BF12
HDA_SDOUT_R: length 159.1
  TOP w0.102: UA1.5 v1(340.72,33.57) 340.72,32.78 v2(340.72,32.78)
  IN1 w0.099: v2(340.72,32.78) 340.72,32.28 340.62,32.18 340.62,32.18 338.48,30.04 338.48,28.65 338.84,28.29 338.84,25.06 336.71,22.93 336.71,22.74 333.87,19.9 333.87,19.8 331.12,17.06 331.12,15.69 324.86,9.43 311.52,9.43 310.93,8.83 309.94,8.83 308.44,10.33 306.48,10.33 306.12,9.98 305.31,9.98 302.76,12.53 297.56,12.53 296.55,11.51 291.83,11.51 v2(291.32,11)
  BOTTOM w0.102: RH45.1 222.29,40.93 222.64,40.58 228.05,40.58 230.26,38.38 236.72,38.38 242.91,32.18 248.88,32.18 249.91,31.16 266,31.16 267.74,29.41 269.84,29.41 275.59,23.66 275.59,20.33 273.71,18.45 273.71,16.64 278.35,12 283.22,12 283.62,11.61 283.62,10.53 284.17,9.98 290.39,9.98 291.32,10.91 v2(291.32,11)
HDA_SYNC: length 7
  BOTTOM w0.089: UH1.BG13 216.3,37.86 216.65,37.51 218.22,37.51 v1(218.23,37.49) 218.38,37.49 218.84,37.94 219.62,37.94 CA74.1 220.07,38.79 RH48.2
HDA_SYNC_R: length 168
  TOP w0.102: v2(344.44,32.55) 344.09,32.9 v1(343.99,32.9) 343.77,32.9 343.19,33.49 343.19,33.65 342.72,34.11 UA1.10
  IN1 w0.099: v2(344.44,32.55) 345.15,31.84 345.15,29.65 344.6,29.1 344.34,29.1 339.11,23.87 339.11,17.59 337.37,15.85 332.23,15.85 325.14,8.75 315.82,8.75 315.22,8.16 309.66,8.16 309.02,8.8 304.14,8.8 302.6,10.34 301.07,10.34 300.79,10.62 298.27,10.62 297.88,11.01 v2(297.88,11.85)
  BOTTOM w0.089: 221.72,39.3 221.57,39.15 RH48.1
  BOTTOM w0.102: v2(297.88,11.85) 297.09,11.85 295.33,11.85 291.68,8.19 291.68,7.62 291.31,7.25 288.54,7.25 287.92,7.87 285.77,7.87 283.39,10.25 283.39,11.52 283.13,11.77 278.25,11.77 273.48,16.55 273.48,18.54 275.36,20.42 275.36,23.57 269.97,28.95 267.42,28.95 265.46,30.91 249.83,30.91 249.47,31.27 245.59,31.27 244.91,31.95 242.82,31.95 236.62,38.15 229.86,38.15 228.85,39.16 227.89,39.16 227.43,39.62 222.04,39.62 221.72,39.3
HDD_A_EQ: length 5
  BOTTOM w0.102: RN10.1 250.36,11.16 250.36,12.5 249.92,12.94 RN11.2 249.14,13.64 UN7.17
HDD_A_EQ2: length 4.7
  BOTTOM w0.102: UN7.18 248.64,13.1 RN21.1 248.88,12.92 249.3,12.5 249.3,11.13 RN20.2
HDD_A_PRE: length 5.3
  BOTTOM w0.102: v1(250.38,22.55) RN6.2 249.86,22.05 249.86,20.78 RN7.2 249.14,20.06 UN7.9
HDD_B_EQ: length 5.8
  BOTTOM w0.102: UN7.19 248.14,13.28 RN13.2 247.81,12.94 248.28,12.47 248.28,11.13 RN12.2 v1(246.76,10.66)
HDD_B_EQ2: length 2.7
  BOTTOM w0.102: RN18.2 252.38,17.72 RN19.1 252.36,16.84 UN7.13
HDD_B_PRE: length 4.3
  BOTTOM w0.102: UN7.8 248.64,19.96 RN9.2 248.84,20.78 248.84,22.05 RN8.1
HDD_DET#: length 81.5
  TOP w0.102: QN6.2 267.92,9.81 v1(266.66,11.07) 266.28,11.46 266.28,11.75 v2(266.24,11.78)
  IN2 w0.102: v2(206.86,19.3) 206.93,19.3 207.6,19.97 211.91,19.97 214.27,17.61 220.55,17.61 222.14,19.2 240.52,19.2 240.59,19.27 240.93,19.27 241,19.2 250.18,19.2 250.33,19.05 252.1,19.05 252.41,19.35 254.13,19.35 254.22,19.27 260.73,19.27 v2(262.54,17.46)
  BOTTOM w0.089: RH324.2 207.32,14.9 206.38,15.84 206.38,18.96 206.73,19.3 v2(206.86,19.3) 206.9,19.35 206.9,20.38 207.04,20.52 207.04,20.53 207.04,20.53 207.04,20.87 206.96,20.95 UH1.AK47
  BOTTOM w0.102: v2(262.54,17.46) 262.54,16.27 261.35,15.08 JSATA1.13 261.35,11.57 261.57,11.35 264.58,11.35 265.01,11.78 v2(266.24,11.78)
HDD_DEVSLP: length 78.4
  TOP w0.102: v2(251.77,21.17) 251.75,21.14 251.75,11.23 v1(252.32,10.65) 252.93,10.05 v2(252.93,8.6)
  IN2 w0.102: v2(206.64,24.61) 207.04,24.61 207.2,24.77 208.18,24.77 209.26,23.69 209.26,22.19 208.97,21.9 208.97,21.29 209.3,20.95 210.05,20.95 210.19,21.09 211.23,21.09 211.62,20.7 212.65,20.7 214.56,18.8 221.09,18.8 221.95,19.65 227.14,19.65 227.96,20.48 231.86,20.48 232.61,19.74 246.76,19.74 247.79,20.77 251.37,20.77 v2(251.77,21.17)
  BOTTOM w0.089: UH1.AH40 v2(206.64,24.61)
  BOTTOM w0.102: RN3.2 261.9,16.11 260.35,14.56 JSATA1.11 260.35,12.65 258.27,10.57 257.09,10.57 255.05,8.52 253.18,8.52 253.11,8.6 v2(252.93,8.6)
HDD_EN: length 168.4
  TOP w0.102: v2(257.3,18.41) 257.3,17.98 255.93,16.61 255.93,12.34 257.04,11.22 257.04,8.05 260.68,4.42 263.06,4.42 RN5.1 263.45,4.82 RN4.2 264.3,4.83 UZ23.3 ; RE566.1 306.67,41.62 306.09,42.2 306.09,44.64 306.19,44.74 306.19,49.55 305.71,50.03 305.71,51.04 304.47,52.29 303.46,52.29 302.86,52.88 302.18,52.88 301.6,52.31 299.02,52.31 298.47,51.76 298.47,49.11 299.07,48.51 299.07,41.24 298.45,40.63 298.45,39.28 296.77,37.6 296.77,36.64 292.76,32.63 292.76,26.59 292.57,26.39 292.35,26.17 292.35,25.2 289.09,21.94 289.09,21.05 v2(285.35,17.32) ; 222.87,33.11 225.45,33.11 225.88,32.69 226.09,32.69 226.42,32.36 227.72,32.36 227.82,32.46 228.46,32.46 228.82,32.09 v1(228.82,31.22) 228.82,29.55 230.4,27.98 230.4,24.21 228.87,22.68 228.87,22.38 226.15,19.66 v2(226.15,18.68)
  TOP w0.107: 222.87,33.11 221.83,34.15 v2(221.51,34.15)
  IN2 w0.102: v2(226.15,18.68) 226.15,18.66 226.48,18.33 237.38,18.33 238.1,17.61 243.3,17.61 243.84,18.15 255.82,18.15 256.46,18.8 256.92,18.8 v2(257.3,18.41) 260.85,18.41 263.99,15.27 276.94,15.27 278.3,16.64 282.22,16.64 282.9,17.32 v2(285.35,17.32)
  BOTTOM w0.089: RH625.2 221.55,34.11 v2(221.51,34.15)
HDD_EN_EC: length 7.3
  TOP w0.102: 311.09,41.17 311.03,41.23 309.62,41.23 T141.1 309.23,41.62 RE566.2
  TOP w0.104: UE1.D1 313.41,38.26 313.41,38.28 313.18,38.51 313.15,38.51 312.21,39.44 312.21,40.05 311.09,41.17
HDD_EN_PCH: length 7.1
  BOTTOM w0.089: RH625.1 219.95,33.55 219.88,33.62 218.72,33.62 218.68,33.58 218.06,33.58 217.65,33.18 215.3,33.18 215.05,33.42 214.29,33.42 214.11,33.6 UH1.BD21
HDD_FALL_INT: length 96.2
  TOP w0.102: v2(211.43,30.66) 211.43,30.78 211.74,31.08 213.83,31.08 214.21,30.7 215.74,30.7 216.18,30.26 RH355.2 ; v2(235.91,24.12) 235.88,24.09 235.88,21.58 234.67,20.37 234.67,17.33 234.47,17.13 234.47,16.21 233.5,15.24 233.5,14.5 231.41,12.41 231.41,7.68 233.67,5.42 v1(239.81,5.42) 257.23,5.42 260.07,2.58 264.6,2.58 267.13,5.1 271.48,5.1 271.58,5 LGA1.12
  IN2 w0.102: v2(211.43,30.66) 211.43,30.58 211.83,30.18 215.4,30.18 216.95,28.63 218.96,28.63 221.61,25.99 222.69,25.99 223.17,26.47 224.38,26.47 224.4,26.49 228,26.49 229.62,24.86 233.65,24.86 234.39,24.12 v2(235.91,24.12)
  BOTTOM w0.089: UH1.AW26 v2(211.43,30.66)
HDD_UN7_EN:
  vias: v1(268.32,11.42)
HDD_UN7_EN_R: length 28
  TOP w0.102: v2(267.1,15.68) 267.1,14.81 v1(269.44,12.47) 270.22,11.68 RN227.2
  IN2 w0.102: v2(267.1,15.68) 266.69,16.09 264.49,16.09 260.46,20.12 254.64,20.12 254.45,20.31 248.41,20.31 v2(247.84,19.73)
  BOTTOM w0.102: v2(247.84,19.73) 248.14,19.43 UN7.7
HDMI_CEC: length 9
  TOP w0.102: RV19.1 113.36,125.3 113.36,126.9 v1(114,127.55) 114.44,127.98 v2(114.44,129.29)
  IN1 w0.099: v2(114.44,129.29) 114.44,129.48 114.27,129.64 111.12,129.64 110.6,130.16 JHDMI1.13
HDMI_CLKN: length 3
  TOP w0.097: RV33.1 109.32,123.38 LV12.2 108.95,123.02 108.95,122.21 RV17.1 108.94,121.52 108.94,121.33 CV38.1
HDMI_CLKP: length 3
  TOP w0.097: CV37.1 108.76,121.39 108.76,121.54 RV16.1 108.77,122.21 108.77,123.07 LV12.1 108.45,123.38 RV34.1
HDMI_CTRL_CLK: length 10
  TOP w0.107: QV3.6 116.56,125.15 RV22.1 116.56,126.82 v2(116.89,127.15)
  IN3 w0.102: JHDMI1.15 111.6,130.28 112.19,129.69 114.85,129.69 115.24,129.31 115.24,128.22 115.9,127.56 116.15,127.56 116.56,127.15 v2(116.89,127.15)
HDMI_CTRL_DATA: length 8
  TOP w0.107: QV3.3 115.57,123.97 RV23.1 115.57,127.08 v2(115.54,127.1)
  IN3 w0.102: v2(115.54,127.1) 115.31,127.1 114.25,128.17 112.75,128.17 JHDMI1.16
HDMI_HPD: length 12.8
  TOP w0.102: v2(117.65,128.29) 118.22,128.29 v1(118.47,128.04) 118.72,127.8 RV21.1 118.72,126.02 QV5.1
  IN1 w0.099: JHDMI1.19 114.7,130.32 114.84,130.18 114.84,127.23 115.37,126.7 117.33,126.7 117.65,127.01 v2(117.65,128.29)
HDMI_L_CLKN: length 11.7
  TOP w0.097: RV33.2 109.32,124.32 LV12.3 109.16,124.77 108.97,124.96 108.97,125.08 RV35.2 108.99,125.78 108.99,126.85 109.11,126.97 v4(109.51,126.97) 110,126.97 110.16,126.82 110.16,126.09 110.12,126.05 110.12,125.47 110.16,125.43 110.16,125.3 110.42,125.04 110.78,125.04 111.04,125.3 111.04,127.69 110.69,128.04 109.85,128.04 109.69,128.19 109.69,128.41 JHDMI1.12
HDMI_L_CLKP: length 11.7
  TOP w0.097: JHDMI1.10 109.51,128.41 109.51,128.12 109.77,127.86 110.61,127.86 110.86,127.61 110.86,125.37 110.71,125.22 110.49,125.22 110.34,125.37 v4(110.34,125.76) 110.34,126.9 110.08,127.16 109.84,127.16 109.8,127.2 109.08,127.2 108.8,126.92 108.8,125.83 RV35.1 108.78,125.07 108.78,124.97 108.61,124.79 LV12.4 108.45,124.32 RV34.2
HDMI_L_TX_N0: length 11.7
  TOP w0.097: JHDMI1.9 108.19,129.91 108.19,129.82 108.29,129.72 113.3,129.72 113.84,129.18 113.84,128.52 112.75,127.43 112.75,127.37 112.34,126.96 112.29,126.96 112.19,126.85 112.19,126.69 RV32.2 112.2,125.98 112.2,125.61 LV9.3 112.54,125.27 112.54,125.26 RV30.2
HDMI_L_TX_N1: length 11.7
  TOP w0.097: JHDMI1.6 106.69,128.41 106.69,127.68 107.62,126.75 107.62,126.18 107.66,126.14 107.66,125.55 107.62,125.51 107.62,124.43 107.36,124.17 v4(107.03,124.17) 106.76,124.17 106.5,124.43 106.5,126.1 106.29,126.31 105.47,126.31 105.34,126.18 105.34,125.8 RV29.2 105.34,125.08 105.34,124.6 LV6.3 105.69,124.24 RV27.2
HDMI_L_TX_N2: length 11.7
  TOP w0.097: JHDMI1.3 105.2,129.92 105.2,129.69 104.95,129.44 104.34,129.44 103.98,129.08 v4(103.98,127.74) 103.98,126.62 104.02,126.58 104.02,126 103.98,125.96 103.98,125.3 103.72,125.04 103.33,125.04 103.07,125.3 103.07,125.98 102.76,126.29 101.98,126.29 101.85,126.16 101.85,125.8 RV26.2 101.85,125.08 101.85,124.59 LV3.3 102.19,124.24 RV24.2
HDMI_L_TX_P0: length 11.6
  TOP w0.097: JHDMI1.7 108.01,129.91 108.01,129.74 108.21,129.53 113.23,129.53 113.65,129.11 113.65,128.59 v4(112.38,127.32) 112,126.94 112,126.69 RV32.1 112.01,125.95 112.01,125.59 LV9.4 111.68,125.26 RV31.2
HDMI_L_TX_P1: length 11.6
  TOP w0.097: JHDMI1.4 106.51,128.41 106.51,127.6 107.43,126.68 v4(107.43,125.84) 107.43,124.51 107.32,124.4 106.8,124.4 106.68,124.51 106.68,126.18 106.36,126.5 105.39,126.5 105.15,126.26 105.15,125.81 RV29.1 105.15,125.07 105.15,124.57 LV6.4 104.82,124.24 RV28.2
HDMI_L_TX_P2: length 11.7
  TOP w0.097: JHDMI1.1 105,129.92 105,129.75 104.87,129.62 104.26,129.62 103.8,129.16 103.8,128.07 103.76,128.03 103.76,127.44 103.8,127.4 v4(103.8,126.29) 103.8,125.37 103.65,125.22 103.41,125.22 103.25,125.37 103.25,126.06 102.84,126.47 101.9,126.47 101.66,126.23 101.66,125.81 RV26.1 101.66,125.08 101.66,124.59 LV3.4 101.32,124.24 RV25.2
