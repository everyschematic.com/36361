# Allegro board LA-F711P R05-0112.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_B_CLK1: length 87.5
  IN1 w0.076: v2(98.66,57.41) 98.66,57.62 98.75,57.71 98.94,57.71 99.07,57.58 99.07,57.19 99.37,56.89 99.64,56.89 100.53,56 100.53,53.66 101.23,52.96 101.23,45.66 101.23,45.45 101.49,45.19 101.49,44.98
  IN1 w0.089: v2(144,17.3) 144,16.97 144.12,16.85 144.39,16.85 144.69,17.15 144.69,17.51 144.45,17.75 144.45,18.31 143.81,18.95 143.81,20.38 143.46,20.72 143.46,21.39 143.81,21.74 143.81,22.63 143.2,23.24 143.2,24.37 137.55,30.02 111.79,30.02 101.49,40.31 101.49,44.98
  BOTTOM w0.076: v2(98.66,57.41) 98.34,57.09 UC1.AM7
  BOTTOM w0.089: v2(144,17.3) 143.68,16.98 143.44,16.98 142.91,17.52 142.74,17.52 142.66,17.6 142.66,18.87 142.46,19.07 141.86,19.07 141.66,18.87 141.66,16.88 141.86,16.68 142.6,16.68 142.95,16.34 142.95,16.05 143.47,15.53 JDIMM2.138
DDR_B_CLK#0: length 85.3
  IN1 w0.076: 101,44.98 101,44.99 100.97,45.02 100.97,45.05 100.97,45.06 100.97,45.26 100.92,45.31 100.92,52.85 100.34,53.43 100.34,55.81 99.47,56.68 98.78,56.68 98.3,57.16 98.3,58.28 98.15,58.43 98.01,58.43 v2(97.74,58.7)
  IN1 w0.089: 101,44.98 101,40.11 111.91,29.19 112.26,29.19 112.35,29.28 112.35,29.32 112.55,29.53 112.98,29.53 113.18,29.32 113.18,29.28 113.27,29.19 113.54,29.19 113.63,29.28 113.63,29.32 113.83,29.53 114.26,29.53 114.46,29.32 114.46,29.28 114.55,29.19 114.82,29.19 114.91,29.28 114.91,29.32 115.11,29.53 115.54,29.53 115.74,29.32 115.74,29.28 115.83,29.19 116.1,29.19 116.19,29.28 116.19,29.32 116.39,29.53 116.82,29.53 117.02,29.32 117.02,29.28 117.11,29.19 117.38,29.19 117.47,29.28 117.47,29.32 117.67,29.53 118.1,29.53 118.3,29.32 118.3,29.28 118.39,29.19 118.66,29.19 118.75,29.28 118.75,29.32 118.95,29.53 119.38,29.53 119.58,29.32 119.58,29.28 119.67,29.19 119.94,29.19 120.03,29.28 120.03,29.32 120.23,29.53 120.66,29.53 120.86,29.32 120.86,29.28 120.95,29.19 121.22,29.19 121.31,29.28 121.31,29.32 121.51,29.53 121.94,29.53 122.14,29.32 122.14,29.28 122.23,29.19 122.5,29.19 122.59,29.28 122.59,29.32 122.79,29.53 123.22,29.53 123.42,29.32 123.42,29.28 123.51,29.19 123.78,29.19 123.87,29.28 123.87,29.32 124.07,29.53 124.5,29.53 124.71,29.32 124.71,29.28 124.79,29.19 125.06,29.19 125.15,29.28 125.15,29.32 125.35,29.53 125.78,29.53 125.99,29.32 125.99,29.28 126.07,29.19 126.34,29.19 126.43,29.28 126.43,29.32 126.63,29.53 127.06,29.53 127.27,29.32 127.27,29.28 127.35,29.19 127.62,29.19 127.71,29.28 127.71,29.32 127.91,29.53 128.34,29.53 128.55,29.32 128.55,29.28 128.63,29.19 128.9,29.19 128.99,29.28 128.99,29.32 129.19,29.53 129.62,29.53 129.83,29.32 129.83,29.28 129.91,29.19 130.18,29.19 130.27,29.28 130.27,29.32 130.47,29.53 130.9,29.53 131.11,29.32 131.11,29.28 131.19,29.19 131.41,29.19 131.5,29.28 131.5,29.32 131.7,29.53 132.13,29.53 132.34,29.32 132.34,29.28 132.42,29.19 132.74,29.19 132.83,29.28 132.83,29.32 133.04,29.53 133.47,29.53 133.67,29.32 133.67,29.28 133.76,29.19 137.68,29.19 142.7,24.17 142.7,22.71 142.79,22.62 143.12,22.62 143.31,22.43 143.31,21.96 143.11,21.75 142.79,21.75 142.7,21.67 142.7,19.56 142.82,19.44 142.99,19.44 143.16,19.61 v2(143.16,19.7)
  BOTTOM w0.076: v2(97.74,58.7) 97.42,58.39 97.4,58.39 97.39,58.39 UC1.AN9
  BOTTOM w0.089: v2(143.16,19.7) 143.16,19.4 143.03,19.27 142.79,19.27 142.55,19.51 142.55,20.41 143.35,21.21 143.35,21.21 143.72,21.58 JDIMM2.139
DDR_B_CLK#1: length 87.5
  IN1 w0.076: v2(98.66,58.06) 98.85,57.87 99.01,57.87 99.23,57.65 99.23,57.25 99.44,57.05 99.71,57.05 100.69,56.07 100.69,53.73 101.39,53.03 101.39,45.59 101.39,45.59 101.39,45.52 101.66,45.26 101.66,45.09 101.69,45.06 101.69,44.98
  IN1 w0.089: 101.69,44.98 101.69,40.39 111.87,30.22 137.63,30.22 143.39,24.45 143.39,23.32 144,22.71 144,21.65 143.66,21.31 143.66,20.8 144,20.46 144,19.04 144.65,18.39 144.65,17.83 144.89,17.59 144.89,17.07 144.47,16.65 144.17,16.65 v2(143.97,16.46)
  BOTTOM w0.076: UC1.AM8 98.34,57.74 v2(98.66,58.06)
  BOTTOM w0.089: JDIMM2.140 143.97,15.01 143.65,15.33 143.65,15.6 143.13,16.13 143.13,16.41 142.68,16.86 141.93,16.86 141.85,16.95 141.85,18.8 141.93,18.89 142.39,18.89 142.47,18.8 142.47,17.53 142.67,17.33 142.83,17.33 143.37,16.8 143.48,16.8 143.51,16.77 143.77,16.77 143.97,16.57 v2(143.97,16.46)
DDR_B_CS#0: length 90.8
  IN1 w0.076: v2(103.22,59.33) 103.69,59.33 103.77,59.26 103.77,57.27 103.48,56.98 103.48,54.54 104.27,53.74 104.27,50.23 104.27,48.85 104.96,48.17 105.12,48.17 106.73,46.56 106.85,46.56 107.02,46.39
  IN1 w0.152: v2(150.52,25.32) 150.68,25.49 151.12,25.49 151.36,25.24 151.36,24.75 151.21,24.6 150.41,24.6 149.91,25.1 149.91,25.97 148.71,27.16 148.71,27.38 148.86,27.52 148.86,27.74 148.64,27.96 148.43,27.96 148.28,27.81 148.07,27.81 147.85,28.03 147.85,28.24 148,28.39 148,28.6 147.78,28.82 147.57,28.82 147.42,28.67 147.2,28.67 146.99,28.89 146.99,29.1 147.14,29.25 147.14,29.47 146.92,29.68 146.7,29.68 146.56,29.53 146.34,29.53 146.13,29.75 146.13,29.97 146.27,30.11 146.27,30.33 146.06,30.54 145.84,30.54 145.69,30.4 145.48,30.4 145.26,30.61 145.26,30.83 145.41,30.98 145.41,31.19 145.19,31.41 144.98,31.41 144.83,31.26 144.62,31.26 144.4,31.48 144.4,31.69 144.55,31.84 144.55,32.05 144.33,32.27 144.12,32.27 143.97,32.12 143.75,32.12 143.54,32.34 143.54,32.55 143.69,32.7 143.69,32.92 143.47,33.13 143.25,33.13 143.11,32.99 142.89,32.99 142.68,33.2 142.68,33.42 142.82,33.56 142.82,33.78 142.61,33.99 142.39,33.99 142.24,33.85 142.03,33.85 141.81,34.06 141.81,34.28 141.96,34.43 141.96,34.64 141.74,34.86 141.53,34.86 141.38,34.71 141.17,34.71 140.95,34.93 140.95,35.14 141.1,35.29 141.1,35.5 140.88,35.72 140.67,35.72 140.52,35.57 140.3,35.57 139.9,35.98 116.04,35.98 113.95,38.07 113.95,38.28 114.45,38.78 114.45,39 114.23,39.21 114.02,39.21 113.52,38.72 113.3,38.72 107.35,44.67 107.35,46.06 107.02,46.39
  BOTTOM w0.168: v2(150.52,25.32) 149.8,25.32 149.63,25.16 149.63,24.75 149.46,24.59 149.13,24.59 148.96,24.75 148.96,25.16 148.79,25.32 148.39,25.32 148.22,25.16 148.22,24.87 148.07,24.71 146.08,24.71 145.93,24.56 145.93,24.15 146.1,23.98 147.98,23.98 148.22,23.75 JDIMM2.149 ; UC1.AF11 v2(103.22,59.33)
DDR_B_CS#1: length 89
  IN1 w0.076: 107.66,47.04 107.53,47.17 107,47.17 106.84,47.34 105.43,48.74 105,48.74 104.71,49.03 104.71,54.29 104.54,54.45 104.54,56.85 104.47,56.92 104.29,56.92 v2(104.08,56.72)
  IN1 w0.152: 107.66,47.04 108.26,46.44 108.26,45.05 113.18,40.13 114.61,40.13 117.84,36.9 141,36.9 152.28,25.62 152.28,21.78 152.04,21.55 152.04,17.14 151.75,16.86 151.75,16.26 151.6,16.11 151.22,16.11 151.08,16.25 151.08,17.89 v2(151.48,18.3)
  BOTTOM w0.076: v2(104.08,56.72) 103.71,57.09 UC1.AE7
  BOTTOM w0.168: v2(151.48,18.3) 151.48,18.62 151.31,18.79 151,18.79 150.83,18.62 150.83,18.08 151.06,17.86 151.06,16.85 150.9,16.68 150.52,16.68 150.4,16.8 150.4,21.12 150.22,21.3 JDIMM2.157
DDR_B_D0: length 45
  IN3 w0.076: v2(105.13,49.81) 104.77,49.45 104.77,48.67 104.8,48.64
  IN3 w0.097: v2(108.23,21.08) 108.23,21.26 108.12,21.36 107.41,21.36 107.31,21.46 107.31,21.69 107.41,21.79 108.1,21.79 108.2,21.88 108.2,22.08 108.1,22.17 107.41,22.17 107.31,22.27 107.31,22.46 107.41,22.56 108.1,22.56 108.2,22.66 108.2,22.85 108.1,22.94 107.41,22.94 107.31,23.04 107.31,23.23 107.41,23.33 108.1,23.33 108.2,23.43 108.2,23.62 108.1,23.72 107.41,23.72 107.31,23.81 107.31,24.01 107.41,24.1 108.1,24.1 108.2,24.2 108.2,24.39 108.1,24.49 107.41,24.49 107.31,24.59 107.31,24.81 107.41,24.91 107.95,24.91 108.05,25.01 108.05,25.19 107.95,25.3 107.41,25.3 107.31,25.39 107.31,29.57 107.79,30.05 107.79,44.58 104.8,47.57 104.8,48.64
  BOTTOM w0.076: UC1.AB1 106.25,53.16 106.25,50.93 v2(105.13,49.81)
  BOTTOM w0.107: JDIMM2.3 109.72,21.38 109.42,21.08 v2(108.23,21.08)
DDR_B_D1: length 45.2
  IN3 w0.076: v2(105.13,50.39) 105.56,49.96 105.56,49.09 105.27,48.8 105.27,48.64
  IN3 w0.097: v2(109.7,15.7) 109.28,16.12 109.28,17.68 109.32,17.72 109.32,18.67 108.73,19.25 108.73,24.97 107.67,26.04 107.67,26.23 107.76,26.33 107.99,26.33 108.09,26.42 108.09,26.62 107.99,26.71 107.76,26.71 107.67,26.81 107.67,27 107.76,27.1 107.99,27.1 108.09,27.2 108.09,27.39 107.99,27.48 107.76,27.48 107.67,27.58 107.67,27.77 107.76,27.87 107.99,27.87 108.09,27.97 108.09,28.16 107.99,28.26 107.76,28.26 107.67,28.35 107.67,28.55 107.76,28.64 107.99,28.64 108.09,28.74 108.09,28.93 107.99,29.03 107.87,29.03 107.74,29.16 107.74,29.58 108.09,29.92 108.09,44.71 105.27,47.52 105.27,47.77 105.27,47.77 105.27,48.64
  BOTTOM w0.076: UC1.AB2 105.95,53.55 105.95,53.06 106.03,52.98 106.03,51.29 v2(105.13,50.39)
  BOTTOM w0.107: v2(109.7,15.7) 109.97,15.43 JDIMM2.4
DDR_B_D2: length 46.3
  IN3 w0.076: 107.45,47.93 107.21,48.17 107.21,48.33 106.52,49.02 106.52,49.13 106.14,49.51 106.14,53.5 v2(107.41,54.76)
  IN3 w0.097: v2(112.78,15.79) 111.75,15.79 111.66,15.89 111.66,16.06 111.77,16.17 112.23,16.17 112.33,16.27 112.33,16.46 112.23,16.56 111.77,16.56 111.65,16.68 111.65,17.86 111.39,18.11 111.39,24.71 109.79,26.32 109.79,45.12 107.64,47.27 107.64,47.74 107.45,47.93
  BOTTOM w0.076: UC1.AA4 107.06,55.13 107.41,54.78 v2(107.41,54.76)
  BOTTOM w0.107: v2(112.78,15.79) 112.97,15.6 JDIMM2.16
DDR_B_D3: length 46.6
  IN3 w0.076: 108.58,48.03 107.65,48.96 107.65,49.49 106.98,50.16 106.98,52.3 107.23,52.55 107.58,52.55 107.79,52.76 107.79,54.95 v2(107.4,55.35)
  IN3 w0.097: v2(112.7,20.51) 112.7,21.53 112.88,21.71 112.88,21.91 112.79,22 112.46,22 112.37,22.1 112.37,22.29 112.46,22.39 112.79,22.39 112.88,22.49 112.88,22.68 112.79,22.78 112.46,22.78 112.37,22.87 112.37,23.06 112.46,23.16 112.79,23.16 112.88,23.26 112.88,23.45 112.79,23.55 112.46,23.55 112.37,23.64 112.37,27.84 112.27,27.94 110.79,27.94 110.69,28.04 110.69,28.26 110.78,28.36 112.32,28.36 112.42,28.45 112.42,28.64 112.32,28.74 110.78,28.74 110.69,28.84 110.69,45.49 108.58,47.6 108.58,48.03
  BOTTOM w0.076: UC1.AA5 v2(107.4,55.35)
  BOTTOM w0.107: v2(112.7,20.51) 113.22,21.03 JDIMM2.17
DDR_B_D4: length 46.8
  IN3 w0.076: v2(105.13,52.17) 104.47,51.51 104.47,48.64
  IN3 w0.097: 104.47,48.64 104.47,47.47 107.49,44.45 107.49,32.12 107.39,32.03 107.01,32.03 106.92,31.93 106.92,31.74 107.01,31.64 107.39,31.64 107.49,31.54 107.49,31.35 107.39,31.25 107.01,31.25 106.92,31.16 106.92,30.96 107.01,30.87 107.21,30.87 107.31,30.77 107.31,30 107.01,29.69 107.01,20.49 107.11,20.39 107.72,20.39 107.82,20.29 107.82,20.1 107.72,20.01 107.11,20.01 107.01,19.9 107.01,19.66 107.11,19.55 v2(108.29,19.55)
  BOTTOM w0.076: v2(105.13,52.17) 105.2,52.17 105.62,52.59 105.62,55.17 UC1.AB5
  BOTTOM w0.107: v2(108.29,19.55) 109.06,19.55 110.72,21.21 JDIMM2.7
DDR_B_D5: length 46.6
  IN3 w0.076: v2(105.13,51.56) 105.76,50.93 105.76,48.7 105.7,48.64
  IN3 w0.097: 105.7,48.64 105.57,48.51 105.57,47.65 108.59,44.62 108.59,25.59 109.03,25.15 109.03,21.03 109.13,20.94 109.44,20.94 109.54,20.84 109.54,20.65 109.44,20.55 109.13,20.55 109.03,20.45 109.03,20.26 109.13,20.16 109.44,20.16 109.54,20.07 109.54,19.89 109.42,19.78 109.13,19.78 109.03,19.68 109.03,19.49 109.15,19.38 109.44,19.38 109.54,19.28 109.54,18.89 109.62,18.81 109.62,18.4 109.71,18.3 110.08,18.3 110.18,18.2 110.18,18.02 110.06,17.89 109.76,17.89 109.7,17.83 109.7,17.53 v2(109.68,17.52)
  BOTTOM w0.076: v2(105.13,51.56) 105.79,52.22 105.79,54.68 UC1.AB4
  BOTTOM w0.107: v2(109.68,17.52) 110.82,16.38 110.82,15.42 110.97,15.26 JDIMM2.8
DDR_B_D6: length 45.1
  IN3 w0.076: v2(107.39,53.52) 107.23,53.52 106.45,52.73 106.45,49.81 106.87,49.39 106.87,49.01 107.44,48.44 107.44,48.37 107.86,47.95
  IN3 w0.097: v2(112.71,17.47) 111.69,18.48 111.69,25.51 111.59,25.61 111.43,25.61 111.32,25.71 111.32,25.89 111.43,25.99 111.67,25.99 111.77,26.09 111.77,26.29 111.67,26.39 110.19,26.39 110.09,26.49 110.09,45.24 109.66,45.67 107.94,47.39 107.94,47.87 107.86,47.94 107.86,47.95
  BOTTOM w0.076: v2(107.39,53.52) 107.39,53.55 107.11,53.83 UC1.AA2
  BOTTOM w0.107: JDIMM2.20 113.97,16.2 v2(112.71,17.47)
DDR_B_D7: length 44.7
  IN3 w0.076: v2(107.41,52.92) 107.17,52.92 106.7,52.45 106.7,50.04 107.22,49.52 107.22,49.01 108.2,48.03
  IN3 w0.097: 108.2,48.03 108.2,48.03 108.24,47.99 108.24,47.51 110.39,45.37 110.39,27.69 110.48,27.6 111.65,27.6 111.74,27.5 111.74,27.31 111.65,27.21 110.48,27.21 110.39,27.12 110.39,26.87 110.49,26.77 111.97,26.77 112.07,26.67 112.07,19.63 v2(112.7,18.99)
  BOTTOM w0.076: v2(107.41,52.92) 107.41,52.91 107.15,53.18 UC1.AA1
  BOTTOM w0.107: JDIMM2.21 114.22,20.85 114.02,20.65 114.02,20.3 v2(112.7,18.99)
DDR_B_D8: length 49.3
  IN3 w0.076: 109.34,47.57 109.33,47.58 109.33,47.61 108.01,48.93 108.01,49.57 107.41,50.17 v2(107.41,51.61)
  IN3 w0.097: v2(114.48,15.41) 113.39,16.5 113.39,23.88 113.27,24 113.02,24 112.92,24.09 112.92,24.32 113.02,24.41 113.32,24.41 113.42,24.51 113.42,24.7 113.32,24.8 113.02,24.8 112.92,24.89 112.92,25.09 113.02,25.18 113.32,25.18 113.42,25.28 113.42,25.47 113.32,25.57 113.02,25.57 112.92,25.67 112.92,25.86 113.02,25.96 113.32,25.96 113.42,26.05 113.42,26.25 113.32,26.34 113.02,26.34 112.92,26.44 112.92,29.27 112.82,29.36 111.3,29.36 111.2,29.46 111.2,29.71 111.29,29.81 111.5,29.81 111.6,29.91 111.6,30.09 111.5,30.19 111.29,30.19 111.19,30.3 111.19,45.7 109.34,47.55 109.34,47.57
  BOTTOM w0.076: v2(107.41,51.61) 108.08,52.28 108.08,52.66 108.13,52.72 108.13,55.17 UC1.V5
  BOTTOM w0.107: JDIMM2.24 114.97,14.92 v2(114.48,15.41)
DDR_B_D9: length 47.4
  IN3 w0.076: v2(108.71,49.96) 108.71,49.03 110.6,47.13
  IN3 w0.097: v2(114.46,18.84) 114.29,18.67 114.11,18.67 114.02,18.77 114.02,29.86 113.79,30.09 113.07,30.09 112.98,30.18 112.98,30.37 113.07,30.47 113.79,30.47 113.89,30.57 113.89,30.76 113.78,30.86 111.89,30.86 111.79,30.96 111.79,31.14 111.89,31.24 113.03,31.24 113.13,31.34 113.13,31.52 113.03,31.63 111.89,31.63 111.79,31.72 111.79,45.95 110.6,47.13
  BOTTOM w0.076: 108.71,50.09 108.71,51.82 108.46,52.06 108.46,53.55 UC1.V2
  BOTTOM w0.107: v2(114.46,18.84) 116.22,20.6 JDIMM2.29 ; 108.71,50.09 v2(108.71,49.96)
DDR_B_D10: length 46.8
  IN3 w0.076: v2(109.94,52.95) 109.57,52.58 109.57,51.13 114.04,46.66 114.04,46.22 114.06,46.2
  IN3 w0.097: 114.06,46.2 114.19,46.07 114.19,36.33 116.84,33.68 116.84,26.62 116.94,26.52 117.6,26.52 117.7,26.42 117.7,24.97 117.8,24.88 118.03,24.88 118.13,24.78 118.13,24.59 118.03,24.49 117.8,24.49 117.7,24.39 117.7,24.2 117.8,24.11 118.08,24.11 118.18,24 118.18,23.82 118.08,23.72 117.8,23.72 117.7,23.62 117.7,23.43 117.8,23.33 118.21,23.33 118.31,23.23 118.31,23.05 118.21,22.95 117.8,22.95 117.7,22.85 117.7,22.66 117.8,22.56 118.27,22.56 118.37,22.46 118.37,22.27 118.27,22.17 117.8,22.17 117.7,22.08 117.7,21.89 117.8,21.79 118.34,21.79 118.53,21.6 118.53,19.25 v2(118.11,18.84)
  BOTTOM w0.076: UC1.U1 109.71,53.18 v2(109.94,52.95)
  BOTTOM w0.107: v2(118.11,18.84) 119.22,19.94 JDIMM2.41
DDR_B_D11: length 46.7
  IN3 w0.076: v2(109.93,53.53) 109.34,52.95 109.34,51.08 113.82,46.61 113.82,46.02 113.85,45.99
  IN3 w0.097: v2(118.11,20.54) 117.95,20.37 117.67,20.37 117.43,20.6 117.43,21.51 117.34,21.61 116.65,21.61 116.56,21.71 116.56,21.9 116.65,22 117.22,22 117.32,22.09 117.32,22.29 117.22,22.38 116.65,22.38 116.56,22.48 116.56,22.67 116.65,22.77 117.22,22.77 117.32,22.87 117.32,23.06 117.22,23.15 116.65,23.15 116.56,23.25 116.56,23.44 116.65,23.54 117.22,23.54 117.32,23.64 117.32,24.51 117.22,24.61 116.64,24.61 116.54,24.71 116.54,24.96 116.63,25.06 117.22,25.06 117.32,25.15 117.32,25.35 117.22,25.44 116.63,25.44 116.54,25.54 116.54,25.73 116.63,25.83 117.22,25.83 117.32,25.92 117.32,26.12 117.22,26.21 116.63,26.21 116.54,26.31 116.54,33.56 113.89,36.21 113.89,45.95 113.85,45.99
  BOTTOM w0.076: UC1.U2 109.63,53.83 v2(109.93,53.53)
  BOTTOM w0.107: v2(118.11,20.54) 118.22,20.64 JDIMM2.37
DDR_B_D12: length 47
  IN3 w0.076: 110.82,47.34 110.76,47.4 110.68,47.4 109.17,48.91 v2(109.17,49.55)
  IN3 w0.097: 110.82,47.34 112.09,46.07 112.09,45.82 112.09,45.82 112.09,33.68 112.19,33.58 113.89,33.58 113.99,33.48 113.99,33.29 113.89,33.19 112.19,33.19 112.09,33.1 112.09,32.9 112.19,32.81 114.07,32.81 114.17,32.71 114.17,32.52 114.07,32.42 112.19,32.42 112.09,32.32 112.09,32.11 112.19,32 114.1,32 114.2,31.9 114.2,31.67 114.11,31.57 113.53,31.57 113.43,31.47 113.43,31.28 113.53,31.18 114.11,31.18 114.32,30.98 114.32,22.08 114.54,21.85 v2(114.54,20.55)
  BOTTOM w0.076: 109.17,49.63 109.17,51.69 108.74,52.11 UC1.V1
  BOTTOM w0.107: v2(114.54,20.55) 115.22,21.23 JDIMM2.25 ; 109.17,49.63 v2(109.17,49.55)
DDR_B_D13: length 48.7
  IN3 w0.076: v2(107.82,50.8) 107.82,50.22 108.4,49.63 108.4,48.91 110.37,46.94
  IN3 w0.097: 110.37,46.94 111.49,45.82 111.49,30.61 111.6,30.5 112.54,30.5 112.65,30.4 112.65,30.22 112.54,30.12 112.03,30.12 111.93,30.02 111.93,29.83 112.03,29.73 113.59,29.73 113.72,29.61 113.72,29.4 113.62,29.3 113.32,29.3 113.22,29.2 113.22,29.01 113.32,28.92 113.62,28.92 113.72,28.82 113.72,28.63 113.62,28.53 113.32,28.53 113.22,28.43 113.22,28.24 113.32,28.14 113.62,28.14 113.72,28.05 113.72,17.85 v2(114.48,17.09)
  BOTTOM w0.076: v2(107.82,50.8) 108.24,51.22 108.24,52.59 108.3,52.65 108.3,54.53 108.74,54.98 UC1.V4
  BOTTOM w0.107: JDIMM2.28 115.97,15.6 v2(114.48,17.09)
DDR_B_D14: length 48.4
  IN3 w0.076: 113.29,45.82 113.29,46.6 108.84,51.05 108.84,54.36 v2(109.93,55.45)
  IN3 w0.097: v2(118.11,15.33) 117,15.33 116.9,15.43 116.9,15.65 117,15.75 117.62,15.75 117.72,15.85 117.72,16.04 117.62,16.14 117,16.14 116.9,16.23 116.9,20.26 115.94,21.22 115.94,33.31 113.29,35.96 113.29,45.82
  BOTTOM w0.076: v2(109.93,55.45) 109.6,55.78 UC1.U5
  BOTTOM w0.107: JDIMM2.38 118.47,14.98 v2(118.11,15.33)
DDR_B_D15: length 48.3
  IN3 w0.076: v2(109.93,54.8) 109.09,53.96 109.09,51.07 113.59,46.57 113.59,45.82
  IN3 w0.097: 113.59,45.82 113.59,36.08 116.24,33.43 116.24,21.38 117.2,20.41 117.2,18.63 117.3,18.53 117.79,18.53 117.89,18.44 117.89,18.27 117.77,18.15 117.3,18.15 117.2,18.05 117.2,17.86 117.3,17.76 117.62,17.76 117.72,17.66 117.72,17.47 117.62,17.38 117.3,17.38 117.2,17.28 117.2,17.05 117.3,16.96 v2(118.09,16.96)
  BOTTOM w0.076: v2(109.93,54.8) 109.6,55.13 UC1.U4
  BOTTOM w0.107: JDIMM2.42 119.47,15.58 v2(118.09,16.96)
DDR_B_D16: length 84.6
  IN1 w0.076: 112.15,47.66 112.15,47.97 112.04,48.08 112.04,48.09 108.17,51.96 108.17,56.36 107.78,56.75 107.78,58.24 107.43,58.58 107.43,59.86 107.36,59.94 v2(106.89,59.94)
  IN1 w0.097: v2(157.16,20.7) 157.32,20.87 157.32,21.14 157.22,21.25 156.89,21.25 156.79,21.35 156.79,21.54 156.89,21.64 157.25,21.64 157.34,21.73 157.34,21.95 157.25,22.04 156.89,22.04 156.79,22.14 156.79,22.34 156.89,22.44 157.25,22.44 157.34,22.52 157.34,22.74 157.25,22.83 156.89,22.83 156.79,22.93 156.79,23.13 156.89,23.23 157.06,23.23 157.16,23.33 157.16,23.51 156.79,23.88 156.79,24.27 156.88,24.36 157.24,24.36 157.34,24.46 157.34,24.66 157.24,24.76 157.07,24.76 156.98,24.86 156.98,25.12 157.08,25.22 157.23,25.22 157.34,25.33 157.34,25.61 157.24,25.7 156.43,25.7 156.33,25.8 156.33,26 156.43,26.1 156.88,26.1 156.98,26.2 156.98,26.44 156.87,26.54 156.44,26.54 156.34,26.64 156.34,26.93 151.72,31.54 151.72,32.37 143.42,40.67 120.57,40.67 120.14,41.1 120,41.1 119.92,41.02 119.79,41.02 119.67,41.14 119.67,41.27 119.75,41.35 119.75,41.49 119.61,41.62 119.47,41.62 119.4,41.55 119.26,41.55 119.12,41.68 119.12,41.82 119.2,41.89 119.2,42.03 119.06,42.17 118.93,42.17 118.85,42.09 118.72,42.09 118.58,42.23 118.58,42.37 118.65,42.44 118.65,42.58 118.52,42.71 118.38,42.71 118.31,42.64 118.17,42.64 118.03,42.78 118.03,42.91 118.11,42.99 118.11,43.12 117.97,43.26 117.83,43.26 117.76,43.18 117.62,43.18 117.49,43.32 117.49,43.46 117.56,43.53 117.56,43.67 117.43,43.81 117.29,43.81 117.21,43.73 117.08,43.73 116.86,43.95 114.82,43.95 112.15,46.62 112.15,47.66
  BOTTOM w0.076: UC1.AA11 106.64,59.69 v2(106.89,59.94)
  BOTTOM w0.107: v2(157.16,20.7) 157.72,21.26 JDIMM2.187
DDR_B_D17: length 84.4
  IN1 w0.076: v2(106.89,59.33) 107.26,58.97 107.26,58.34 107.59,58.01 107.59,56.65 107.98,56.25 107.98,51.88 111.85,48.01 111.85,47.85
  IN1 w0.097: v2(157.06,19.05) 157.06,18.8 156.95,18.69 156.59,18.69 156.49,18.8 156.49,20.85 156.39,20.95 156.24,20.95 156.15,21.05 156.15,21.24 156.24,21.34 156.39,21.34 156.49,21.43 156.49,21.63 156.39,21.72 156.24,21.72 156.15,21.82 156.15,22.01 156.24,22.11 156.39,22.11 156.49,22.21 156.49,24.46 156.41,24.54 156.15,24.54 156.03,24.65 156.03,24.9 156.11,24.99 156.54,24.99 156.64,25.08 156.64,25.28 156.54,25.38 156.11,25.38 156.02,25.48 156.02,26.82 151.42,31.42 151.42,32.25 144.5,39.17 144.1,39.17 144,39.26 144,39.66 143.87,39.8 143.73,39.8 143.43,39.5 143.3,39.5 143.16,39.63 143.16,39.77 143.46,40.07 143.46,40.21 143.3,40.36 143.16,40.36 142.87,40.07 142.72,40.07 142.43,40.36 120.02,40.36 116.74,43.65 114.57,43.65 111.85,46.37 111.85,47.85
  BOTTOM w0.076: v2(106.89,59.33) 106.6,59.04 UC1.AA10
  BOTTOM w0.107: v2(157.06,19.05) 156.69,19.42 156.69,20.8 156.72,20.83 JDIMM2.183
DDR_B_D18: length 82.8
  IN1 w0.076: 105.57,50.2 105.51,50.27 105.51,56.75 105.1,57.16 105.1,58.76 105.53,59.19 105.53,59.56 v2(105.98,60.01)
  IN1 w0.097: v2(153.99,15.5) 153.99,15.58 153.23,16.33 153.02,16.33 152.87,16.18 152.73,16.18 152.51,16.41 152.51,16.54 152.8,16.83 152.8,21.22 152.95,21.38 152.95,21.38 153.22,21.64 153.22,25.76 141.32,37.66 118.16,37.66 114.93,40.89 113.5,40.89 109.06,45.32 109.06,46.71 105.57,50.2
  BOTTOM w0.076: UC1.AC11 v2(105.98,60.01)
  BOTTOM w0.107: v2(153.99,15.5) 154.47,15.02 JDIMM2.174
DDR_B_D19: length 82.1
  IN1 w0.076: 105.79,50.42 105.7,50.5 105.7,56.83 105.36,57.17 105.36,58.65 105.98,59.27 v2(105.98,59.36)
  IN1 w0.097: v2(153.96,17.18) 153.62,16.84 153.31,16.84 153.1,17.05 153.1,21.09 153.26,21.25 153.26,21.26 153.52,21.52 153.52,25.88 141.44,37.96 118.28,37.96 115.05,41.19 113.63,41.19 109.37,45.45 109.37,46.84 105.79,50.42
  BOTTOM w0.076: v2(105.98,59.36) 105.65,59.04 UC1.AC10
  BOTTOM w0.107: JDIMM2.170 153.47,16.69 v2(153.96,17.18)
DDR_B_D20: length 81.7
  IN1 w0.076: v2(106.89,57.41) 107.01,57.3 107.01,51.46 107.29,51.18 108.04,51.18 111.25,47.98 111.25,47.91
  IN1 w0.097: 111.25,47.91 111.25,46.12 114.31,43.05 116.49,43.05 119.78,39.76 142.18,39.76 143.38,38.57 144.24,38.57 150.81,32 150.81,31.17 155.41,26.57 155.41,24.42 155.75,24.07 155.75,23.54 155.41,23.2 155.41,20.74 155.88,20.27 155.88,17.63 155.3,17.05 155.3,16.19 155.87,15.62 v2(157.11,15.62)
  BOTTOM w0.076: UC1.AA7 v2(106.89,57.41)
  BOTTOM w0.107: v2(157.11,15.62) 157.47,15.26 JDIMM2.186
DDR_B_D21: length 82.4
  IN1 w0.076: 111.55,47.6 111.55,48.03 111.37,48.21 111.37,48.21 107.79,51.78 107.79,56.13 107.38,56.54 107.38,57.57 v2(106.89,58.06)
  IN1 w0.097: v2(157.13,17.4) 156.75,17.4 156.65,17.3 156.65,16.9 156.54,16.79 156.28,16.79 156.19,16.89 156.19,20.39 155.71,20.87 155.71,23.07 156.05,23.42 156.05,24.2 155.71,24.54 155.71,26.69 151.12,31.29 151.12,32.12 144.37,38.87 143.5,38.87 142.31,40.06 119.9,40.06 116.61,43.35 114.44,43.35 111.55,46.24 111.55,47.6
  BOTTOM w0.076: UC1.AA8 v2(106.89,58.06)
  BOTTOM w0.107: JDIMM2.182 156.47,16.74 v2(157.13,17.4)
DDR_B_D22: length 81
  IN1 w0.076: 106,50.63 105.89,50.74 105.89,56.91 105.58,57.21 105.58,57.67 v2(105.98,58.06)
  IN1 w0.097: v2(153.83,19.29) 154.01,19.11 154.01,18.75 153.91,18.65 153.5,18.65 153.4,18.75 153.4,20.97 153.56,21.13 153.56,21.13 153.8,21.37 153.8,21.37 153.82,21.39 153.82,26.01 141.57,38.26 118.4,38.26 116.44,40.22 116.44,40.35 116.68,40.59 116.68,40.73 116.55,40.86 116.41,40.86 116.17,40.63 116.04,40.63 115.9,40.77 115.9,40.9 116.14,41.15 116.14,41.28 116,41.42 115.87,41.42 115.62,41.18 115.49,41.18 115.17,41.49 113.76,41.49 109.67,45.57 109.67,46.96 106,50.63
  BOTTOM w0.076: UC1.AC8 v2(105.98,58.06)
  BOTTOM w0.107: v2(153.83,19.29) 153.03,20.09 153.03,21.26 153.22,21.45 JDIMM2.169
DDR_B_D23: length 79.9
  IN1 w0.076: v2(105.98,57.41) 106.12,57.27 106.12,50.94 106.21,50.84
  IN1 w0.097: v2(153.96,20.96) 153.97,20.96 154.12,21.12 154.12,26.13 147.52,32.74 147.52,32.88 147.67,33.03 147.67,33.17 147.53,33.31 147.39,33.31 147.24,33.16 147.1,33.16 146.93,33.32 146.93,33.46 147.2,33.73 147.2,33.87 147.06,34.01 146.92,34.01 146.65,33.74 146.51,33.74 146.37,33.88 146.37,34.02 146.64,34.29 146.64,34.43 146.5,34.57 146.36,34.57 146.09,34.3 145.95,34.3 145.81,34.44 145.81,34.58 146.08,34.85 146.08,34.99 145.94,35.13 145.8,35.13 145.53,34.86 145.39,34.86 145.25,35 145.25,35.14 145.52,35.41 145.52,35.55 145.38,35.69 145.24,35.69 144.97,35.42 144.83,35.42 144.69,35.56 144.69,35.7 144.96,35.97 144.96,36.11 144.82,36.25 144.68,36.25 144.41,35.98 144.27,35.98 144.13,36.12 144.13,36.27 144.4,36.53 144.4,36.67 144.26,36.81 144.12,36.81 143.85,36.55 143.71,36.55 143.57,36.69 143.57,36.83 143.84,37.09 143.84,37.23 143.7,37.37 143.56,37.37 143.29,37.11 143.15,37.11 141.69,38.56 119.28,38.56 116.06,41.79 113.88,41.79 109.97,45.7 109.97,47.09 106.21,50.84
  BOTTOM w0.076: v2(105.98,57.41) 105.65,57.09 UC1.AC7
  BOTTOM w0.107: JDIMM2.173 154.22,21.22 v2(153.96,20.96)
DDR_B_D24: length 85.4
  IN1 w0.076: v2(108.7,58.13) 108.35,57.78 108.35,57 108.76,56.59 108.76,52.18 113.31,47.64 113.31,47.04 113.48,46.86
  IN1 w0.097: v2(159.29,19.37) 158.81,19.37 158.67,19.23 158.67,17.4 158.57,17.3 158.31,17.3 158.21,17.4 158.21,19.66 158.34,19.79 158.54,19.79 158.64,19.89 158.64,20.08 158.44,20.28 158.44,20.48 158.54,20.58 158.72,20.58 158.82,20.68 158.82,20.88 158.72,20.97 158.54,20.97 158.44,21.07 158.44,26.54 158.27,26.72 158.27,26.72 152.89,32.1 152.89,32.77 143.88,41.78 121.86,41.78 119.89,43.75 119.75,43.75 119.47,43.46 119.33,43.46 119.19,43.6 119.19,43.74 119.48,44.02 119.48,44.16 119.3,44.34 119.16,44.34 118.88,44.05 118.74,44.05 117.74,45.05 115.29,45.05 113.48,46.86
  BOTTOM w0.076: v2(108.7,58.13) 108.3,57.74 UC1.W8
  BOTTOM w0.107: JDIMM2.191 158.72,19.94 v2(159.29,19.37)
DDR_B_D25: length 85
  IN1 w0.076: v2(108.71,57.38) 108.71,56.94 108.95,56.69 108.95,52.26 113.66,47.55 113.66,47.11 113.89,46.88
  IN1 w0.097: 113.89,46.88 115.42,45.35 117.86,45.35 118.15,45.07 118.27,45.07 118.55,45.35 118.71,45.35 118.87,45.19 118.87,45.06 118.58,44.77 118.58,44.63 118.72,44.5 118.85,44.5 119.14,44.78 119.28,44.78 121.98,42.08 144.01,42.08 153.19,32.9 153.19,32.23 153.38,32.03 153.52,32.03 153.71,32.22 153.85,32.22 153.99,32.08 153.99,31.94 153.8,31.75 153.8,31.61 153.94,31.47 154.08,31.47 154.27,31.66 154.41,31.66 154.55,31.52 154.55,31.38 154.36,31.19 154.36,31.05 154.5,30.91 154.64,30.91 154.83,31.1 154.97,31.1 155.12,30.96 155.12,30.82 154.92,30.63 154.92,30.49 155.06,30.35 155.2,30.35 155.4,30.54 155.54,30.54 155.68,30.4 155.68,30.26 155.49,30.07 155.49,29.93 155.63,29.79 155.77,29.79 155.96,29.98 156.1,29.98 156.24,29.84 156.24,29.7 156.05,29.51 156.05,29.37 156.19,29.23 156.33,29.23 156.52,29.42 156.66,29.42 156.8,29.28 156.8,29.14 156.61,28.95 156.61,28.81 156.75,28.67 156.89,28.67 157.08,28.86 157.22,28.86 157.36,28.72 157.36,28.58 157.17,28.39 157.17,28.25 157.31,28.11 157.45,28.11 157.64,28.3 157.78,28.3 157.92,28.16 157.92,28.02 157.73,27.83 157.73,27.69 157.87,27.55 158.01,27.55 158.2,27.74 158.34,27.74 158.48,27.6 158.48,27.46 158.29,27.27 158.29,27.12 158.39,27.02 158.75,26.67 158.75,25.42 158.85,25.32 159.03,25.32 159.13,25.22 159.13,25.03 159.03,24.93 158.85,24.93 158.75,24.83 158.75,24.63 158.85,24.53 159.21,24.53 159.3,24.43 159.3,24.23 159.21,24.13 158.85,24.13 158.75,24.04 158.75,23.29 158.85,23.19 159.18,23.19 159.28,23.09 159.28,22.89 159.18,22.79 158.85,22.79 158.75,22.69 158.75,22.5 158.85,22.4 159.18,22.4 159.28,22.3 159.28,22.1 159.18,22 158.85,22 158.75,21.9 158.75,21.59 158.85,21.49 159.14,21.49 159.24,21.39 v2(159.24,21.02)
  BOTTOM w0.076: UC1.W7 108.41,57.09 v2(108.71,57.38)
  BOTTOM w0.107: v2(159.24,21.02) 159.72,21.5 JDIMM2.195
DDR_B_D26: length 86.6
  IN1 w0.076: 115.89,47.9 115.66,48.13 115.34,48.13 110.82,52.66 110.82,55.49 110.7,55.6 110.7,56.35 110.29,56.76 110.29,58.11 109.98,58.42 109.98,58.98 v2(109.6,59.36)
  IN1 w0.097: v2(162.79,18.66) 162.79,18.44 162.64,18.29 162.19,18.29 162.11,18.36 162.11,18.78 162.22,18.88 162.48,18.88 162.57,18.98 162.57,19.22 162.48,19.32 162.21,19.32 162.11,19.41 162.11,20.29 162.01,20.4 161.41,20.4 161.31,20.5 161.31,20.69 161.41,20.79 161.82,20.79 161.89,20.86 161.89,23.95 161.13,24.71 161.13,26.05 161.05,26.13 160.76,26.13 160.66,26.22 160.66,26.44 160.76,26.54 160.96,26.54 161.06,26.64 161.06,26.83 160.96,26.93 160.64,26.93 160.54,27.02 160.54,27.21 160.64,27.3 160.97,27.3 161.07,27.4 161.07,27.59 160.97,27.69 160.64,27.69 160.54,27.79 160.54,28.11 144.72,43.93 122.66,43.93 119.22,47.37 116.42,47.37 115.89,47.9
  BOTTOM w0.076: UC1.V10 109.18,59.06 v2(109.6,59.36)
  BOTTOM w0.107: v2(162.79,18.66) 161.59,19.86 161.59,21.08 161.72,21.21 JDIMM2.203
DDR_B_D27: length 87.5
  IN1 w0.076: v2(109.61,60.01) 110.11,60.01 110.18,59.94 110.18,58.53 110.49,58.22 110.49,56.81 110.9,56.41 110.9,55.75 111.1,55.55 111.1,52.65 115.41,48.34 115.88,48.34 116.11,48.11
  IN1 w0.097: v2(162.64,20.54) 162.29,20.54 162.2,20.63 162.2,20.83 162.32,20.95 162.71,20.95 162.81,21.05 162.81,21.25 162.71,21.35 162.32,21.35 162.22,21.45 162.22,21.64 162.32,21.74 162.71,21.74 162.81,21.84 162.81,22.04 162.71,22.14 162.32,22.14 162.22,22.24 162.22,22.44 162.32,22.54 162.71,22.54 162.81,22.63 162.81,22.83 162.71,22.93 162.32,22.93 162.22,23.03 162.22,23.23 162.32,23.33 162.71,23.33 162.81,23.43 162.81,23.63 162.71,23.72 162.32,23.72 162.22,23.82 162.22,24.02 162.32,24.12 162.69,24.12 162.78,24.22 162.78,24.49 162.69,24.59 161.68,24.59 161.57,24.7 161.57,24.9 161.66,25 162.2,25 162.3,25.1 162.3,25.28 162.19,25.39 161.54,25.39 161.44,25.48 161.44,27.64 144.85,44.23 124.09,44.23 123.89,44.43 123.76,44.43 123.56,44.23 123.42,44.23 123.28,44.37 123.28,44.51 123.48,44.71 123.48,44.84 123.35,44.98 123.21,44.98 122.8,44.57 122.67,44.57 122.53,44.71 122.53,44.85 122.94,45.25 122.94,45.39 120.65,47.67 116.55,47.67 116.11,48.11
  BOTTOM w0.076: v2(109.61,60.01) 109.18,59.71 UC1.V11
  BOTTOM w0.107: v2(162.64,20.54) 162.72,20.62 JDIMM2.207
DDR_B_D28: length 87.4
  IN1 w0.076: v2(108.72,59.36) 108.3,58.94 108.3,58.28 108.16,58.14 108.16,56.91 108.57,56.5 108.57,52.1 113,47.67 113,46.91 113.05,46.86
  IN1 w0.097: v2(159.19,17.69) 159.19,17.49 158.7,16.99 158.19,16.99 157.91,17.27 157.91,20.22 158.14,20.45 158.14,26.42 152.58,31.98 152.58,32.65 143.76,41.47 121.74,41.47 121.44,41.77 121.36,41.77 121.06,41.47 120.91,41.47 120.81,41.57 120.81,41.71 121.09,41.99 121.09,42.12 120.96,42.25 120.81,42.25 120.54,41.98 120.39,41.98 120.27,42.1 120.27,42.23 120.56,42.52 120.56,42.65 120.42,42.79 120.28,42.79 120,42.51 119.86,42.51 119.74,42.63 119.74,42.77 120.01,43.04 120.01,43.18 119.88,43.31 119.74,43.31 119.46,43.04 119.33,43.04 117.62,44.75 115.16,44.75 113.05,46.86
  BOTTOM w0.076: UC1.W11 108.4,59.69 v2(108.72,59.36)
  BOTTOM w0.107: JDIMM2.190 158.47,15.03 158.34,15.16 158.34,16.84 v2(159.19,17.69)
DDR_B_D29: length 86.7
  IN1 w0.076: 112.67,47.14 112.67,47.73 108.38,52.02 108.38,56.42 107.97,56.83 107.97,58.6 v2(107.8,58.77)
  IN1 w0.097: 112.67,47.14 112.67,46.81 115.03,44.45 117.49,44.45 120.77,41.17 143.63,41.17 152.28,32.52 152.28,31.69 156.93,27.04 157.09,27.04 157.48,26.66 157.48,26.18 157.84,25.82 157.84,20.62 157.6,20.39 157.6,19.83 157.4,19.63 157.4,19.4 157.6,19.2 157.6,17.3 157.44,17.13 157.44,16.81 157.63,16.62 158.8,16.62 158.9,16.52 158.9,15.91 158.8,15.81 158.61,15.81 158.51,15.91 158.51,16.23 158.42,16.32 158.25,16.32 158.14,16.21 158.14,15.88 158.04,15.79 157.59,15.79 157.51,15.71 157.51,15.49 157.61,15.39 158.95,15.39 v2(159.21,15.66)
  BOTTOM w0.076: UC1.W10 108.07,59.04 v2(107.8,58.77)
  BOTTOM w0.107: JDIMM2.194 159.47,15.4 v2(159.21,15.66)
DDR_B_D30: length 84.2
  IN1 w0.076: 115.32,47.62 110.32,52.62 110.32,56.23 109.84,56.71 109.84,56.81 109.66,56.98 v2(109.66,57.41)
  IN1 w0.097: v2(162.69,15.34) 161.51,15.34 161.35,15.5 161.35,16.39 161.51,16.55 161.51,19.44 160.52,20.43 160.52,21.37 160.62,21.47 160.8,21.47 160.91,21.57 160.91,21.77 160.8,21.87 160.62,21.87 160.52,21.97 160.52,22.17 160.62,22.26 161.19,22.26 161.29,22.36 161.29,22.56 161.19,22.66 160.62,22.66 160.52,22.76 160.52,22.96 160.62,23.06 161.19,23.06 161.29,23.16 161.29,23.71 160.52,24.48 160.52,25.52 159.94,26.1 159.94,27.86 144.47,43.33 122.42,43.33 118.97,46.77 116.16,46.77 115.32,47.62
  BOTTOM w0.076: UC1.V7 109.34,57.09 v2(109.66,57.41)
  BOTTOM w0.107: v2(162.69,15.34) 162.97,15.06 JDIMM2.208
DDR_B_D31: length 85.3
  IN1 w0.076: 115.68,47.69 115.49,47.88 115.33,47.88 110.56,52.64 110.56,55.4 110.51,55.45 110.51,56.28 110.1,56.7 110.1,57.62 v2(109.66,58.06)
  IN1 w0.097: v2(162.66,16.89) 162.38,16.89 162.29,16.79 162.29,15.95 162.19,15.86 161.91,15.86 161.81,15.95 161.81,19.57 160.83,20.56 160.83,21 160.93,21.1 161.49,21.1 161.59,21.2 161.59,21.4 161.49,21.5 161.33,21.5 161.24,21.6 161.24,21.8 161.33,21.9 161.49,21.9 161.59,21.99 161.59,23.83 160.82,24.6 160.82,25.64 160.24,26.22 160.24,27.98 144.6,43.63 122.54,43.63 119.1,47.07 116.29,47.07 115.68,47.69
  BOTTOM w0.076: UC1.V8 109.34,57.74 v2(109.66,58.06)
  BOTTOM w0.107: v2(162.66,16.89) 162.25,16.48 162.25,15.47 161.97,15.19 JDIMM2.204
DDR_B_D32: length 48.7
  IN3 w0.076: v2(111.67,50.72) 111.67,49.84 114.29,47.22 114.65,47.22 114.87,47
  IN3 w0.097: 114.87,47 115.03,46.84 115.29,46.57 115.29,36.79 117.94,34.14 117.94,29.49 118.04,29.39 119.2,29.39 119.3,29.29 119.3,29.05 119.2,28.95 118.16,28.95 118.06,28.85 118.06,28.66 118.16,28.56 120.02,28.56 120.12,28.46 120.12,28.2 120.02,28.1 119.14,28.1 119.05,28 119.05,27.81 119.14,27.71 119.78,27.71 120.01,27.49 120.01,19.1 v2(120.42,18.69)
  BOTTOM w0.076: UC1.R2 110.98,53.55 110.98,52.57 111.27,52.27 111.27,51.64 111.67,51.24 v2(111.67,50.72)
  BOTTOM w0.107: JDIMM2.49 121.22,21.27 121.41,21.08 121.41,19.67 v2(120.42,18.69)
DDR_B_D33: length 48.3
  IN3 w0.076: 115.85,48.2 115.67,48.2 111.73,52.15 111.73,54.74 v2(112.44,55.45)
  IN3 w0.097: v2(124.13,17.14) 123.33,17.94 123.33,30.85 117.61,36.57 117.61,46.99 116.4,48.2 115.85,48.2
  BOTTOM w0.076: UC1.P5 112.11,55.78 v2(112.44,55.45)
  BOTTOM w0.107: v2(124.13,17.14) 123.16,16.16 123.16,15.21 123.47,14.9 JDIMM2.58
DDR_B_D34: length 50
  IN3 w0.076: v2(110.84,51.56) 110.84,50.4 114.25,46.99 114.45,46.99 114.65,46.79
  IN3 w0.097: v2(120.55,16.91) 120.24,16.91 120.16,16.83 120.16,16.53 120.07,16.43 119.8,16.43 119.71,16.53 119.71,27.15 119.45,27.41 117.74,27.41 117.64,27.51 117.64,27.74 117.74,27.84 118.61,27.84 118.72,27.94 118.72,28.12 118.61,28.22 117.74,28.22 117.64,28.32 117.64,34.01 114.99,36.66 114.99,46.45 114.65,46.79
  BOTTOM w0.076: v2(110.84,51.56) 110.82,51.59 110.82,54.68 UC1.R4
  BOTTOM w0.107: v2(120.55,16.91) 121.47,15.99 JDIMM2.50
DDR_B_D35: length 48.5
  IN3 w0.076: v2(112.44,54.8) 111.92,54.28 111.92,52.23 115.64,48.5 115.85,48.5
  IN3 w0.097: v2(124.16,18.84) 123.63,19.36 123.63,30.98 123.43,31.18 123.43,31.32 123.67,31.56 123.67,31.7 123.54,31.83 123.39,31.83 123.16,31.59 123.02,31.59 122.88,31.73 122.88,31.87 123.11,32.09 123.11,32.23 122.98,32.36 122.83,32.36 122.61,32.14 122.47,32.14 122.34,32.28 122.34,32.41 122.52,32.6 122.52,32.74 122.39,32.87 122.25,32.87 122.06,32.69 121.93,32.69 117.91,36.7 117.91,47.11 116.53,48.5 115.85,48.5
  BOTTOM w0.076: UC1.P4 112.11,55.13 v2(112.44,54.8)
  BOTTOM w0.107: v2(124.16,18.84) 123.45,19.55 123.45,21.06 123.72,21.34 JDIMM2.59
DDR_B_D36: length 49.7
  IN3 w0.076: 114.44,46.58 114.24,46.78 114.19,46.78 110.4,50.57 v2(110.4,51.96)
  IN3 w0.097: 114.44,46.58 114.69,46.33 114.69,36.54 117.34,33.89 117.34,27.13 117.44,27.03 119.28,27.03 119.4,26.9 119.4,26.72 119.28,26.59 118.3,26.59 118.2,26.49 118.2,26.3 118.31,26.19 119.25,26.19 119.38,26.06 119.38,15.87 119.92,15.33 v2(120.48,15.33)
  BOTTOM w0.076: UC1.R5 110.65,55.17 110.65,55.17 110.65,52.2 110.41,51.96 v2(110.4,51.96)
  BOTTOM w0.107: v2(120.48,15.33) 120.47,15.33 JDIMM2.46
DDR_B_D37: length 46.4
  IN3 w0.076: 115.85,48.8 115.66,48.8 112.11,52.35 112.11,53.17 v2(112.44,53.5)
  IN3 w0.097: v2(124.24,20.51) 124.24,31.56 122.42,33.38 121.68,33.38 119.91,35.15 119.91,35.29 120.36,35.74 120.36,35.87 120.22,36.01 120.08,36.01 119.64,35.56 119.5,35.56 119.36,35.7 119.36,35.84 119.81,36.28 119.81,36.42 119.67,36.56 119.54,36.56 119.09,36.11 118.95,36.11 118.82,36.25 118.82,36.38 119.26,36.83 119.26,36.97 119.13,37.1 118.99,37.1 118.54,36.66 118.41,36.66 118.27,36.79 118.27,36.93 118.72,37.38 118.72,37.51 118.39,37.84 118.39,47.07 116.65,48.8 115.85,48.8
  BOTTOM w0.076: UC1.P2 112.11,53.83 v2(112.44,53.5)
  BOTTOM w0.107: JDIMM2.63 124.72,21 v2(124.24,20.51)
DDR_B_D38: length 47.4
  IN3 w0.076: 114.93,47.36 114.8,47.49 114.29,47.49 112.08,49.7 v2(112.08,50.28)
  IN3 w0.097: v2(120.42,20.46) 120.48,20.52 120.48,29.62 120.37,29.72 118.34,29.72 118.24,29.82 118.24,30.01 118.33,30.11 120.03,30.11 120.13,30.21 120.13,30.39 120.02,30.5 118.33,30.5 118.24,30.59 118.24,30.79 118.33,30.88 120.02,30.88 120.11,30.98 120.11,31.16 120,31.27 118.33,31.27 118.24,31.37 118.24,34.26 116.28,36.22 116.28,46.61 116.03,46.86 115.43,46.86 114.93,47.36
  BOTTOM w0.076: UC1.R1 111.26,52.67 111.6,52.32 111.6,51.76 112.08,51.28 v2(112.08,50.28)
  BOTTOM w0.107: v2(120.42,20.46) 120.22,20.67 JDIMM2.45
DDR_B_D39: length 46.7
  IN3 w0.076: 115.85,49.1 115.66,49.1 112.49,52.27 v2(112.49,52.91)
  IN3 w0.097: 115.85,49.1 116.78,49.1 118.9,46.97 118.9,37.91 121.95,34.87 121.95,34.73 121.54,34.33 121.54,34.18 121.67,34.05 121.81,34.05 122.22,34.46 122.36,34.46 124.67,32.14 124.67,15.9 v2(124.21,15.43)
  BOTTOM w0.076: UC1.P1 112.27,52.91 v2(112.49,52.91)
  BOTTOM w0.107: v2(124.21,15.43) 124.47,15.17 JDIMM2.62
DDR_B_D40: length 51.2
  IN3 w0.097: v2(126.05,20.49) 126.05,32.58 123.12,35.51 123.12,35.87 123.22,35.96 123.8,35.96 123.9,36.06 123.9,36.25 123.8,36.35 123.22,36.35 123.12,36.45 123.12,36.64 123.22,36.74 123.8,36.74 123.9,36.83 123.9,37.03 123.8,37.12 123.22,37.12 123.12,37.22 123.12,37.41 123.22,37.51 123.8,37.51 123.9,37.61 123.9,37.8 123.8,37.9 123.22,37.9 123.12,37.99 123.12,38.18 123.22,38.28 123.93,38.28 124.03,38.38 124.03,38.57 123.93,38.67 123.22,38.67 123.12,38.76 123.12,38.96 123.22,39.05 123.93,39.05 124.03,39.15 124.03,39.34 123.93,39.44 123.22,39.44 123.12,39.54 123.12,45.73 118.35,50.5 116.46,50.5 115.41,51.55 v2(113.83,51.55)
  BOTTOM w0.076: v2(113.83,51.55) 113.83,52.06 113.69,52.21 113.69,52.5 113.33,52.86 113.33,54.68 UC1.M4
  BOTTOM w0.107: v2(126.05,20.49) 125.72,20.82 JDIMM2.67
DDR_B_D41: length 47.8
  IN3 w0.097: v2(126.47,15.43) 126.26,15.43 125.22,16.48 125.22,32.31 121.73,35.8 121.73,38.72 121.82,38.81 122.4,38.81 122.51,38.92 122.51,39.1 122.41,39.2 121.82,39.2 121.73,39.3 121.73,39.49 121.82,39.59 122.4,39.59 122.51,39.69 122.51,39.87 122.41,39.97 121.82,39.97 121.73,40.07 121.73,44.87 119.41,47.18 119.41,47.18 116.82,49.77 116.22,49.77 115.78,50.2 v2(115.18,50.2)
  BOTTOM w0.076: v2(115.18,50.2) 115.18,51.31 114.32,52.17 114.32,52.4 113.77,52.95 UC1.M1
  BOTTOM w0.107: JDIMM2.70 v2(126.47,15.43)
DDR_B_D42: length 52.7
  IN3 w0.097: v2(129.54,20.18) 129.54,32.51 126.77,35.28 126.77,39.29 126.66,39.4 126.3,39.4 126.2,39.49 126.2,39.69 126.3,39.78 126.89,39.78 127,39.89 127,40.09 126.9,40.18 126.3,40.18 126.2,40.28 126.2,40.5 126.3,40.6 126.9,40.6 127,40.7 127,40.89 126.9,40.98 126.18,40.98 126.08,41.08 126.08,41.25 126.19,41.36 126.9,41.36 127,41.46 127,41.63 126.9,41.73 125.58,41.73 125.48,41.83 125.48,42.07 125.58,42.17 126.88,42.17 126.98,42.26 126.98,42.47 126.88,42.57 125.31,42.57 125.22,42.67 125.22,46.97 118.74,53.45 116.3,53.45 v2(114.96,54.79)
  BOTTOM w0.076: v2(114.96,54.79) 114.62,55.13 UC1.L4
  BOTTOM w0.107: JDIMM2.83 129.72,20.36 v2(129.54,20.18)
DDR_B_D43: length 49.4
  IN3 w0.097: v2(129.55,16.87) 129.13,17.3 129.13,32.4 126.44,35.09 126.44,38.17 126.34,38.27 126,38.27 125.9,38.36 125.9,38.56 126,38.65 126.34,38.65 126.44,38.75 126.44,38.94 126.34,39.04 126,39.04 125.9,39.14 125.9,40.84 124.91,41.83 124.91,46.85 118.62,53.15 116.17,53.15 115.85,53.47 v2(114.93,53.47)
  BOTTOM w0.076: v2(114.93,53.47) 114.87,53.47 UC1.L2
  BOTTOM w0.107: v2(129.55,16.87) 128.82,16.15 128.82,15.11 128.97,14.97 JDIMM2.80
DDR_B_D44: length 54.2
  IN3 w0.097: v2(113.38,52) 115.38,52 116.58,50.8 118.23,50.8 118.48,50.8 123.42,45.85 123.42,40.7 123.52,40.6 124.02,40.6 124.13,40.5 124.13,40.32 124.02,40.22 123.52,40.22 123.42,40.12 123.42,39.88 123.5,39.8 124.23,39.8 124.33,39.7 124.33,35.01 126.45,32.88 126.45,32.25 126.55,32.15 127.25,32.15 127.36,32.04 127.36,31.86 127.26,31.76 126.55,31.76 126.45,31.67 126.45,31.47 126.55,31.38 127.25,31.38 127.36,31.27 127.36,31.09 127.26,30.99 126.55,30.99 126.45,30.89 126.45,19.17 v2(126.07,18.79)
  BOTTOM w0.076: UC1.M5 113.16,55.17 113.16,55.17 113.16,53.06 113.16,53.06 113.16,52.75 113.38,52.52 v2(113.38,52)
  BOTTOM w0.107: v2(126.07,18.79) 127.33,20.04 127.33,20.75 126.72,21.36 JDIMM2.71
DDR_B_D45: length 49.2
  IN3 w0.097: v2(126.1,17.01) 125.57,17.53 125.57,32.38 122.81,35.15 122.81,36.99 122.71,37.09 122.27,37.09 122.17,37.19 122.17,37.37 122.27,37.47 122.71,37.47 122.81,37.57 122.81,37.76 122.71,37.86 122.25,37.86 122.14,37.96 122.14,38.15 122.25,38.25 122.71,38.25 122.81,38.34 122.81,45.62 118.26,50.16 116.3,50.16 115.81,50.65 v2(114.73,50.65)
  BOTTOM w0.076: UC1.M2 113.49,53.55 113.49,52.97 114.04,52.43 114.04,52.02 114.73,51.33 v2(114.73,50.65)
  BOTTOM w0.107: JDIMM2.66 125.47,16.38 v2(126.1,17.01)
DDR_B_D46: length 53.6
  IN3 w0.097: v2(129.57,18.53) 129.95,18.92 129.95,32.59 127.3,35.24 127.3,42.65 127.08,42.87 125.61,42.87 125.52,42.97 125.52,43.19 125.61,43.29 127.15,43.29 127.25,43.38 127.25,43.58 127.15,43.67 125.61,43.67 125.52,43.77 125.52,47.1 118.87,53.75 116.48,53.75 116.05,54.18 116.05,54.42 v2(114.96,55.5)
  BOTTOM w0.076: v2(114.96,55.5) 114.78,55.5 UC1.L5
  BOTTOM w0.107: v2(129.57,18.53) 128.6,19.5 128.6,21.08 128.72,21.21 JDIMM2.79
DDR_B_D47: length 49.7
  IN3 w0.097: v2(114.98,52.86) 115.06,52.93 115.92,52.93 116.01,52.85 118.5,52.85 124.61,46.73 124.61,41.7 125.54,40.78 125.54,38.03 125.64,37.92 126.01,37.92 126.11,37.83 126.11,37.64 126.01,37.54 125.64,37.54 125.54,37.44 125.54,37.25 125.64,37.15 126.01,37.15 126.11,37.06 126.11,36.86 126.01,36.77 125.64,36.77 125.54,36.67 125.54,36.48 125.64,36.38 126.01,36.38 126.11,36.28 126.11,35 128.76,32.35 128.76,16.32 129.75,15.33 v2(129.8,15.33)
  BOTTOM w0.076: v2(114.98,52.86) 114.83,52.86 UC1.L1
  BOTTOM w0.107: JDIMM2.84 129.97,15.16 v2(129.8,15.33)
DDR_B_D48: length 88.2
  IN1 w0.076: v2(111.47,60.01) 110.92,59.47 110.92,58.55 110.71,58.34 110.71,56.85 111.09,56.47 111.09,55.96 111.32,55.72 111.32,52.69 115.42,48.59 116.34,48.59 116.46,48.47
  IN1 w0.097: v2(164.43,15.43) 163.41,15.43 163.31,15.53 163.31,15.77 163.41,15.87 163.92,15.87 164.02,15.97 164.02,16.16 163.92,16.26 163.41,16.26 163.31,16.35 163.31,24.97 162.6,25.69 162.6,25.82 163.12,26.35 163.12,26.48 162.98,26.62 162.85,26.62 162.37,26.14 162.23,26.14 162.08,26.3 162.08,26.43 162.65,27.01 162.65,27.14 145.06,44.74 124.3,44.74 120.86,48.18 116.76,48.18 116.46,48.47
  BOTTOM w0.076: UC1.R11 v2(111.47,60.01)
  BOTTOM w0.107: JDIMM2.216 164.97,14.89 v2(164.43,15.43)
DDR_B_D49: length 87.8
  IN1 w0.076: v2(112.38,60.01) 112.94,59.46 112.94,58.42 113.2,58.15 113.2,56.6 114,55.8 114,54.15 114.47,53.69 114.47,52.84 116.43,50.87 116.95,50.87 117.25,51.18 117.37,51.18
  IN1 w0.097: 117.37,51.18 122.85,51.18 123.32,50.71 123.74,50.71 124.41,50.04 124.41,49.9 123.97,49.47 123.97,49.34 124.11,49.2 124.25,49.2 124.68,49.63 124.82,49.63 124.95,49.49 124.95,49.36 124.52,48.93 124.52,48.79 124.66,48.65 124.79,48.65 125.23,49.09 125.36,49.09 126.59,47.86 146.2,47.86 167.01,27.04 167.01,24.21 167.11,24.1 167.94,24.1 168.04,24 168.04,23.77 167.94,23.67 167.56,23.67 167.46,23.57 167.46,23.34 167.56,23.24 168.45,23.24 168.53,23.16 168.53,22.89 168.45,22.81 168.09,22.81 167.99,22.71 167.99,22.42 168.09,22.32 168.43,22.32 168.53,22.22 168.53,22.02 168.43,21.92 168.09,21.92 167.99,21.82 167.99,21.62 168.09,21.53 168.43,21.53 168.53,21.43 168.53,21.23 168.43,21.13 168.09,21.13 167.99,21.03 167.99,20.68 168.1,20.56 v2(168.33,20.56)
  BOTTOM w0.076: UC1.P11 v2(112.38,60.01)
  BOTTOM w0.107: JDIMM2.229 168.22,20.67 v2(168.33,20.56)
DDR_B_D50: length 83.2
  IN1 w0.076: 117.37,50.27 116.22,50.27 113.83,52.67 113.83,53.25 113.33,53.75 113.33,55.67 112.38,56.62 v2(112.38,57.41)
  IN1 w0.097: 117.37,50.27 121.76,50.27 125.08,46.95 145.82,46.95 166.11,26.67 166.11,23.39 167.09,22.41 167.09,15.69 167.33,15.44 v2(168.33,15.44)
  BOTTOM w0.076: UC1.P7 112.05,57.09 v2(112.38,57.41)
  BOTTOM w0.107: JDIMM2.228 167.97,15.09 v2(168.33,15.44)
DDR_B_D51: length 84.9
  IN1 w0.076: v2(111.44,58.06) 111.07,57.69 111.07,57.08 111.45,56.69 111.45,56.29 111.81,55.93 111.81,52.75 115.51,49.05 116.74,49.05 116.89,48.9
  IN1 w0.097: 116.89,48.9 117.01,48.78 121.11,48.78 124.55,45.34 145.31,45.34 163.92,26.73 163.92,20.4 164.18,20.13 164.18,19.51 163.92,19.24 163.92,17.4 164.02,17.3 164.28,17.3 164.38,17.4 164.38,18.79 164.55,18.96 v2(164.71,18.96)
  BOTTOM w0.076: v2(111.44,58.06) 111.33,58.06 UC1.R8
  BOTTOM w0.107: v2(164.71,18.96) 163.72,19.95 JDIMM2.211
DDR_B_D52: length 86.3
  IN1 w0.076: 116.68,48.68 116.57,48.79 115.49,48.79 111.55,52.73 111.55,55.88 111.28,56.16 111.28,56.57 110.9,56.94 110.9,58.2 111.11,58.41 111.11,59.01 v2(111.47,59.36)
  IN1 w0.097: v2(164.78,17.13) 164.81,17.16 165.15,17.16 165.25,17.06 165.25,16.81 165.15,16.71 163.71,16.71 163.62,16.81 163.62,26.61 145.19,45.03 124.43,45.03 120.98,48.48 116.88,48.48 116.68,48.68
  BOTTOM w0.076: UC1.R10 v2(111.47,59.36)
  BOTTOM w0.107: v2(164.78,17.13) 164.7,17.13 163.97,16.4 JDIMM2.212
DDR_B_D53: length 86.8
  IN1 w0.076: v2(112.38,59.36) 112.75,59 112.75,58.34 112.98,58.11 112.98,56.56 113.8,55.74 113.8,54 114.25,53.55 114.25,52.79 116.35,50.68 117.05,50.68 117.24,50.88 117.37,50.88
  IN1 w0.097: v2(168.33,18.9) 168.33,18.59 168.23,18.49 167.79,18.49 167.69,18.59 167.69,19.26 167.86,19.43 167.86,19.86 167.69,20.04 167.69,22.66 166.71,23.64 166.71,26.92 146.07,47.56 126.47,47.56 126,48.02 125.9,48.02 125.43,47.56 125.33,47.56 125.15,47.73 125.15,47.87 125.59,48.3 125.59,48.44 125.45,48.57 125.31,48.57 124.88,48.14 124.75,48.14 122.01,50.88 117.37,50.88
  BOTTOM w0.076: UC1.P10 v2(112.38,59.36)
  BOTTOM w0.107: v2(168.33,18.9) 167.22,20 JDIMM2.225
DDR_B_D54: length 82.3
  IN1 w0.076: v2(111.42,57.38) 111.64,57.16 111.64,56.44 112.02,56.06 112.02,52.82 115.57,49.28 116.94,49.28 117.1,49.11
  IN1 w0.097: v2(164.71,20.79) 164.88,20.96 164.88,21.29 164.79,21.38 164.33,21.38 164.23,21.48 164.23,21.68 164.33,21.77 164.96,21.77 165.05,21.87 165.05,22.07 164.96,22.17 164.33,22.17 164.23,22.27 164.23,22.47 164.33,22.57 164.9,22.57 165,22.66 165,22.83 164.86,22.96 164.33,22.96 164.23,23.06 164.23,23.26 164.33,23.36 164.82,23.36 164.91,23.46 164.91,23.63 164.79,23.76 164.33,23.76 164.23,23.85 164.23,24.05 164.33,24.15 164.8,24.15 164.91,24.26 164.91,24.45 164.82,24.55 164.33,24.55 164.23,24.65 164.23,24.85 164.33,24.94 164.82,24.94 164.91,25.04 164.91,26.17 145.44,45.64 124.7,45.64 121.26,49.08 117.14,49.08 117.1,49.11
  BOTTOM w0.076: UC1.R7 111.11,57.09 111.17,57.15 111.18,57.15 v2(111.42,57.38)
  BOTTOM w0.107: v2(164.71,20.79) 164.72,20.8 JDIMM2.215
DDR_B_D55: length 85
  IN1 w0.076: v2(112.38,58.06) 112.76,57.68 112.76,56.5 113.57,55.7 113.57,53.85 114.05,53.36 114.05,52.71 116.3,50.47 117.14,50.47 117.24,50.58 117.37,50.58
  IN1 w0.097: v2(168.38,17.2) 167.97,16.79 167.49,16.79 167.39,16.89 167.39,22.54 166.41,23.52 166.41,26.79 145.95,47.25 125.2,47.25 121.88,50.58 117.37,50.58
  BOTTOM w0.076: UC1.P8 112.05,57.74 v2(112.38,58.06)
  BOTTOM w0.107: v2(168.38,17.2) 166.97,15.79 JDIMM2.224
DDR_B_D56: length 88.3
  IN1 w0.076: v2(115.1,60.01) 115.83,60.01 116.35,59.49 116.35,59.28 116.56,59.08 117.7,59.08 117.83,58.95 118.18,58.95
  IN1 w0.097: v2(174.23,20.79) 174.23,21.06 174.14,21.16 172.95,21.16 172.85,21.26 172.85,21.51 172.95,21.61 174.07,21.61 174.16,21.71 174.16,21.91 174.07,22.01 172.95,22.01 172.85,22.1 172.85,22.3 172.95,22.4 174.09,22.4 174.19,22.5 174.19,22.68 174.07,22.8 172.95,22.8 172.85,22.9 172.85,23.1 172.95,23.19 173.54,23.19 173.64,23.29 173.64,23.48 173.52,23.59 172.95,23.59 172.85,23.69 172.85,23.89 172.95,23.99 173.4,23.99 173.5,24.09 173.5,25.61 147.76,51.36 141.16,51.36 134.77,57.75 121.63,57.75 120.43,58.95 118.18,58.95
  BOTTOM w0.076: UC1.L11 v2(115.1,60.01)
  BOTTOM w0.107: v2(174.23,20.79) 173.82,20.79 173.22,21.39 JDIMM2.249
DDR_B_D57: length 89.5
  IN1 w0.076: 116.01,52.92 115.11,53.82 114.7,53.82 114.26,54.27 114.26,55.81 113.43,56.64 113.43,58.19 113.66,58.42 113.66,59.16 113.74,59.23 113.74,59.54 v2(114.21,60.01)
  IN1 w0.097: 116.01,52.92 117.25,51.69 123.06,51.69 123.53,51.21 124.52,51.21 127.37,48.36 146.41,48.36 167.52,27.25 167.52,25.31 169.04,23.79 169.04,17.09 169.14,17 169.65,17 169.74,16.9 169.74,16.71 169.65,16.61 169.14,16.61 169.04,16.51 169.04,16.29 169.14,16.19 170.04,16.19 170.13,16.1 170.13,15.9 170.04,15.81 169.43,15.81 169.33,15.71 169.33,15.49 169.45,15.37 v2(170.55,15.37)
  BOTTOM w0.076: UC1.M11 v2(114.21,60.01)
  BOTTOM w0.107: JDIMM2.236 169.97,14.93 170.41,15.37 v2(170.55,15.37)
DDR_B_D58: length 85.3
  IN1 w0.076: v2(115.05,57.44) 115.26,57.44 115.8,56.9 117.17,56.9 117.32,56.74 118.46,56.74
  IN1 w0.097: 118.46,56.74 119.58,56.74 122.42,53.9 123.8,53.9 124.4,53.3 125.39,53.3 128.23,50.46 147.37,50.46 171.95,25.88 171.95,20.07 172.99,19.03 172.99,17.03 173.09,16.93 173.66,16.93 173.76,16.83 173.76,16.63 173.66,16.53 173.26,16.53 173.16,16.44 173.16,16.24 173.26,16.14 174.12,16.14 v2(174.18,16.2)
  BOTTOM w0.076: UC1.L7 114.94,57.44 v2(115.05,57.44)
  BOTTOM w0.107: JDIMM2.250 173.47,15.5 v2(174.18,16.2)
DDR_B_D59: length 85.3
  IN1 w0.076: v2(114.14,57.38) 114.14,57.26 114.67,56.73 115.15,56.73 115.65,56.23 115.65,55.73 116.2,55.17 116.2,54.06 116.49,53.77 116.52,53.77 116.69,53.6
  IN1 w0.097: 116.69,53.6 117.67,52.63 123.39,52.63 123.9,52.11 124.89,52.11 127.74,49.26 146.79,49.26 168.86,27.19 168.86,27.05 168.47,26.66 168.47,26.52 168.61,26.38 168.75,26.38 169.14,26.77 169.28,26.77 169.42,26.63 169.42,26.49 168.63,25.69 168.63,25.55 168.77,25.41 168.91,25.41 169.69,26.19 169.86,26.19 169.99,26.07 169.99,25.9 169.34,25.25 169.34,24.89 169.96,24.27 169.96,22.64 170.06,22.54 170.47,22.54 170.58,22.43 170.58,22.26 170.47,22.15 170.06,22.15 169.96,22.05 169.96,21.85 170.06,21.75 170.49,21.75 170.58,21.65 170.58,21.45 170.49,21.35 170.28,21.35 170.19,21.26 170.19,20.49 170.6,20.08 v2(170.6,20.01)
  BOTTOM w0.076: UC1.M8 113.75,57.77 v2(114.14,57.38)
  BOTTOM w0.107: JDIMM2.237 170.22,21.3 170.1,21.18 170.1,20.29 170.38,20.01 v2(170.6,20.01)
