# Allegro board LA-F711P R05-0112.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
RV11  470_0402_1%  [R_0402]  102.13 121.89 0 top
RV12  470_0402_1%  [R_0402]  104.85 121.87 180 top
RV13  470_0402_1%  [R_0402]  105.71 121.87 0 top
RV14  470_0402_1%  [R_0402]  111.71 123.01 180 top
RV15  470_0402_1%  [R_0402]  112.52 123.01 0 top
RV16  470_0402_1%  [R_0402]  108.43 121.87 180 top
RV17  470_0402_1%  [R_0402]  109.29 121.87 0 top
RV18  10K_0402_5%  [R_0402]  94.79 121.61 90 top
RV19  10K_0402_5%  [R_0402]  113.46 125.2 270 top
RV20  1M_0402_5%  [R_0402]  120.01 122.2 180 top
RV21  20K_0402_5%  [R_0402]  118.72 126.9 0 top
RV22  2.2K_0402_5%  [R_0402]  116.56 126.14 0 top
RV23  2.2K_0402_5%  [R_0402]  115.57 126.14 180 top
RV24  5.6_0402_5%  [R_0402]  102.19 123.32 90 top
RV25  5.6_0402_5%  [R_0402]  101.32 123.32 90 top
RV26  200_0402_5%  [R_0402]  101.3 125.44 0 top
RV27  5.6_0402_5%  [R_0402]  105.69 123.32 90 top
RV28  5.6_0402_5%  [R_0402]  104.82 123.32 90 top
RV29  200_0402_5%  [R_0402]  104.78 125.44 0 top
RV30  5.6_0402_5%  [R_0402]  112.55 124.34 90 top
RV31  5.6_0402_5%  [R_0402]  111.68 124.34 90 top
RV32  200_0402_5%  [R_0402]  111.64 126.33 0 top
RV33  5.6_0402_5%  [R_0402]  109.32 123.39 90 top
RV34  5.6_0402_5%  [R_0402]  108.45 123.39 90 top
RV35  200_0402_5%  [R_0402]  108.41 125.44 0 top
RV50  4.99K_0402_1%  [R_0402]  280.91 38.7 0 top
RV71  100K_0402_5%  [R_0402]  268.52 38.39 180 top
RV74  1M_0402_5%  [R_0402]  280.91 39.66 0 top
RV76  100K_0402_5%  [R_0402]  280.91 34.25 0 top
RV77  100K_0402_5%  [R_0402]  268.52 37.5 180 top
RV79  4.7K_0402_5%  [R_0402]  280.91 36.03 0 top
RV80  4.7K_0402_5%  [R_0402]  280.91 35.14 0 top
RV81  4.7K_0402_5%  [R_0402]  273.85 30.83 270 top
RV82  4.7K_0402_5%  [R_0402]  272.97 30.82 270 top
RV83  4.7K_0402_5%  [R_0402]  280.91 36.92 0 top
RV84  4.7K_0402_5%  [R_0402]  280.91 37.81 0 top
RV89  4.7K_0402_5%  [R_0402]  269.03 40.22 270 top
RV102  100K_0402_5%  [R_0402]  325.67 74.83 90 top
RV106  4.7K_0402_5%  [R_0402]  326.56 74.83 90 top
RV107  4.7K_0402_5%  [R_0402]  327.45 74.83 90 top
RV116  75_0402_1%  [R_0402]  356.79 104.09 90 top
RV117  75_0402_1%  [R_0402]  356.79 101.68 90 top
RV118  75_0402_1%  [R_0402]  356.79 98.88 90 top
RV119  2.2K_0402_5%  [R_0402]  359.66 102.39 180 bottom
RV120  2.2K_0402_5%  [R_0402]  359.46 84.95 180 bottom
RV121  1K_0402_5%  [R_0402]  358.57 88.37 270 bottom
RV122  1K_0402_5%  [R_0402]  359.66 101.5 180 bottom
RV123  4.7K_0402_5%  [R_0402]  326.42 66.13 90 top
RV124  4.7K_0402_5%  [R_0402]  325.4 66.13 90 top
RV323  0_0402_5%  [R_0402]  130.44 95.54 90 top
RV324  0_0402_5%  [R_0402]  131.37 95.54 90 top
RV326  100K_0402_5%  [R_0402]  126.1 97.83 270 top
RV620  4.7K_0402_5%  [R_0402]  328.94 65.71 180 top
RV621  10K_0402_5%  [R_0402]  268.66 31.62 0 top
RV622  4.7K_0402_5%  [R_0402]  328.97 66.62 180 top
RV623  100K_0402_5%  [R_0402]  153.27 98.54 270 bottom
RV624  1M_0402_5%  [R_0402]  153.24 95.57 270 bottom
RV625  47K_0402_5%  [R_0402]  149.85 95.57 90 bottom
RV626  200K_0402_5%  [R_0402]  143.5 96.16 270 bottom
RV627  10K_0402_5%  [R_0402]  144.87 97.94 270 bottom
RV628  0_0402_5%  [R_0402]  154.02 96.58 0 bottom
RV629  200K_0402_5%  [R_0402]  146.31 92.16 270 bottom
RV630  47K_0402_5%  [R_0402]  152.16 90.97 0 bottom
RV631  10K_0402_5%  [R_0402]  148.18 93.9 270 bottom
RV632  0_0402_5%  [R_0402]  153.15 93.74 0 bottom
RV1400  0_0402_5%  [R_0402]  124.37 99.38 0 top
RV1650  100_0402_5%  [R_0402]  358.69 98.91 90 bottom
RV1651  100_0402_5%  [R_0402]  357.55 87.45 90 bottom
RV1656  0_0402_5%  [R_0402]  153.15 91.96 90 bottom
RZ1  0_0402_5%  [R_0402]  333.12 52.83 90 top
RZ2  0_0402_5%  [R_0402]  334.02 52.83 90 top
RZ3  0_0201_5%  [R_0201]  298.64 43.69 270 bottom
RZ4  0_0201_5%  [R_0201]  292.48 44.89 0 bottom
RZ7  0_0402_5%  [R_0402]  291.55 6.01 0 top
RZ8  4.7K_0402_5%  [R_0402]  309.78 13.55 270 bottom
RZ9  4.7K_0402_5%  [R_0402]  308.13 13.55 270 bottom
RZ10  100K_0402_5%  [R_0402]  301.91 7.33 90 top
RZ18  4.7K_0402_5%  [R_0402]  150.8 9.25 270 bottom
RZ19  4.7K_0402_5%  [R_0402]  150.8 6.3 90 bottom
RZ20  2.2K_0402_5%  [R_0402]  154.35 7.21 270 top
RZ21  2.2K_0402_5%  [R_0402]  154.35 8.33 90 top
RZ22  0_0402_5%  [R_0402]  152.5 8.28 0 bottom
RZ23  0_0402_5%  [R_0402]  152.5 7.39 0 bottom
RZ25  150_0402_5%  [R_0402]  301.8 58.95 90 bottom
RZ26  0_0402_5%  [R_0402]  153.41 6.5 180 top
RZ28  330_0402_5%  [R_0402]  322.7 10.06 180 bottom
RZ29  0_0402_5%  [R_0402]  153.41 9.17 180 top
RZ32  330_0402_5%  [R_0402]  352.73 110.69 90 bottom
RZ38  100K_0402_5%  [R_0402]  288.08 2.88 90 top
RZ40  100K_0402_5%  [R_0402]  317.78 70.07 180 top
RZ43  47K_0402_5%  [R_0402]  326.8 63.34 90 bottom
RZ56  0_0402_5%  [R_0402]  306.23 26.51 180 bottom
RZ58  33_0402_5%  [R_0402]  251.13 24.71 90 top
RZ59  33_0402_5%  [R_0402]  248.33 24.71 90 top
RZ60  33_0402_5%  [R_0402]  245.41 24.71 90 top
RZ61  0_0402_5%  [R_0402]  246.3 24.71 90 top
RZ62  10K_0402_5%  [R_0402]  251.81 29.49 0 top
RZ63  33_0402_5%  [R_0402]  244.52 24.71 90 top
RZ64  0_0402_5%  [R_0402]  193.85 4.29 270 bottom
RZ65  0_0402_5%  [R_0402]  195.7 2.31 180 bottom
RZ69  10K_0402_5%  [R_0402]  242.45 26.89 180 top
RZ70  0_0402_5%  [R_0402]  287.19 2.87 90 top
RZ71  0_0402_5%  [R_0402]  286.3 2.87 90 top
RZ78  0_0402_5%  [R_0402]  306.76 24.89 180 bottom
RZ79  0_0402_5%  [R_0402]  306.76 24.01 180 bottom
RZ80  0_0402_5%  [R_0402]  306.76 23.12 180 bottom
RZ81  0_0402_5%  [R_0402]  306.76 22.23 180 bottom
RZ87  0_0402_5%  [R_0402]  298.34 11.01 270 bottom
RZ89  0_0402_5%  [R_0402]  244.14 35.66 270 top
RZ90  0.01_1206_1%  [R_1206]  114.73 112.23 270 top
RZ93  0.01_1206_1%  [R_1206]  136.25 104.42 0 bottom
RZ96  0.01_1206_1%  [R_1206]  294.43 8.34 90 top
RZ99  0.01_1206_1%  [R_1206]  360.35 7.96 90 top
RZ102  0.01_1206_1%  [R_1206]  258.24 8.98 90 top
RZ108  0.01_1206_1%  [R_1206]  266.4 17.16 180 top
RZ112  0_0402_5%  [R_0402]  252.73 30.38 180 top
RZ114  0_0402_5%  [R_0402]  300 11.14 270 bottom
RZ116  10K_0402_5%  [R_0402]  150.8 6.3 90 top
RZ117  10K_0402_5%  [R_0402]  150.8 9.25 270 top
RZ119  0_0402_5%  [R_0402]  70.89 60.8 0 top
RZ120  0_0402_5%  [R_0402]  152.32 54 180 bottom
RZ128  0_0201_5%  [R_0201]  339.66 58.26 270 top
RZ129  0_0201_5%  [R_0201]  340.23 58.26 270 top
RZ130  0_0201_5%  [R_0201]  341.37 58.27 270 top
RZ132  0_0402_5%  [R_0402]  338.38 57.43 90 top
RZ151  0_0402_5%  [R_0402]  131.67 73.05 0 top
RZ320  0_0402_5%  [R_0402]  145.35 81.66 0 bottom
RZ326  0_0402_5%  [R_0402]  330.23 53.71 270 top
RZ334  51_0402_5%  [R_0402]  348.52 48.48 180 bottom
RZ335  15K_0402_5%  [R_0402]  349.53 47.21 0 bottom
RZ345  0_0402_5%  [R_0402]  329.52 51.17 270 top
RZ346  0_0402_5%  [R_0402]  152.5 6.5 0 bottom
RZ347  0_0402_5%  [R_0402]  152.5 9.17 0 bottom
RZ360  10K_0402_5%  [R_0402]  361.96 51.38 90 top
RZ361  150_0402_5%  [R_0402]  307.77 61.62 180 bottom
RZ362  10K_0402_5%  [R_0402]  252.73 31.27 180 top
RZ363  0_0402_5%  [R_0402]  247.4 35.79 270 top
RZ364  100_0402_5%  [R_0402]  311.73 10.94 270 bottom
RZ365  0_0402_5%  [R_0402]  242.56 30.36 180 top
RZ366  0_0402_5%  [R_0402]  242.58 31.23 180 top
RZ367  0_0402_5%  [R_0402]  243.25 35.65 270 top
RZ368  0_0402_5%  [R_0402]  240.97 33.91 0 top
RZ369  0_0402_5%  [R_0402]  242.32 36.71 270 top
RZ370  100_0603_5%  [R_0603]  300.59 49.68 0 top
RZ371  0_0402_5%  [R_0402]  306.76 21.3 180 bottom
RZ372  0_0201_5%  [R_0201]  340.8 58.27 270 top
RZ373  0_0201_5%  [R_0201]  341.95 58.26 270 top
RZ374  0_0201_5%  [R_0201]  339.1 58.25 270 top
RZ375  100K_0402_5%  [R_0402]  282.1 4.32 180 top
RZ376  10K_0402_5%  [R_0402]  294.09 43.47 90 bottom
RZ377  100K_0402_5%  [R_0402]  294.97 45.03 270 bottom
RZ378  100K_0402_5%  [R_0402]  295.53 42.14 0 bottom
RZ379  20K_0402_5%  [R_0402]  292.34 4.89 0 top
RZ380  100K_0402_5%  [R_0402]  289.78 5.99 0 top
RZ381  100K_0402_5%  [R_0402]  290.32 43.14 270 bottom
RZ518  100K_0402_5%  [R_0402]  282.15 2.11 90 top
RZ542  10K_0402_5%  [R_0402]  141.26 86.49 180 bottom
RZ543  10K_0402_5%  [R_0402]  140.13 81.83 0 bottom
RZ1380  0_0402_5%  [R_0402]  126.37 98.45 90 bottom
RZ1381  22_0402_5%  [R_0402]  305.88 33.49 180 bottom
RZ1382  22_0402_5%  [R_0402]  218.92 48.03 0 top
RZ1383  22_0402_5%  [R_0402]  305.88 30.31 180 bottom
RZ1384  22_0402_5%  [R_0402]  215.24 48.22 0 top
SW1  SS3-CMFTQR9_3P  [SW_SS3-CMFTQR9_3P]  211.87 7.2 180 bottom
SW3  SKRBAAE010_4P  [SW_SKRBAAE010_4P]  346.06 121.97 270 top
T1  PAD~D  [TPC12]  127.4 58.48 180 bottom
T2  PAD~D  [TPC12]  128.63 57.95 180 bottom
T3  PAD~D  [TPC12]  125.97 59.42 180 bottom
T4  PAD~D  [TPC12]  128.61 59.38 180 bottom
T5  PAD~D  [TPC12]  78.89 49.82 0 top
T6  PAD~D  [TPC12]  74.6 49.05 0 top
T7  PAD~D  [TPC12]  78.48 83.44 0 top
T8  PAD~D  [TPC12]  79.79 83.43 0 top
T9  PAD~D  [TPC12]  114.75 70.46 0 top
T10  PAD~D  [TPC12]  117.04 70.08 0 top
T11  PAD~D  [TPC12]  74.82 72.81 0 top
T12  PAD~D  [TPC12]  106.92 61.45 0 top
T13  PAD~D  [TPC12]  110.92 61.75 0 top
T14  PAD~D  [TPC12]  110.36 83.34 0 top
T15  PAD~D  [TPC12]  96.91 81.95 180 bottom
T18  PAD~D  [TPC12]  123.93 74.4 180 bottom
T19  PAD~D  [TPC12]  127.87 74.89 0 top
T20  PAD~D  [TPC12]  120.06 49.68 0 top
T21  PAD~D  [TPC12]  118.66 49.68 0 top
T22  PAD~D  [TPC12]  81.14 83.41 0 top
T23  PAD~D  [TPC12]  76.06 78.89 180 bottom
T24  PAD~D  [TPC12]  76.12 72.39 0 top
T25  PAD~D  [TPC12]  91.84 61.23 0 top
T26  PAD~D  [TPC12]  95.31 61.11 0 top
T27  PAD~D  [TPC12]  96.08 62.56 0 top
T28  PAD~D  [TPC12]  95.53 73.62 0 top
T29  PAD~D  [TPC12]  77.29 71.6 0 top
T30  PAD~D  [TPC12]  77.01 70.32 0 top
T31  PAD~D  [TPC12]  93.63 60.9 0 top
T32  PAD~D  [TPC12]  90.94 60.29 0 top
T33  PAD~D  [TPC12]  200.97 25.55 0 top
T34  PAD~D  [TPC12]  201.51 27.08 0 top
T35  PAD~D  [TPC12]  208.28 26.45 0 top
T36  PAD~D  [TPC12]  221.28 46.66 180 bottom
T37  PAD~D  [TPC12]  212.84 35.25 0 top
T38  PAD~D  [TPC12]  208.19 35.77 0 top
T40  PAD~D  [TPC12]  199.82 37.82 0 top
T41  PAD~D  [TPC12]  100.12 59.33 0 top
T42  PAD~D  [TPC12]  117.24 60.48 0 top
T43  PAD~D  [TPC12]  125.95 58.04 180 bottom
T44  PAD~D  [TPC12]  75.95 71.09 0 top
T45  PAD~D  [TPC12]  125.78 78.66 180 bottom
T46  PAD~D  [TPC12]  76.88 49.85 0 top
T47  PAD~D  [TPC12]  77.89 48.96 0 top
T48  PAD~D  [TPC12]  127.36 59.84 180 bottom
T49  PAD~D  [TPC12]  125.23 80.35 180 bottom
T50  PAD~D  [TPC12]  70.35 12.14 0 top
T51  PAD~D  [TPC12]  71.85 20.93 0 top
T52  PAD~D  [TPC12]  151.24 16.15 0 top
T53  PAD~D  [TPC12]  152.81 24.54 0 top
T58  PAD~D  [TPC12]  219.44 33.3 270 bottom
T59  PAD~D  [TPC12]  218.17 33.17 270 bottom
T60  PAD~D  [TPC12]  199.72 36.52 270 top
T61  PAD~D  [TPC12]  198.42 37.64 270 top
T62  PAD~D  [TPC12]  209.52 26.1 270 top
T63  PAD~D  [TPC12]  208.26 24.87 270 top
T66  PAD~D  [TPC12]  207.37 37.83 270 top
T67  PAD~D  [TPC12]  207.15 36.52 270 top
T68  PAD~D  [TPC12]  199.42 29.62 270 top
T69  PAD~D  [TPC12]  198.66 27.46 270 top
T70  PAD~D  [TPC12]  200.29 27.48 0 top
T71  PAD~D  [TPC12]  199.89 26.24 0 top
T72  PAD~D  [TPC12]  200.99 36.93 0 top
T73  PAD~D  [TPC12]  201.05 38.28 0 top
T74  PAD~D  [TPC12]  210.41 32.42 0 top
T75  PAD~D  [TPC12]  219.01 43.56 180 bottom
T76  PAD~D  [TPC12]  198.42 17.47 270 bottom
T77  PAD~D  [TPC12]  197.38 18.21 180 bottom
T88  PAD~D  [TPC12]  313.79 85.81 0 top
T89  PAD~D  [TPC12]  317.08 84.76 0 top
T141  PAD~D  [TPC12]  309.36 41.49 0 top
T143  PAD~D  [TPC12]  318.51 33.2 180 bottom
T144  PAD~D  [TPC12]  311.46 29.55 0 top
T178  PAD~D  [TPC12]  218.23 26.57 90 bottom
T179  PAD~D  [TPC12]  48.43 55.65 180 top
T180  PAD~D  [TPC12]  51.12 52.25 180 top
T181  PAD~D  [TPC12]  58.85 54.63 180 top
T182  PAD~D  [TPC12]  166.16 56.03 0 top
T183  PAD~D  [TPC12]  207.82 46.56 90 top
T184  PAD~D  [TPC12]  47.86 52.86 180 top
T185  PAD~D  [TPC12]  50.08 54.13 180 top
T186  PAD~D  [TPC12]  47.16 50.7 0 top
T187  PAD~D  [TPC12]  49.58 50.82 0 top
T188  PAD~D  [TPC12]  46.19 36.86 0 top
T189  PAD~D  [TPC12]  34.74 37.4 180 top
T190  PAD~D  [TPC12]  74.13 71.41 180 bottom
T191  PAD~D  [TPC12]  46 33.82 180 top
T192  PAD~D  [TPC12]  208.5 47.97 90 bottom
T194  PAD~D  [TPC12]  124.38 75.72 180 bottom
T199  PAD~D  [TPC12]  76.3 60.43 180 bottom
T200  PAD~D  [TPC12]  359.58 105.18 180 bottom
T219  PAD~D  [TPC12]  28.35 87.85 0 top
T220  PAD~D  [TPC12]  29.52 89.8 0 top
T225  PAD~D  [TPC12]  341.87 50.6 180 bottom
T258  PAD~D  [TPC12]  217.53 27.76 180 bottom
T259  PAD~D  [TPC12]  209.11 34.33 0 top
T260  PAD~D  [TPC12]  217.86 36.38 0 top
T262  PAD~D  [TPC12]  316.92 33.93 180 bottom
T264  PAD~D  [TPC12]  325.5 37.88 0 top
T268  PAD~D  [TPC12]  211.29 26.89 0 top
T269  PAD~D  [TPC12]  219.43 36.37 180 bottom
T283  PAD~D  [TPC12]  243.55 33.2 0 top
T284  PAD~D  [TPC12]  126.6 74.19 0 top
T285  PAD~D  [TPC12]  133.73 76.03 0 top
T286  PAD~D  [TPC12]  217.65 24.87 90 bottom
T287  PAD~D  [TPC12]  209.97 29.6 90 top
T300  PAD~D  [TPC12]  197.58 39.51 90 top
T301  PAD~D  [TPC12]  196.97 41.06 90 top
T302  PAD~D  [TPC12]  208.77 14.11 180 bottom
T304  PAD~D  [TPC12]  211.29 34.09 0 top
TL1  350UH_IH-160  [TAIMA_IH-160_24P]  336.08 109.99 180 bottom
UA1  -  [ALC3246-CG_MQFN48_6X6]  339.12 34.72 90 top
UC1  CFL-H_BGA1440  [CFL-H_BGA_1440P-T]  120.98 53.18 270 bottom
UC3  -  [74AHC1G09GW_TSSOP5]  218.7 50.9 270 bottom
UC5  W25Q256JVEIQ_WSON8_8X6  [W25Q256FVEIQ_WSON8_8X6]  234.74 20.64 270 bottom
UC6  -  [MX25L25645GM2I-10G_SO8]  238.41 13.55 0 bottom
UD1  74AUP1G07SE-7_SOT353  [74AUP1G07GW_TSSOP5]  68.52 60.17 270 bottom
UE1  MEC5105_WFBGA169_11X11  [MEC5105_WFBGA_169P]  313.72 40.35 0 top
UE3  TC7SH08FU_SSOP5~D  [TC7SH08FU_SSOP5]  341.53 50.51 270 top
UE4  -  [74AUP1G07GW_TSSOP5]  345.09 50.51 270 top
UE5  TC7SH08FU_SSOP5~D  [TC7SH08FU_SSOP5]  336.71 50.26 270 top
UE6  -  [74AUP1G07GW_TSSOP5]  261.52 24.35 270 bottom
UH1  CNP-H_BGA874  [CNP-H_BGA_874P-T]  192.77 43.6 270 bottom
UH7  -  [TC7SH08FU_SSOP5]  235.38 25.97 90 bottom
UI1  -  [SY6288D20AAC_SOT23-5]  20.44 96.23 90 bottom
UI2  -  [SY6288D20AAC_SOT23-5]  95.91 122.01 90 bottom
UI3  -  [SLGC55544CVTR_TQFN16_3X3]  339.5 67.4 0 top
UL1  WGI219LM-SLKJ2-A0_QFN48_6X6~D  [WGI219LM-SLKJ2-A0_QFN48_6X6]  324.3 84.1 180 top
UL2  TC7SH08FU_SSOP5~D  [TC7SH08FU_SSOP5]  316.26 90.51 90 top
UN7  PI3EQX6741STZDEX_TQFN20_4X4  [PI3EQX6741STZDEX_TQFN20_4X4-S]  246.66 15.84 0 bottom
UR1  -  [RTS5242-GR_QFN32_4X4]  15.78 69.34 0 top
UT5  TPS65982_BGA96  [TPS65982_BGA_96P]  30.38 85.69 0 bottom
UT6  GD25Q80CSIGR_SO8  [W25Q80DVSSIG_SO8]  49.09 85.43 180 bottom
UT7  AP2112K-3.3TRG1_SOT23-5  [AP2112K-3P3TRG1_SOT23-5]  33.86 101.62 270 bottom
UT8  AP2204R-5.0TRG1_SOT89-3  [AP2204R-5P0TRG1_SOT89-3]  31.44 110.38 0 bottom
UT9  -  [PS8802QFN52GTRA0_QFN52_6P5X4P5]  21 114.72 270 bottom
UV2  -  [AP2330W-7_SC59-3]  124.06 123.85 90 bottom
UV4  -  [AP2330W-7_SC59-3]  353.56 85.5 270 bottom
UV6  -  [RTD2166-CG_QFN32_4X4]  325.28 72.23 0 top
UV9  -  [PS8330BQFN48GTR2-A0_QFN48_7X7]  278.3 33.49 90 top
UV24  -  [G524B1T11U_SOT23-5]  140.11 106.9 90 bottom
UZ2  -  [EM5209VF_DFN14_3X2]  315.12 69.31 90 top
UZ3  -  [EM5209VF_DFN14_3X2]  193.83 3.9 0 top
UZ4  -  [EM5209VF_DFN14_3X2]  285.53 5.55 0 top
UZ5  -  [EM5209VF_DFN14_3X2]  332.01 18.76 0 top
UZ6  TC7SH08FU_SSOP5~D  [TC7SH08FU_SSOP5]  313.8 22.49 180 top
UZ8  -  [AOZ1336DI_DFN8_2X2]  331.75 48.73 180 top
UZ10  TC7SH08FU_SSOP5~D  [TC7SH08FU_SSOP5]  345.93 110.88 90 bottom
UZ12  NPCT750JAAYX_QFN32_5X5  [NPCT650JB2YX_QFN32_5X5]  248.94 32.8 270 top
UZ19  -  [TPS22961DNYR_WSON8]  143.67 72.13 0 top
UZ21  -  [TPS22961DNYR_WSON8]  131.22 91.78 180 top
UZ23  -  [AOZ1336DI_DFN8_2X2]  263.3 6.31 0 top
UZ26  -  [TPS22961DNYR_WSON8]  69.14 62.08 90 bottom
UZ29  -  [PI3PCIE3212ZBEX_TQFN20_2P5X4P5]  362.53 49.05 180 top
UZ34  -  [TC7SH08FU_SSOP5]  152.68 51.03 180 bottom
UZ35  -  [SN74AHC1G08DCKR_SC70-5]  144.98 84.89 0 bottom
UZ61  -  [74AUP1G07GW_TSSOP5]  141.54 83.25 180 bottom
YE1  32.768KHZ_9PF_X1A000141000200  [Y_X1A000141000200_2P]  311.56 45.3 0 top
YH1  32.768KHZ_12.5PF_9H03200042  [Y_9H03200042_2P]  217.06 13.25 0 bottom
YH2  24MHZ_12PF_7M24000055  [Y_7M24000055_4P]  198.65 50.55 0 bottom
YL1  25MHZ_20PF_XRCGB25M000F2P18R0  [Y_XRCGB25M000F2P18R0_4P]  329.49 90.08 270 top

## Library data of the parts
CA1-CA6 CA12 CA13 CA19 CA22-CA24 CA27 CA28 CA33 CA35 CA41 CA54 CA62-CA69 CA72-CA76 CC28 CC29 CC32 CC33 CC193 CC194 CC269 CC300-CC308 CC316 CC318-CC320 CC322-CC325 CC327 CC328 CC334 CC335 CD9-CD16 CD18 CD19 CD23-CD27 CD29 CD31 CD32 CD41-CD48 CD50 CD51 CD55-CD59 CD61 CD62 CE3 CE4 CE8 CE10 CE12 CE14 CE24 CE26-CE31 CE35-CE40 CE46 CE47 CE52-CE54 CE57 CE59-CE66 CH4 CH5 CH10 CH13 CH14 CH20-CH22 CH29-CH38 CH40 CH41 CH46 CH63 CH65-CH67 CH266-CH268 CH321-CH323 CH340-CH348 CI4 CI5 CI9 CI13 CI16 CI27 CI28 CI31 CI43-CI48 CL1 CL2 CL5 CL6 CL13 CL14 CL18 CL29 CL30 CN4-CN8 CN12-CN16 CN60 CN65-CN72 CR1 CR4 CR11-CR15 CR21 CR22 CR25-CR28 CT22 CT44-CT48 CT70-CT74 CT83 CT85-CT87 CT89-CT93 CT103-CT117 CT119 CT122 CT189 CT190 CT610-CT612 CT614-CT618 CT625-CT629 CV1-CV7 CV11 CV13 CV14 CV17-CV25 CV31-CV38 CV61 CV75 CV100-CV112 CV126-CV135 CV631-CV636 CV1635 CV1638 CZ3-CZ13 CZ17-CZ19 CZ21 CZ23-CZ25 CZ28 CZ29 CZ33-CZ41 CZ56-CZ63 CZ69 CZ71-CZ73 CZ75 CZ80 CZ81 CZ83-CZ89 CZ100-CZ102 CZ104-CZ106 CZ109 CZ110 CZ113 CZ114 CZ117 CZ118 CZ121 CZ124 CZ126 CZ127 CZ130 CZ150-CZ155 CZ197 CZ198 CZ544 CZ1200 PC1 PC2 PC9 PC10 PC100 PC103 PC113 PC115 PC116 PC127 PC128 PC133-PC140 PC202 PC203 PC206-PC208 PC216-PC218 PC221 PC222 PC303 PC307 PC314 PC403 PC405 PC407 PC409 PC415 PC503 PC505 PC506 PC509 PC510 PC513 PC515 PC834-PC840 PC902 PC903 PC925-PC929 PC932 PC933 PC937-PC939 PC942-PC947 PC949 PC950 PC955-PC959 PC1023-PC1032 PC1074-PC1087 PC1103-PC1109 PC1201-PC1217 PC1700-PC1731 PC1733-PC1737 PC1800-PC1803 PC1806 PC1807 PC1816 PC1817 PC1901 PC1902 PC1910 PC1911 PC2001 PC2002 PC2010 PC2011 PC2020 PC2021 PC2027-PC2040 PC2048-PC2055 = C_0402
CA7 CA8 CA10 CA45 CA47 CA55 CA57 CA60 CC186 CC191 CC192 CC195 CC209 CC210 CC310 CC311 CC329-CC332 CD28 CD60 CE11 CE13 CE15 CE18-CE23 CE25 CH9 CH44 CH62 CH64 CH68 CH270 CI3 CI7 CI10 CI12 CI17 CI19 CL3 CL7-CL11 CL15-CL17 CL19-CL21 CN2 CN3 CN9-CN11 CN17 CN61 CN62 CR2 CR3 CR6 CR7 CR17 CR19 CT80 CT81 CT88 CT95-CT102 CT118 CT630-CT633 CV12 CV39 CV40 CV62 CV65-CV74 CZ1 CZ2 CZ30 CZ31 CZ50 CZ51 CZ53 CZ54 CZ64 CZ66-CZ68 CZ82 CZ90-CZ93 CZ103 CZ111 CZ112 CZ115 CZ116 CZ119 CZ120 CZ122 CZ125 CZ128 CZ129 PC800-PC806 PC819-PC833 PC851 PC852 PC1088-PC1099 PC1132-PC1146 PC1162-PC1170 = C_0201
CA9 CA25 CA29 CA31 CA43 CA44 CA46 CA48 CA49 CA51-CA53 CA56 CA58 CA59 CA61 CC81-CC84 CC161 CC163-CC168 CC170-CC172 CC185 CC187-CC189 CC272 CC333 CD1-CD8 CD20-CD22 CD33-CD40 CD52-CD54 CE16 CE17 CE32 CH47 CI6 CI11 CI33 CI34 CL4 CL12 CN1 CN63 CN64 CR5 CR18 CR20 CT82 CT84 CT94 CV15 CV16 CV41 CZ20 CZ27 CZ32 CZ52 CZ55 PC3-PC7 PC11 PC102 PC111 PC112 PC114 PC119 PC125 PC126 PC204 PC205 PC209-PC214 PC219 PC223 PC302 PC304-PC306 PC308-PC313 PC315 PC316 PC401 PC404 PC408 PC410-PC412 PC501 PC502 PC504 PC508 PC514 PC516 PC807-PC813 PC815-PC818 PC841-PC844 PC930 PC931 PC934 PC940 PC941 PC1001-PC1019 PC1041-PC1056 PC1111-PC1116 PC1172-PC1181 PC1732 PC1808-PC1815 PC1818-PC1825 PC1900 PC1903-PC1909 PC1912-PC1919 PC2000 PC2003-PC2009 PC2012-PC2019 PC2022 PC2023 = C_0603
CD17 CD49 = C_D3
CD63 CD64 = C_5X4P5
CH45 CH324 CL28 CT75-CT78 PC8 PC104-PC110 PC117 PC118 PC120-PC124 PC129 PC130 PC200 PC201 PC511 PC904-PC906 PC911 PC913-PC916 PC935 PC936 PC951-PC954 = C_0805
CI1 CI8 CI14 = C_1206
CI32 CZ26 PC909 PC921 PC922 PC1826 PC1828 PC1920 PC1922 PC2024 = C_B2
CL22 = C_1808
CMOS1 JTAG1 = SHORTPADS: User Part Number: PART#
DA1-DA3 DA6 DA7 = L03ESDL5V0CC3-2_SOT23-3
DA8 DE2 DH1-DH3 DV11 DV12 DZ1 DZ2 DZ5-DZ7 PD100 PD903 = RB520SM-30T2R_EMD2-2
DE1 = BZV55-B5V1_SOD80C2
DI1 DI4 DI6 DT39 DT40 = L05ESDL5V0NA-4_SLP2510P8-10-9
DI2 DI3 DI5 DV4 PD4 = AZC199-02SPR7G_SOT23-3
DT1-DT3 = 1N4148WS-7-F_SOD323-2
DT4 = L30ESD24VC3-2_SOT23-3
DT5 DT6 DT9 DT10 DT13 DT14 DT17 DT18 = ESD101-B1-02ELS_TSSLP-2-4-2
DV1-DV3 DZ9 PD905 PD1801 = BAT54CW_SOT323-3
DV5 DV6 = PJDLC05C_SOT23-3
DZ8 = RB751S40T1G_SOD523-2
FD1-FD4 = FIDUCIAL_C40M80
H1-H4 H16 = H_3P8
H5 H6 = H_1P0N
H7 H8 = H_3P2
H9 H10 = H_2P6-G
H11 H23 = H_5P2-G
H12 = H_2P4N
H13 H14 H18 H21 = H_2P4-G
H17 = H_4P6-G
H19 H20 = H_5P0X4P0N
H22 = H_5P1-G
H34 H35 = H_3P3
H42 = H_0P7N
H43 = H_0P9N
H46 = H_2P4X1P8N
H49 = H_3P2N
JAPS1 = ACES_50506-01841-P01_18P
JCRT1 = CCM_C070546HR015M29CZR_15P-T
JDB1 = JXT_FP241AH-006GAAM_6P
JDEG1 JESPI = JXT_FP241AH-010GAAM_10P
JDIMM1 JDIMM2 = LCN_DAN05-Q0406-0103_260P
JEDP1 = ACES_50398-04041-001_40P
JFAN1 = ACES_50271-0040N-001_4P
JHDMI1 = CONCR_099BKAC19YBLCNF_19P
JHP1 = SINGA_2SJ3095-059111F_6P
JIR1 = ACES_50208-0060N-P01_6P
JKBTP1 = CVILU_CF5020FD0RK-05-NH_20P-T
JLED1 = CVILU_CF5006FD0R0-05-NH_6P
JLOM1 = SANTA_130456-831_13P-T
JNGFF1 = LCN_DAN05-67406-0102_75P-T
JNGFF2 = CONCR_213BAAA42FA_75P
JNGFF3 = LCN_DAN05-67356-0103_75P
JRTC1 = ACES_50271-0020N-001_2P
JSATA1 = ACES_59003-02006-002_20P
JSD1 = T-SOL_156-2000302608_19P_NR
JSIM1 = T-SOL_5-991503004000-6_8P-T
JSPI1 = ACES_50506-02041-P01_20P
JSPK1 = ACES_50278-00401-001_4P
JUSB1-JUSB3 = J-L_TNBNRAC70030009_9P
JUSBC1 = JAE_DX07BD24JJ2_24P-T
JUSH1 = CVILU_CF5026FD0RK-05-NH_26P-T
JXDP1 = SAMTE_BSH-030-01-L-D-A_60P
LA5 LA12 LA14 LV14 LV30 = MURAT_BLM15PX600SN1D_2P
LA6-LA9 = MURAT_BLM15PD800SN1D_2P
LA10 LA11 LA15 LA16 = MURAT_BLM15PX330SN1D_2P
LA13 = TAI-T_HCB2012KF-121T50_2P
LC1-LC3 = MURAT_BLM15GA750SN1D_2P
LED3 = LED_LTW-C193DC-C_2P
LGA1 = LNG2DMTR_LGA12_2X2
LI3 LI4 LI7 LV27 LZ1 = PANAS_EXC24CQ900U_4P
LI8 LI9 = INPAQ_MCM1012B900F06BP_4P
LI16 LI17 = INPAQ_HCM1012GH900BP_4P
LL1 = TAIYO_BRC2012T4R7MD_2P
LT11 LT601-LT605 = MURAT_BLM18KG331SN1D_2P
LV1 LZ2 = MURAT_BLM15PX221SN1D_2P
LV3 LV6 LV9 LV12 = TAIYO_MCF12102G900-T_4P
LV16-LV18 = MURAT_BLM15BB470SN1D_2P
PBATT1 = DEREN_40-42251-01001RHF_10P-T
PC848 PC849 = C_X
PC1021 PC1022 PC1171 PC2026 = C_D2
PC1804 PC1805 = C_D
PD1 PD2 = TVNST52302AB0_SOT523-3
PD3 = DB3J315E0L_SMINI3-F2-B3
PD5 PD1202 = PDS5100H-13_POWERDI5-3
PD6 = DFLS160-7_POWERDI123-2
PD901 PD904 PD1205 = D_SOD323-2
PD906 = SMF22A-SOD123FL-2-S
PH1700-PH1704 PR1-PR8 PR10-PR12 PR14-PR18 PR24 PR27 PR28 PR30 PR102 PR103 PR107 PR108 PR113 PR116 PR117 PR204-PR207 PR209 PR212 PR302 PR306 PR311-PR313 PR316 PR403 PR405 PR415-PR420 PR425 PR427 PR501 PR505 PR506 PR509 PR510 PR512 PR514-PR517 PR607 PR609 PR918 PR919 PR925 PR927 PR930-PR934 PR940 PR944 PR945 PR948 PR950 PR953 PR1201-PR1203 PR1205-PR1210 PR1212-PR1214 PR1217 PR1219 PR1221 PR1222 PR1224-PR1237 PR1239 PR1240 PR1246-PR1249 PR1251-PR1255 PR1258-PR1262 PR1700 PR1701 PR1703-PR1707 PR1709 PR1711-PR1716 PR1718-PR1722 PR1725 PR1727 PR1729-PR1734 PR1736-PR1746 PR1748 PR1753 PR1755-PR1766 PR1769-PR1776 PR1802 PR1806 PR1902 PR1906 PR2002 PR2007-PR2013 RA5-RA9 RA12-RA14 RA17 RA18 RA35-RA37 RA44 RA45 RA48 RA50-RA54 RA57-RA61 RC1 RC2 RC5-RC7 RC66 RC71 RC74 RC75 RC78-RC80 RC83 RC84 RC114 RC115 RC121 RC122 RC124 RC126-RC129 RC132 RC133 RC135-RC141 RC143 RC144 RC152 RC153 RC157 RC166 RC168 RC169 RC171 RC177-RC179 RC181 RC217-RC219 RC221 RC228-RC230 RC239-RC241 RC304 RC314 RC315 RC319 RC321-RC326 RC366-RC370 RC436-RC443 RC557 RC558 RC560 RC561 RD4-RD9 RD11 RD12 RD14-RD25 RD27-RD31 RE5 RE8 RE10-RE12 RE20 RE21 RE25 RE26 RE30-RE33 RE35 RE37 RE38 RE43 RE48 RE51 RE55-RE60 RE63-RE65 RE67-RE75 RE77 RE79 RE83-RE86 RE90-RE92 RE94 RE95 RE274 RE275 RE280 RE288 RE290 RE292 RE300-RE304 RE306 RE308 RE312-RE314 RE318 RE324 RE340 RE342 RE343 RE349 RE350 RE362 RE365 RE375 RE505 RE507 RE508 RE525 RE526 RE532 RE536 RE539 RE541 RE543 RE546-RE552 RE560 RE561 RE565 RE566 RE702 RE703 RH1 RH10 RH11 RH13-RH15 RH28-RH30 RH37-RH39 RH42-RH46 RH48 RH50 RH56 RH57 RH60 RH62 RH65 RH67 RH70 RH73-RH77 RH80 RH81 RH83 RH90 RH92-RH95 RH97 RH99-RH101 RH110 RH132 RH133 RH152-RH156 RH161 RH166-RH171 RH177-RH185 RH187 RH192 RH193 RH198-RH201 RH203 RH204 RH207 RH214 RH215 RH221-RH225 RH237 RH240 RH243 RH244 RH246 RH250 RH255-RH260 RH286-RH288 RH290-RH300 RH302-RH306 RH308-RH310 RH312-RH319 RH322-RH331 RH333-RH335 RH339 RH340 RH344 RH345 RH348 RH351-RH353 RH355 RH360 RH361 RH364 RH365 RH373-RH380 RH402 RH424 RH431-RH436 RH439-RH445 RH553-RH556 RH600-RH625 RI13 RI14 RI27-RI30 RI47-RI50 RL1-RL7 RL9 RL11-RL20 RL29 RL30 RL34 RL70 RN1-RN21 RN37 RN99-RN101 RN226 RN227 RR3-RR10 RR19 RT50-RT60 RT63-RT76 RT81-RT90 RT92 RT93 RT95-RT101 RT103-RT111 RT120-RT123 RT130-RT133 RT135-RT142 RT246 RT300 RT303-RT308 RT339 RT375-RT380 RT393 RT414 RT415 RV1-RV35 RV50 RV71 RV74 RV76 RV77 RV79-RV84 RV89 RV102 RV106 RV107 RV116-RV124 RV323 RV324 RV326 RV620-RV632 RV1400 RV1650 RV1651 RV1656 RZ1 RZ2 RZ7-RZ10 RZ18-RZ23 RZ25 RZ26 RZ28 RZ29 RZ32 RZ38 RZ40 RZ43 RZ56 RZ58-RZ65 RZ69-RZ71 RZ78-RZ81 RZ87 RZ89 RZ112 RZ114 RZ116 RZ117 RZ119 RZ120 RZ132 RZ151 RZ320 RZ326 RZ334 RZ335 RZ345-RZ347 RZ360-RZ369 RZ371 RZ375-RZ381 RZ518 RZ542 RZ543 RZ1380-RZ1384 = R_0402
PJP1 PJP2 PJP7 PJP12 PJP15 PJP16 PJP18-PJP22 PJP32 PJP33 PJP35 PJP37 PJP38 PJP42 PJP201 PJP391 PJP501-PJP506 = JUMP_43X39
PJP3 PJP13 PJP14 PJP17 PJP34 PJP36 PJP40 PJP100 PJP101 PJP202 PJP301 PJP402 = JUMP_43X79
PJP8 PJP31 PJP39 PJP41 PJP102 PJP103 PJP200 PJP302 PJP401 PJP1202 PJP2000 PJP2001 = JUMP_43X118
PJP901 = JUMP_43X118-NPM
PJPDC1 = CVILU_CI0805M1HRC-NH_5P-T
PL1 PL2 = TAIYO_FBMJ4516HS720NT_2P
PL3 = MURAT_BLM15AG102SN1D_2P
PL4 PL302 PL1201 PL1202 PL1800 PL1801 PL2002 = 5A_Z80_0805_2P
PL100 PL201 = L_7X7X3_M_2P
PL101 = CYNTE_PCMC063T-1R5MN_2P
PL301 = L_5X5X3_M_2P
PL401 = CYNTE_PCMB042T-1R0MS_2P
PL405 PL502 = 3A_Z120_0603_2P
PL501 = MAG_MLV-FY12N1R0M-O1L_2P
PL901 = MAGLA_MMD-05CZ-1R0M-M7L_2P
PL902 = MAG_MMD-10DZ-1R0M-X1A_2P
PL1802 PL1803 PL1900 PL1901 PL2000 = L_7X7X3_M
PL2001 = MAG_MMD05CZR47M_4P
PQ1 PQ1201 PQ1204 PQ1209 PQ1214 QE2 QH4 QL1 QL2 QN1 QV3 QZ2 QZ7 QZ17 QZ18 = DMN65D8LDW-7_SOT363-6
PQ2 = FDV301N-G_SOT23-3
PQ3 = MMST3904-7-F_SOT323-3
PQ4 PQ9 PQ906 PQ1202 PQ1206 PQ1213 = AON7409_DFN8-5
PQ5 PQ1203 PQ1215 = AO3409_SOT23-3
PQ6-PQ8 PQ909 PQ1205 PQ1212 PQ1216 = DMN65D8LW-7_SOT323-3
PQ902 PQ903 = Q_N_DFN56-8-5
PQ1207 PQ1208 PQ1210 PQ1211 QT1 = DMN66D0LDW-7_SOT363-6
PQ1302 = AON6992_DFN5X6D-8-7
PR13 PR916 = R_0805
PR19-PR23 PR25 PR26 PR29 PR104 PR105 PR114 PR119 PR120 PR208 PR210 PR314 PR315 PR402 PR414 PR504 PR511 PR513 PR920 PR922 PR926 PR928 PR929 PR935 PR936 PR939 PR941 PR942 PR946 PR947 PR949 PR951 PR960 PR1211 PR1215 PR1216 PR1218 PR1220 PR1223 PR1238 PR1241-PR1245 PR1250 PR1257 PR1708 PR1710 PR1717 PR1723 PR1724 PR1726 PR1728 PR1735 PR1767 PR1768 RH66 = R0402_0OHM
PR100 PR111 PR203 PR304 PR404 PR502 PR909 PR910 PR914 PR915 PR921 PR937 PR938 PR943 PR1702 PR1747 PR1749-PR1752 PR1754 PR1800 PR1801 PR1804 PR1805 PR1900 PR1901 PR1904 PR1905 PR2000 PR2001 PR2004 PR2005 RA3 RD10 RD26 RH238 RH239 RH241 RH242 RH247 RH289 RL8 RL71-RL78 RT397 RT398 RZ370 = R_0603
PR106 PR112 PR202 PR303 PR923 PR924 PR1803 PR1807 PR1903 PR1907 PR2003 PR2006 RH254 RH279 RZ90 RZ93 RZ96 RZ99 RZ102 RZ108 = R_1206
PR901 PR917 = R_1206_4P-D
PRP1 RPC1 RPC2 RPE7 RPE9-RPE12 RPH6-RPH8 = RP_0804_8P4R
PT1 T1-T15 T18-T38 T40-T53 T58-T63 T66-T77 T88 T89 T141 T143 T144 T178-T192 T194 T199 T200 T219 T220 T225 T258-T260 T262 T264 T268 T269 T283-T287 T300-T302 T304 = TPC12
PU1 PU903 PU1200 UE3 UE5 UH7 UL2 UZ6 UZ10 UZ34 = TC7SH08FU_SSOP5
PU2 = AP2204R-3P3TRG1_SOT89-3
PU100 = SY8288BRAC_QFN20_3X3
PU102 = SY8288CRAC_QFN20_3X3
PU200 = SY8210AQVC_QFN19_4X3
PU301 = SY8286RAC_QFN20_3X3
PU401 = SY8057BQDC_QFN16_3X3
PU501 = RT8097ALGE_SOT23-6
PU502 PU503 = EM1109V-AD_DFN3308-8_3X3
PU901 = ISL9538HRTZTS277_TQFN32_4X4
PU1201 = LM393DGKR_VSSOP8
PU1700 = NCP81215MNTXG_QFN52_6X6
PU1800 PU1801 PU1900 PU1901 PU2000 PU2001 = NCP302045MNTXG_PQFN33_5X5
QE3-QE7 QV19 QV21 = MMBT3904WT1G_SC70-3
QE11 QE12 QE17 QH6 QN6 QR1 QV2 QV4 QV5 QV7 QZ4 = L2N7002WT1G_SC-70-3
QE15 QH7 QV8 QZ1 QZ16 = LP2301ALT1G_SOT23-3
QV1 = AO6405_TSOP6
QV18 QV20 = MMBT3906H_SOT23-3
QZ3 = DDTA144VCA-7-F_SOT23-3
QZ15 = BSS138W-7-F_SOT323-3
R274 RC216 = R0603_0OHM
RE93 RE100 RE101 RE562 RH61 RH78 RH86 RH123-RH127 RH131 RH267 RH268 RH311 RH371 RH372 RH400 RH401 RH437 RH626-RH637 RT416-RT419 RZ3 RZ4 RZ128-RZ130 RZ372-RZ374 = R_0201
SW1 = SW_SS3-CMFTQR9_3P
SW3 = SW_SKRBAAE010_4P
TL1 = TAIMA_IH-160_24P
UA1 = ALC3246-CG_MQFN48_6X6
UC1 = CFL-H_BGA_1440P-T
UC3 = 74AHC1G09GW_TSSOP5
UC5 = W25Q256FVEIQ_WSON8_8X6
UC6 = MX25L25645GM2I-10G_SO8
UD1 UE4 UE6 UZ61 = 74AUP1G07GW_TSSOP5
UE1 = MEC5105_WFBGA_169P
UH1 = CNP-H_BGA_874P-T
UI1 UI2 = SY6288D20AAC_SOT23-5
UI3 = SLGC55544CVTR_TQFN16_3X3
UL1 = WGI219LM-SLKJ2-A0_QFN48_6X6
UN7 = PI3EQX6741STZDEX_TQFN20_4X4-S
UR1 = RTS5242-GR_QFN32_4X4
UT5 = TPS65982_BGA_96P
UT6 = W25Q80DVSSIG_SO8
UT7 = AP2112K-3P3TRG1_SOT23-5
UT8 = AP2204R-5P0TRG1_SOT89-3
UT9 = PS8802QFN52GTRA0_QFN52_6P5X4P5
UV2 UV4 = AP2330W-7_SC59-3
UV6 = RTD2166-CG_QFN32_4X4
UV9 = PS8330BQFN48GTR2-A0_QFN48_7X7
UV24 = G524B1T11U_SOT23-5
UZ2-UZ5 = EM5209VF_DFN14_3X2
UZ8 UZ23 = AOZ1336DI_DFN8_2X2
UZ12 = NPCT650JB2YX_QFN32_5X5
UZ19 UZ21 UZ26 = TPS22961DNYR_WSON8
UZ29 = PI3PCIE3212ZBEX_TQFN20_2P5X4P5
UZ35 = SN74AHC1G08DCKR_SC70-5
YE1 = Y_X1A000141000200_2P
YH1 = Y_9H03200042_2P
YH2 = Y_7M24000055_4P
YL1 = Y_XRCGB25M000F2P18R0_4P

## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated)
1N4148WS-7-F_SOD323-2
  rect 1.346x0.66 smd: 1(0,0) 2(2.4,0)
3A_Z120_0603_2P
  rect 0.559x1.041 smd: 1(0,0) 2(1.3,0)
5A_Z80_0805_2P
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
74AHC1G09GW_TSSOP5
  oval 0.381x1.346 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.79) 5(0,1.79)
74AUP1G07GW_TSSOP5
  oval 0.381x1.346 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.79) 5(0,1.79)
ACES_50208-0060N-P01_6P
  oval 0.508x0.991 smd: 1(0,0) 2(0.8,0) 3(1.6,0) 4(2.4,0) 5(3.2,0) 6(4,0)
  rect 1.194x1.702 smd: 7(-1.3,-1.95) 8(5.3,-1.95)
ACES_50271-0020N-001_2P
  oval 0.787x1.6 smd: 1(0,0) 2(1.25,0)
  rect 2.108x2.997 smd: 3(3.8,-2.9) 4(-2.55,-2.9)
ACES_50271-0040N-001_4P
  oval 0.787x1.6 smd: 1(0,0) 2(-1.25,0) 3(-2.5,0) 4(-3.75,0)
  rect 2.108x2.997 smd: 5(2.55,-2.9) 6(-6.3,-2.9)
ACES_50278-00401-001_4P
  oval 0.787x1.905 smd: 1(0,0) 2(1.25,0) 3(2.5,0) 4(3.75,0)
  rect 1.295x3.353 smd: 5(-2.85,-4.925) 6(6.6,-4.925)
ACES_50398-04041-001_40P
  oval 0.254x1.295 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0) 19(9,0) 20(9.5,0) 21(10,0) 22(10.5,0) 23(11,0) 24(11.5,0) 25(12,0) 26(12.5,0) 27(13,0) 28(13.5,0) 29(14,0) 30(14.5,0) 31(15,0) 32(15.5,0) 33(16,0) 34(16.5,0) 35(17,0) 36(17.5,0) 37(18,0) 38(18.5,0) 39(19,0) 40(19.5,0)
  rect 1.194x3.2 smd: 41(-2.4,1.95) 45(21.9,1.95)
  rect 2.311x1.295 smd: 42(0.85,3.9) 43(9.75,3.9) 44(18.65,3.9)
ACES_50506-01841-P01_18P
  oval 0.305x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0)
  rect 0.991x2.007 smd: 19(-2.1,-3.05) 20(10.6,-3.05)
ACES_50506-02041-P01_20P
  oval 0.305x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0) 19(9,0) 20(9.5,0)
  rect 0.991x2.007 smd: 21(-2.1,-3.05) 22(11.6,-3.05)
ACES_59003-02006-002_20P
  oval 0.254x1.397 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0) 19(9,0) 20(9.5,0)
  rect 1.295x1.397 smd: 21(10.55,0.125) 22(10.55,4.125) 23(-1.05,4.125) 24(-1.05,0.125)
ALC3246-CG_MQFN48_6X6
  oval 0.889x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 9(0,-3.2) 10(0,-3.6) 11(0,-4) 12(0,-4.4) 25(6.1,-4.4) 26(6.1,-4) 27(6.1,-3.6) 28(6.1,-3.2) 29(6.1,-2.8) 30(6.1,-2.4) 31(6.1,-2) 32(6.1,-1.6) 33(6.1,-1.2) 34(6.1,-0.8) 35(6.1,-0.4) 36(6.1,0)
  oval 0.203x0.889 smd: 13(0.85,-5.25) 14(1.25,-5.25) 15(1.65,-5.25) 16(2.05,-5.25) 17(2.45,-5.25) 18(2.85,-5.25) 19(3.25,-5.25) 20(3.65,-5.25) 21(4.05,-5.25) 22(4.45,-5.25) 23(4.85,-5.25) 24(5.25,-5.25) 37(5.25,0.85) 38(4.85,0.85) 39(4.45,0.85) 40(4.05,0.85) 41(3.65,0.85) 42(3.25,0.85) 43(2.85,0.85) 44(2.45,0.85) 45(2.05,0.85) 46(1.65,0.85) 47(1.25,0.85) 48(0.85,0.85)
  rect 4.394x4.394 smd: 49(3.05,-2.2)
AO3409_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
AO6405_TSOP6
  oval 0.508x1.473 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.35) 5(0.95,2.35) 6(0,2.35)
AON6992_DFN5X6D-8-7
  oval 0.66x0.635 smd: 1(0,0) 3(3.81,5.67) 4(2.54,5.67) 5(1.27,5.67) 6(0,5.67)
  custom 0.485x0.485 smd: 2(1.905,0.655)
  rect 3.988x2.667 smd: 7(1.905,3.62)
AON7409_DFN8-5
  oval 0.406x0.991 smd: 1(0,0) 2(0.66,0) 3(1.32,0) 4(1.98,0)
  custom 0.559x0.559 smd: 5(0.99,2.247)
AOZ1336DI_DFN8_2X2
  oval 0.254x0.787 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(1.5,2.2) 6(1,2.2) 7(0.5,2.2) 8(0,2.2)
  rect 1.499x0.889 smd: 9(0.75,1.1)
AP2112K-3P3TRG1_SOT23-5
  oval 0.508x0.965 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.375) 5(0,2.375)
AP2204R-3P3TRG1_SOT89-3
  oval 0.559x1.295 smd: 1(0,0) 3(3,0)
  custom 0.463x0.463 smd: 2(1.5,1.65)
AP2204R-5P0TRG1_SOT89-3
  oval 0.889x1.295 smd: 1(0,0) 3(3,0)
  custom 0.433x0.433 smd: 2(1.5,1.775)
AP2330W-7_SC59-3
  oval 0.787x0.991 smd: 1(0,0) 2(-0.95,-2.4) 3(0.95,-2.4)
AZC199-02SPR7G_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
BAT54CW_SOT323-3
  oval 0.711x0.889 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
BSS138W-7-F_SOT323-3
  oval 0.711x0.889 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
BZV55-B5V1_SOD80C2
  rect 0.889x1.6 smd: 1(0,0) 2(3.3,0)
C_5X4P5
  oval 2.997x1.6 smd: 1(0,0) 2(-4.4,0)
C_0201
  rect 0.381x0.356 smd: 1(0,0) 2(0.584,0)
C_0402
  rect 0.508x0.559 smd: 1(0,0) 2(0.914,0)
C_0603
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
C_0805
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
C_1206
  rect 1.016x1.778 smd: 1(0,0) 2(2.667,0)
C_1808
  rect 1.041x2.311 smd: 1(0,0) 2(4.35,0)
C_B2
  rect 1.346x2.692 smd: 1(0,0) 2(-2.75,0)
C_D
  rect 2.388x2.896 smd: 1(0,0) 2(6.1,0)
C_D2
  rect 2.388x2.794 smd: 1(0,0) 2(6.4,0)
C_D3
  rect 2.388x2.794 smd: 1(0,0) 2(6.4,0)
C_X
  rect 1.803x2.896 smd: 1(0,0) 2(6,0)
CCM_C070546HR015M29CZR_15P-T
  round 0.965 hole 0.711: 1(0,0) 2(-2.29,0) 3(-4.58,0) 4(-6.87,0) 5(-9.16,0) 6(1.145,0) 7(-1.145,0) 8(-3.435,0) 9(-5.725,0) 10(-8.015,0) 11(0,-1.4) 12(-2.29,-1.4) 13(-4.58,-1.4) 14(-6.87,-1.4) 15(-9.16,-1.4)
  oval 1.092x2.896 hole 0.787x2.591: 16(-14.63,0.1) 17(5.47,0.1)
CFL-H_BGA_1440P-T
  round 0.406 smd: A3(-1.254,0) A37(-26.054,0) B2(-0.66,0.66) B38(-26.628,0.553) BR1(0,40.062) BR38(-26.628,40.036) BT2(-0.571,40.628) BT37(-26.037,40.628) C1(0,1.267)
  round 0.381 smd: A4(-1.971,0) A34(-24.46,0) A36(-25.272,0) B3(-1.382,0.699) B37(-25.909,0.703) BN1(0,38.614) BN38(-26.628,38.599) BP1(0,39.338) BP38(-26.628,39.31) BR2(-0.719,39.934) BR37(-25.904,39.927) BT3(-1.295,40.628) BT4(-2.019,40.628) BT35(-24.498,40.628) BT36(-25.311,40.628) C2(-0.699,1.361) C38(-26.628,1.334) D1(0,1.991) D38(-26.628,2.097)
  round 0.356 smd: A5(-2.771,0) A33(-23.66,0) B4(-2.031,0.971) B36(-25.198,0.701) BM1(0,37.814) BM38(-26.628,37.888) BN2(-0.65,38.642) BN37(-25.965,38.665) BP2(-0.828,39.28) BP37(-25.689,39.257) BR3(-1.387,39.978) BR36(-25.193,39.971) BT5(-2.819,40.628) BT34(-23.698,40.628) C37(-25.908,1.402) D3(-1.233,1.822) E1(0,2.779) E2(-0.65,2.474) E38(-26.628,2.897)
  round 0.33 smd: A6(-3.546,0) A32(-22.872,0) B5(-2.743,0.65) B34(-24.443,0.67) BK1(0,37.037) BL2(-0.65,37.438) BL38(-26.628,37.176) BM2(-0.963,38.053) BM37(-25.978,37.986) BN3(-1.3,38.701) BN36(-25.314,38.638) BP3(-1.483,39.334) BP35(-24.561,39.328) BR5(-2.166,39.984) BR34(-23.774,39.978) BR35(-24.536,39.978) BT6(-3.594,40.628) BT32(-22.923,40.628) C36(-25.145,1.388) D4(-1.894,1.655) D37(-25.603,1.985) E3(-1.3,2.474) E37(-25.978,2.604) F2(-0.65,3.16) G1(0,3.581) G38(-26.628,3.671)
  round 0.305 smd: A8(-4.318,0) A9(-5.105,0) A10(-5.893,0) A11(-6.68,0) A12(-7.468,0) A13(-8.255,0) A14(-9.042,0) A15(-9.83,0) A16(-10.617,0) A17(-11.405,0) A18(-12.192,0) A19(-12.979,0) A20(-13.767,0) A21(-14.554,0) A22(-15.342,0) A23(-16.129,0) A24(-16.916,0) A25(-17.704,0) A26(-18.491,0) A27(-19.279,0) A28(-20.066,0) A29(-20.853,0) A30(-21.844,0) AA1(0,14.019) AA2(-0.65,14.019) AA3(-1.3,14.019) AA4(-1.951,14.019) AA5(-2.601,14.019) AA6(-3.251,13.968) AA7(-3.911,14.548) AA8(-4.561,14.548) AA9(-5.212,14.548) AA10(-5.862,14.548) AA11(-6.512,14.548) AA12(-7.162,14.548) AA13(-7.813,14.548) AA14(-8.463,14.548) AA29(-20.725,14.415) AA30(-21.376,14.415) AA31(-22.077,14.415) AA32(-22.727,14.415) AA33(-23.377,14.415) AA34(-24.027,14.415) AA35(-24.678,14.415) AA36(-25.328,14.415) AA37(-25.978,14.415) AA38(-26.628,14.415) AB1(0,14.756) AB2(-0.65,14.756) AB3(-1.3,14.756) AB4(-1.951,14.756) AB5(-2.601,14.756) AB6(-3.251,14.806) AB29(-20.725,15.203) AB30(-21.376,15.203) AB31(-22.077,15.203) AB32(-22.727,15.203) AB33(-23.377,15.203) AB34(-24.027,15.203) AB35(-24.678,15.203) AB36(-25.328,15.203) AB37(-25.978,15.203) AB38(-26.628,15.203) AC1(0,15.645) AC2(-0.65,15.645) AC3(-1.3,15.645) AC4(-1.951,15.645) AC5(-2.601,15.645) AC6(-3.251,15.645) AC7(-3.911,15.463) AC8(-4.561,15.463) AC9(-5.212,15.463) AC10(-5.862,15.463) AC11(-6.512,15.463) AC12(-7.162,15.463) AC13(-7.813,15.463) AC14(-8.463,15.463) AC29(-20.725,15.99) AC30(-21.376,15.99) AC31(-22.077,15.99) AC32(-22.727,15.99) AC33(-23.377,15.99) AC34(-24.027,15.99) AC35(-24.678,15.99) AC36(-25.328,15.99) AC37(-25.978,15.99) AC38(-26.628,15.99) AD1(0,16.534) AD2(-0.65,16.534) AD3(-1.3,16.534) AD4(-1.951,16.534) AD5(-2.601,16.534) AD6(-3.251,16.483) AD7(-3.911,16.377) AD8(-4.561,16.377) AD9(-5.212,16.377) AD10(-5.862,16.377) AD11(-6.512,16.377) AD12(-7.162,16.377) AD13(-7.813,16.377) AD14(-8.463,16.377) AD29(-20.725,16.777) AD30(-21.376,16.777) AD31(-22.077,16.777) AD32(-22.727,16.777) AD33(-23.377,16.777) AD34(-24.027,16.777) AD35(-24.678,16.777) AD36(-25.328,16.777) AD37(-25.978,16.777) AD38(-26.628,16.777) AE1(0,17.27) AE2(-0.65,17.27) AE3(-1.3,17.27) AE4(-1.951,17.27) AE5(-2.601,17.27) AE6(-3.251,17.321) AE7(-3.911,17.291) AE8(-4.561,17.291) AE9(-5.212,17.291) AE10(-5.862,17.291) AE11(-6.512,17.291) AE12(-7.162,17.291) AE13(-7.813,17.291) AE14(-8.463,17.291) AE29(-20.725,17.565) AE30(-21.376,17.565) AE31(-22.077,17.565) AE32(-22.727,17.565) AE33(-23.377,17.565) AE34(-24.027,17.565) AE35(-24.678,17.565) AE36(-25.328,17.565) AE37(-25.978,17.565) AE38(-26.628,17.565) AF1(0,18.159) AF2(-0.65,18.159) AF3(-1.3,18.159) AF4(-1.951,18.159) AF5(-2.601,18.159) AF6(-3.251,18.159) AF7(-3.911,18.206) AF8(-4.561,18.206) AF9(-5.212,18.206) AF10(-5.862,18.206) AF11(-6.512,18.206) AF12(-7.162,18.206) AF13(-7.813,18.206) AF14(-8.463,18.206) AF29(-20.725,18.352) AF30(-21.376,18.352) AF31(-22.077,18.352) AF32(-22.727,18.352) AF33(-23.377,18.352) AF34(-24.027,18.352) AF35(-24.678,18.352) AF36(-25.328,18.352) AF37(-25.978,18.352) AF38(-26.628,18.352) AG1(0,19.048) AG2(-0.65,19.048) AG3(-1.3,19.048) AG4(-1.951,19.048) AG5(-2.601,19.048) AG6(-3.251,18.997) AG7(-3.911,19.12) AG8(-4.561,19.12) AG9(-5.212,19.12) AG10(-5.862,19.12) AG11(-6.512,19.12) AG12(-7.162,19.12) AG13(-7.813,19.12) AG14(-8.463,19.12) AG29(-20.725,19.14) AG30(-21.376,19.14) AG31(-22.077,19.14) AG32(-22.727,19.14) AG33(-23.377,19.14) AG34(-24.027,19.14) AG35(-24.678,19.14) AG36(-25.328,19.14) AG37(-25.978,19.14) AG38(-26.628,19.14) AH1(0,19.785) AH2(-0.65,19.785) AH3(-1.3,19.785) AH4(-1.951,19.785) AH5(-2.601,19.785) AH6(-3.251,19.836) AH7(-3.911,20.035) AH8(-4.561,20.035) AH9(-5.212,20.035) AH10(-5.862,20.035) AH11(-6.512,20.035) AH12(-7.162,20.035) AH13(-7.813,20.035) AH14(-8.463,20.035) AH29(-20.725,19.927) AH30(-21.376,19.927) AH31(-22.077,19.927) AH32(-22.727,19.927) AH33(-23.377,19.927) AH34(-24.027,19.927) AH35(-24.678,19.927) AH36(-25.328,19.927) AH37(-25.978,19.927) AH38(-26.628,19.927) AJ1(0,20.674) AJ2(-0.65,20.674) AJ3(-1.3,20.674) AJ4(-1.951,20.674) AJ5(-2.601,20.674) AJ6(-3.251,20.674) AJ7(-3.911,20.949) AJ8(-4.561,20.949) AJ9(-5.212,20.949) AJ10(-5.862,20.949) AJ11(-6.512,20.949) AJ12(-7.162,20.949) AJ13(-7.813,20.949) AJ14(-8.463,20.949) AJ29(-20.725,20.714) AJ30(-21.376,20.714) AJ31(-22.077,20.714) AJ32(-22.727,20.714) AJ33(-23.377,20.714) AJ34(-24.027,20.714) AJ35(-24.678,20.714) AJ36(-25.328,20.714) AJ37(-25.978,20.714) AJ38(-26.628,20.714) AK1(0,21.563) AK2(-0.65,21.563) AK3(-1.3,21.563) AK4(-1.951,21.563) AK5(-2.601,21.563) AK6(-3.251,21.512) AK29(-20.725,21.502) AK30(-21.376,21.502) AK31(-22.077,21.502) AK32(-22.727,21.502) AK33(-23.377,21.502) AK34(-24.027,21.502) AK35(-24.678,21.502) AK36(-25.328,21.502) AK37(-25.978,21.502) AK38(-26.628,21.502) AL1(0,22.299) AL2(-0.65,22.299) AL3(-1.3,22.299) AL4(-1.951,22.299) AL5(-2.601,22.299) AL6(-3.251,22.35) AL7(-3.911,21.863) AL8(-4.561,21.863) AL9(-5.212,21.863) AL10(-5.862,21.863) AL11(-6.512,21.863) AL12(-7.162,21.863) AL13(-7.813,21.863) AL14(-8.463,21.863) AL29(-20.725,22.289) AL30(-21.376,22.289) AL31(-22.077,22.289) AL32(-22.727,22.289) AL33(-23.377,22.289) AL34(-24.027,22.289) AL35(-24.678,22.289) AL36(-25.328,22.289) AL37(-25.978,22.289) AL38(-26.628,22.289) AM1(0,23.188) AM2(-0.65,23.188) AM3(-1.3,23.188) AM4(-1.951,23.188) AM5(-2.601,23.188) AM6(-3.251,23.188) AM7(-3.911,22.778) AM8(-4.561,22.778) AM9(-5.212,22.778) AM10(-5.862,22.778) AM11(-6.512,22.778) AM12(-7.162,22.778) AM13(-7.813,22.778) AM14(-8.463,22.778) AM29(-20.725,23.077) AM30(-21.376,23.077) AM31(-22.077,23.077) AM32(-22.727,23.077) AM33(-23.377,23.077) AM34(-24.027,23.077) AM35(-24.678,23.077) AM36(-25.328,23.077) AM37(-25.978,23.077) AM38(-26.628,23.077) AN1(0,24.077) AN2(-0.65,24.077) AN3(-1.3,24.077) AN4(-1.951,24.077) AN5(-2.601,24.077) AN6(-3.251,24.027) AN7(-3.911,23.692) AN8(-4.561,23.692) AN9(-5.212,23.692) AN10(-5.862,23.692) AN11(-6.512,23.692) AN12(-7.162,23.692) AN13(-7.813,23.692) AN14(-8.463,23.692) AN29(-20.725,23.864) AN30(-21.376,23.864) AN31(-22.077,23.864) AN32(-22.727,23.864) AN33(-23.377,23.864) AN34(-24.027,23.864) AN35(-24.678,23.864) AN36(-25.328,23.864) AN37(-25.978,23.864) AN38(-26.628,23.864) AP1(0,24.814) AP2(-0.65,24.814) AP3(-1.3,24.814) AP4(-1.951,24.814) AP5(-2.601,24.814) AP6(-3.251,24.865) AP7(-3.911,24.607) AP8(-4.561,24.607) AP9(-5.212,24.607) AP10(-5.862,24.607) AP11(-6.512,24.607) AP12(-7.162,24.607) AP13(-7.813,24.607) AP14(-8.463,24.607) AP29(-20.725,24.651) AP30(-21.376,24.651) AP31(-22.077,24.651) AP32(-22.727,24.651) AP33(-23.377,24.651) AP34(-24.027,24.651) AP35(-24.678,24.651) AP36(-25.328,24.651) AP37(-25.978,24.651) AP38(-26.628,24.651) AR1(0,25.703) AR2(-0.65,25.703) AR3(-1.3,25.703) AR4(-1.951,25.703) AR5(-2.601,25.703) AR6(-3.251,25.703) AR7(-3.911,25.521) AR8(-4.561,25.521) AR9(-5.212,25.521) AR10(-5.862,25.521) AR11(-6.512,25.521) AR12(-7.162,25.521) AR13(-7.813,25.521) AR14(-8.463,25.521) AR29(-20.725,25.439) AR30(-21.376,25.439) AR31(-22.077,25.439) AR32(-22.727,25.439) AR33(-23.377,25.439) AR34(-24.027,25.439) AR35(-24.678,25.439) AR36(-25.328,25.439) AR37(-25.978,25.439) AR38(-26.628,25.439) AT1(0,26.592) AT2(-0.65,26.592) AT3(-1.3,26.592) AT4(-1.951,26.592) AT5(-2.601,26.592) AT6(-3.251,26.541) AT7(-3.911,26.435) AT8(-4.561,26.435) AT9(-5.212,26.435) AT10(-5.862,26.435) AT11(-6.512,26.435) AT12(-7.162,26.435) AT13(-7.813,26.435) AT14(-8.463,26.435) AT29(-20.725,26.226) AT30(-21.376,26.226) AT31(-22.077,26.226) AT32(-22.727,26.226) AT33(-23.377,26.226) AT34(-24.027,26.226) AT35(-24.678,26.226) AT36(-25.328,26.226) AT37(-25.978,26.226) AT38(-26.628,26.226) AU1(0,27.329) AU2(-0.65,27.329) AU3(-1.3,27.329) AU4(-1.951,27.329) AU5(-2.601,27.329) AU6(-3.251,27.379) AU7(-3.911,27.35) AU8(-4.561,27.35) AU9(-5.212,27.35) AU10(-5.862,27.35) AU11(-6.512,27.35) AU12(-7.162,27.35) AU13(-7.813,27.35) AU14(-8.463,27.35) AU29(-20.725,27.014) AU30(-21.376,27.014) AU31(-22.077,27.014) AU32(-22.727,27.014) AU33(-23.377,27.014) AU34(-24.027,27.014) AU35(-24.678,27.014) AU36(-25.328,27.014) AU37(-25.978,27.014) AU38(-26.628,27.014) AV29(-20.725,27.801) AV30(-21.376,27.801) AV31(-22.077,27.801) AV32(-22.727,27.801) AV33(-23.377,27.801) AV34(-24.027,27.801) AV35(-24.678,27.801) AV36(-25.328,27.801) AV37(-25.978,27.801) AV38(-26.628,27.801) AW1(0,28.218) AW2(-0.65,28.218) AW3(-1.3,28.218) AW4(-1.951,28.218) AW5(-2.601,28.218) AW6(-3.251,28.218) AW7(-3.911,28.264) AW8(-4.561,28.264) AW9(-5.212,28.264) AW10(-5.862,28.264) AW11(-6.512,28.264) AW12(-7.162,28.264) AW13(-7.813,28.264) AW14(-8.463,28.264) AW29(-20.725,28.588) AW30(-21.376,28.588) AW31(-22.077,28.588) AW32(-22.727,28.588) AW33(-23.377,28.588) AW34(-24.027,28.588) AW35(-24.678,28.588) AW36(-25.328,28.588) AW37(-25.978,28.588) AW38(-26.628,28.588) AY1(0,29.107) AY2(-0.65,29.107) AY3(-1.3,29.107) AY4(-1.951,29.107) AY5(-2.601,29.107) AY6(-3.251,29.056) AY7(-3.911,29.179) AY8(-4.561,29.179) AY9(-5.212,29.179) AY10(-5.862,29.179) AY11(-6.512,29.179) AY12(-7.162,29.179) AY13(-7.813,29.179) AY14(-8.463,29.179) AY29(-20.725,29.376) AY30(-21.376,29.376) AY31(-22.077,29.376) AY32(-22.727,29.376) AY33(-23.377,29.376) AY34(-24.027,29.376) AY35(-24.678,29.376) AY36(-25.328,29.376) AY37(-25.978,29.376) AY38(-26.628,29.376) B6(-3.531,0.65) B8(-4.318,0.65) B9(-5.105,0.65) B10(-5.893,0.65) B11(-6.68,0.65) B12(-7.468,0.65) B13(-8.255,0.65) B14(-9.042,0.65) B15(-9.83,0.65) B16(-10.617,0.65) B17(-11.405,0.65) B18(-12.192,0.65) B19(-12.979,0.65) B20(-13.767,0.65) B21(-14.554,0.65) B22(-15.342,0.65) B23(-16.129,0.65) B24(-16.916,0.65) B25(-17.704,0.65) B26(-18.491,0.65) B27(-19.279,0.65) B28(-20.066,0.65) B29(-20.853,0.65) B30(-21.641,0.65) B31(-22.428,0.65) B33(-23.216,0.65) BA1(0,29.843) BA2(-0.65,29.843) BA3(-1.3,29.843) BA4(-1.951,29.843) BA5(-2.601,29.843) BA6(-3.251,29.894) BA7(-3.911,30.093) BA8(-4.561,30.093) BA9(-5.212,30.093) BA10(-5.862,30.093) BA11(-6.512,30.093) BA12(-7.162,30.093) BA13(-7.813,30.093) BA14(-8.463,30.093) BA29(-20.725,30.163) BA30(-21.376,30.163) BA31(-22.077,30.163) BA32(-22.727,30.163) BA33(-23.377,30.163) BA34(-24.027,30.163) BA35(-24.678,30.163) BA36(-25.328,30.163) BA37(-25.978,30.163) BA38(-26.628,30.163) BB1(0,30.732) BB2(-0.65,30.732) BB3(-1.3,30.732) BB4(-1.951,30.732) BB5(-2.601,30.732) BB6(-3.251,30.732) BB7(-3.911,31.007) BB8(-4.561,31.007) BB9(-5.212,31.007) BB10(-5.862,31.007) BB11(-6.512,31.007) BB12(-7.162,31.007) BB13(-7.813,31.007) BB14(-8.463,31.007) BB29(-20.725,30.951) BB30(-21.376,30.951) BB31(-22.077,30.951) BB32(-22.727,30.951) BB33(-23.377,30.951) BB34(-24.027,30.951) BB35(-24.678,30.951) BB36(-25.328,30.951) BB37(-25.978,30.951) BB38(-26.628,30.951) BC1(0,31.621) BC2(-0.65,31.621) BC3(-1.3,31.621) BC4(-1.951,31.621) BC5(-2.601,31.621) BC6(-3.251,31.57) BC7(-3.911,31.922) BC8(-4.561,31.922) BC9(-5.212,31.922) BC10(-5.862,31.922) BC11(-6.512,31.922) BC12(-7.162,31.922) BC13(-7.813,31.922) BC14(-8.463,31.922) BC29(-20.725,31.738) BC30(-21.376,31.738) BC31(-22.077,31.738) BC32(-22.727,31.738) BC33(-23.377,31.738) BC34(-24.027,31.738) BC35(-24.678,31.738) BC36(-25.328,31.738) BC37(-25.978,31.738) BC38(-26.628,31.738) BD1(0,32.358) BD2(-0.65,32.358) BD3(-1.3,32.358) BD4(-1.951,32.358) BD5(-2.601,32.358) BD6(-3.251,32.409) BD7(-3.911,32.836) BD8(-4.561,32.836) BD9(-5.212,32.836) BD10(-5.862,32.836) BD11(-6.512,32.836) BD12(-7.162,32.836) BD13(-7.813,32.836) BD14(-8.463,32.836) BD29(-20.725,32.525) BD30(-21.376,32.525) BD31(-22.077,32.525) BD32(-22.727,32.525) BD33(-23.377,32.525) BD34(-24.027,32.525) BD35(-24.678,32.525) BD36(-25.328,32.525) BD37(-25.978,32.525) BD38(-26.628,32.525) BE1(0,33.247) BE2(-0.65,33.247) BE3(-1.3,33.247) BE4(-1.951,33.247) BE5(-2.601,33.247) BE6(-3.251,33.247) BE29(-20.725,33.313) BE30(-21.376,33.313) BE31(-22.077,33.313) BE32(-22.727,33.313) BE33(-23.377,33.313) BE34(-24.027,33.313) BE35(-24.678,33.313) BE36(-25.328,33.313) BE37(-25.978,33.313) BE38(-26.628,33.313) BF1(0,34.136) BF2(-0.65,34.136) BF3(-1.3,34.136) BF4(-1.951,34.136) BF5(-2.601,34.136) BF6(-3.251,34.085) BF7(-3.911,33.751) BF8(-4.561,33.751) BF9(-5.212,33.751) BF10(-5.862,33.751) BF11(-6.512,33.751) BF12(-7.162,33.751) BF13(-7.813,33.751) BF14(-8.463,33.751) BF29(-20.725,34.1) BF30(-21.376,34.1) BF31(-22.077,34.1) BF32(-22.727,34.1) BF33(-23.377,34.1) BF34(-24.027,34.1) BF35(-24.678,34.1) BF36(-25.328,34.1) BF37(-25.978,34.1) BF38(-26.628,34.1) BG1(0,34.872) BG2(-0.65,34.872) BG3(-1.3,34.872) BG4(-1.951,34.872) BG5(-2.601,34.872) BG6(-3.251,34.923) BG7(-3.911,34.665) BG8(-4.561,34.665) BG9(-5.212,34.665) BG10(-5.862,34.665) BG11(-6.512,34.665) BG12(-7.162,34.665) BG13(-7.813,34.665) BG14(-8.463,34.665) BG29(-20.725,34.888) BG30(-21.376,34.888) BG31(-22.077,34.888) BG32(-22.727,34.888) BG33(-23.377,34.888) BG34(-24.027,34.888) BG35(-24.678,34.888) BG36(-25.328,34.888) BG37(-25.978,34.888) BG38(-26.628,34.888) BH1(0,36.015) BH2(-0.65,35.761) BH3(-1.3,35.761) BH4(-1.951,35.761) BH5(-2.601,35.761) BH6(-3.251,35.761) BH7(-3.911,35.579) BH8(-4.561,35.579) BH9(-5.212,35.579) BH10(-5.862,35.579) BH11(-6.512,35.579) BH12(-7.162,35.579) BH13(-7.813,35.579) BH14(-8.463,35.541) BH29(-20.725,35.548) BH30(-21.376,35.675) BH31(-22.077,35.675) BH32(-22.727,35.675) BH33(-23.377,35.675) BH34(-24.027,35.675) BH35(-24.678,35.675) BH36(-25.328,35.675) BH37(-25.978,35.675) BH38(-26.628,35.675) BJ7(-3.911,36.494) BJ8(-4.561,36.494) BJ9(-5.212,36.494) BJ10(-5.862,36.494) BJ11(-6.512,36.494) BJ12(-7.282,36.405) BJ13(-8.171,36.126) BJ14(-8.851,36.077) BJ15(-9.601,36.077) BJ16(-10.388,36.077) BJ17(-11.175,36.077) BJ18(-11.963,36.077) BJ19(-12.75,36.077) BJ20(-13.538,36.077) BJ21(-14.325,36.077) BJ22(-15.112,36.077) BJ23(-15.9,36.077) BJ24(-16.687,36.077) BJ25(-17.475,36.077) BJ26(-18.262,36.077) BJ27(-19.049,36.077) BJ28(-19.837,36.077) BJ29(-20.497,36.158) BJ30(-21.353,36.329) BJ31(-22.077,36.462) BJ32(-22.727,36.462) BJ33(-23.377,36.462) BJ34(-24.027,36.462) BJ35(-24.678,36.462) BJ36(-25.328,36.462) BJ37(-25.978,36.462) BJ38(-26.628,36.412) BK2(-0.65,36.6) BK3(-1.3,36.6) BK4(-1.951,36.6) BK5(-2.601,36.6) BK6(-3.251,36.6) BK13(-7.899,36.727) BK14(-8.813,36.727) BK15(-9.601,36.727) BK16(-10.388,36.727) BK17(-11.175,36.727) BK18(-11.963,36.727) BK19(-12.75,36.727) BK20(-13.538,36.727) BK21(-14.325,36.727) BK22(-15.112,36.727) BK23(-15.9,36.727) BK24(-16.687,36.727) BK25(-17.475,36.727) BK26(-18.262,36.727) BK27(-19.049,36.727) BK28(-19.837,36.727) BK29(-20.833,36.735) BL3(-1.3,37.387) BL4(-1.951,37.387) BL5(-2.601,37.387) BL6(-3.251,37.438) BL7(-3.987,37.383) BL8(-4.876,37.377) BL9(-5.664,37.377) BL11(-6.451,37.377) BL12(-7.238,37.377) BL13(-8.026,37.377) BL14(-8.813,37.377) BL15(-9.601,37.377) BL16(-10.388,37.377) BL17(-11.175,37.377) BL18(-11.963,37.377) BL19(-12.75,37.377) BL20(-13.538,37.377) BL21(-14.325,37.377) BL22(-15.112,37.377) BL23(-15.9,37.377) BL24(-16.687,37.377) BL25(-17.475,37.377) BL26(-18.262,37.377) BL27(-19.049,37.377) BL28(-19.837,37.377) BL29(-20.624,37.377) BL30(-21.426,37.25) BL31(-22.077,37.25) BL32(-22.727,37.25) BL33(-23.377,37.25) BL34(-24.027,37.25) BL35(-24.678,37.25) BL36(-25.328,37.25) BL37(-25.978,37.25) BM3(-1.613,38.129) BM5(-2.525,38.129) BM6(-3.169,38.231) BM7(-4.089,38.027) BM8(-4.876,38.027) BM9(-5.664,38.027) BM11(-6.451,38.027) BM12(-7.238,38.027) BM13(-8.026,38.027) BM14(-8.813,38.027) BM15(-9.601,38.027) BM16(-10.388,38.027) BM17(-11.175,38.027) BM18(-11.963,38.027) BM19(-12.75,38.027) BM20(-13.538,38.027) BM21(-14.325,38.027) BM22(-15.112,38.027) BM23(-15.9,38.027) BM24(-16.687,38.027) BM25(-17.475,38.027) BM26(-18.262,38.027) BM27(-19.049,38.027) BM28(-19.837,38.027) BM29(-20.624,38.027) BM30(-21.412,38.027) BM31(-22.199,38.027) BM33(-22.986,38.027) BM34(-23.774,38.027) BM35(-24.561,38.027) BM36(-25.328,37.986) BN4(-2.106,38.629) BN5(-2.748,38.793) BN7(-4.089,38.678) BN8(-4.876,38.678) BN9(-5.664,38.678) BN11(-6.451,38.678) BN12(-7.238,38.678) BN13(-8.026,38.678) BN14(-8.813,38.678) BN15(-9.601,38.678) BN16(-10.388,38.678) BN17(-11.175,38.678) BN18(-11.963,38.678) BN19(-12.75,38.678) BN20(-13.538,38.678) BN21(-14.325,38.678) BN22(-15.112,38.678) BN23(-15.9,38.678) BN24(-16.687,38.678) BN25(-17.475,38.678) BN26(-18.262,38.678) BN27(-19.049,38.678) BN28(-19.837,38.678) BN29(-20.624,38.678) BN30(-21.412,38.678) BN31(-22.199,38.678) BN33(-22.986,38.678) BN34(-23.774,38.678) BN35(-24.562,38.678) BP5(-2.374,39.351) BP6(-3.294,39.288) BP7(-4.089,39.328) BP8(-4.876,39.328) BP9(-5.664,39.328) BP11(-6.451,39.328) BP12(-7.238,39.328) BP13(-8.026,39.328) BP14(-8.813,39.328) BP15(-9.601,39.328) BP16(-10.388,39.328) BP17(-11.175,39.328) BP18(-11.963,39.328) BP19(-12.75,39.328) BP20(-13.538,39.328) BP21(-14.325,39.328) BP22(-15.112,39.328) BP23(-15.9,39.328) BP24(-16.687,39.328) BP25(-17.475,39.328) BP26(-18.262,39.328) BP27(-19.049,39.328) BP28(-19.837,39.328) BP29(-20.624,39.328) BP30(-21.412,39.328) BP31(-22.199,39.328) BP33(-22.986,39.328) BP34(-23.774,39.328) BR6(-3.192,39.961) BR7(-4.089,39.978) BR8(-4.876,39.978) BR9(-5.664,39.978) BR11(-6.451,39.978) BR12(-7.238,39.978) BR13(-8.026,39.978) BR14(-8.813,39.978) BR15(-9.601,39.978) BR16(-10.388,39.978) BR17(-11.175,39.978) BR18(-11.963,39.978) BR19(-12.75,39.978) BR20(-13.538,39.978) BR21(-14.325,39.978) BR22(-15.112,39.978) BR23(-15.9,39.978) BR24(-16.687,39.978) BR25(-17.475,39.978) BR26(-18.262,39.978) BR27(-19.049,39.978) BR28(-19.837,39.978) BR29(-20.624,39.978) BR30(-21.412,39.978) BR31(-22.199,39.978) BR33(-22.986,39.978) BT8(-4.648,40.628) BT9(-5.664,40.628) BT11(-6.451,40.628) BT12(-7.238,40.628) BT13(-8.026,40.628) BT14(-8.813,40.628) BT15(-9.601,40.628) BT16(-10.388,40.628) BT17(-11.175,40.628) BT18(-11.963,40.628) BT19(-12.75,40.628) BT20(-13.538,40.628) BT21(-14.325,40.628) BT22(-15.112,40.628) BT23(-15.9,40.628) BT24(-16.687,40.628) BT25(-17.475,40.628) BT26(-18.262,40.628) BT27(-19.049,40.628) BT28(-19.837,40.628) BT29(-20.624,40.628) BT30(-21.412,40.628) BT31(-22.174,40.628) C5(-2.743,1.3) C6(-3.531,1.3) C8(-4.318,1.3) C9(-5.105,1.3) C10(-5.893,1.3) C11(-6.68,1.3) C12(-7.468,1.3) C13(-8.255,1.3) C14(-9.042,1.3) C15(-9.83,1.3) C16(-10.617,1.3) C17(-11.405,1.3) C18(-12.192,1.3) C19(-12.979,1.3) C20(-13.767,1.3) C21(-14.554,1.3) C22(-15.342,1.3) C23(-16.129,1.3) C24(-16.916,1.3) C25(-17.704,1.3) C26(-18.491,1.3) C27(-19.279,1.3) C28(-20.066,1.3) C29(-20.853,1.3) C30(-21.641,1.3) C31(-22.428,1.3) C33(-23.216,1.3) C34(-24.011,1.29) D5(-2.743,1.951) D6(-3.531,1.951) D8(-4.318,1.951) D9(-5.105,1.951) D10(-5.893,1.951) D11(-6.68,1.951) D12(-7.468,1.951) D13(-8.255,1.951) D14(-9.042,1.951) D15(-9.83,1.951) D16(-10.617,1.951) D17(-11.405,1.951) D18(-12.192,1.951) D19(-12.979,1.951) D20(-13.767,1.951) D21(-14.554,1.951) D22(-15.342,1.951) D23(-16.129,1.951) D24(-16.916,1.951) D25(-17.704,1.951) D26(-18.491,1.951) D27(-19.279,1.951) D28(-20.066,1.951) D29(-20.853,1.951) D30(-21.641,1.951) D31(-22.428,1.951) D33(-23.216,1.951) D34(-24.003,1.951) D35(-24.655,1.861) E4(-1.951,2.575) E5(-2.743,2.601) E6(-3.531,2.601) E8(-4.318,2.601) E9(-5.105,2.601) E10(-5.893,2.601) E11(-6.68,2.601) E12(-7.468,2.601) E13(-8.255,2.601) E14(-9.042,2.601) E15(-9.83,2.601) E16(-10.617,2.601) E17(-11.405,2.601) E18(-12.192,2.601) E19(-12.979,2.601) E20(-13.767,2.601) E21(-14.554,2.601) E22(-15.342,2.601) E23(-16.129,2.601) E24(-16.916,2.601) E25(-17.704,2.601) E26(-18.491,2.601) E27(-19.279,2.601) E28(-20.066,2.601) E29(-20.853,2.601) E30(-21.641,2.601) E31(-22.428,2.601) E33(-23.216,2.601) E34(-24.003,2.601) E35(-24.678,2.604) E36(-25.328,2.604) F3(-1.3,3.16) F4(-1.951,3.261) F5(-2.743,3.273) F6(-3.531,3.273) F8(-4.318,3.251) F9(-5.105,3.251) F10(-5.893,3.251) F11(-6.68,3.251) F12(-7.468,3.251) F13(-8.255,3.251) F14(-9.042,3.251) F15(-9.83,3.251) F16(-10.617,3.251) F17(-11.405,3.251) F18(-12.192,3.251) F19(-12.979,3.251) F20(-13.767,3.251) F21(-14.554,3.251) F22(-15.342,3.251) F23(-16.129,3.251) F24(-16.916,3.251) F25(-17.704,3.251) F26(-18.491,3.251) F27(-19.279,3.251) F28(-20.066,3.251) F29(-20.853,3.251) F30(-21.641,3.251) F31(-22.428,3.251) F33(-23.216,3.251) F34(-24.027,3.392) F35(-24.678,3.392) F36(-25.328,3.392) F37(-25.978,3.392) G2(-0.65,3.947) G3(-1.3,3.947) G4(-1.951,3.947) G5(-2.601,3.947) G6(-3.251,3.947) G8(-4.318,3.901) G9(-5.105,3.901) G10(-5.893,3.901) G11(-6.68,3.901) G12(-7.468,3.901) G13(-8.255,3.901) G14(-9.042,3.901) G15(-9.83,3.901) G16(-10.617,3.901) G17(-11.405,3.901) G18(-12.192,3.901) G19(-12.979,3.901) G20(-13.767,3.901) G21(-14.554,3.901) G22(-15.342,3.901) G23(-16.129,3.901) G24(-16.916,3.901) G25(-17.704,3.901) G26(-18.491,3.901) G27(-19.279,3.901) G28(-20.066,3.901) G29(-20.853,3.901) G30(-21.641,3.901) H1(0,4.443) H11(-6.68,4.552) H12(-7.468,4.552) H13(-8.255,4.602) H14(-9.042,4.602) H15(-9.83,4.602) H16(-10.617,4.602) H17(-11.405,4.602) H18(-12.192,4.602) H19(-12.979,4.602) H20(-13.767,4.602) H21(-14.554,4.602) H22(-15.342,4.602) H23(-16.129,4.602) H24(-16.916,4.602) H25(-17.704,4.602) H26(-18.491,4.602) H27(-19.279,4.602) H28(-20.066,4.602) H29(-20.853,4.552) H30(-21.603,4.552) H32(-22.727,4.179) H33(-23.377,4.179) H34(-24.027,4.179) H35(-24.678,4.179) H36(-25.328,4.179) H37(-25.978,4.179) J2(-0.65,4.748) J3(-1.3,4.748) J4(-1.951,4.748) J5(-2.601,4.748) J6(-3.251,4.748) J7(-3.893,4.619) J8(-4.541,4.716) J9(-5.212,4.693) J10(-5.893,4.628) J14(-9.042,5.253) J15(-9.83,5.253) J16(-10.617,5.253) J17(-11.405,5.253) J18(-12.192,5.253) J19(-12.979,5.253) J20(-13.767,5.253) J21(-14.554,5.253) J22(-15.342,5.253) J23(-16.129,5.253) J24(-16.916,5.253) J25(-17.704,5.253) J26(-18.491,5.253) J27(-19.279,5.253) J28(-20.066,5.253) J30(-21.061,5.168) J31(-22.077,5.005) J32(-22.727,4.966) J33(-23.377,4.966) J34(-24.027,4.966) J35(-24.678,4.966) J36(-25.328,4.966) J37(-25.978,4.966) J38(-26.628,4.712) K1(0,5.586) K2(-0.65,5.586) K3(-1.3,5.586) K4(-1.951,5.586) K5(-2.601,5.586) K6(-3.251,5.586) K7(-3.911,5.557) K8(-4.561,5.48) K9(-5.212,5.48) K10(-5.862,5.48) K11(-6.512,5.48) K12(-7.162,5.48) K13(-7.879,5.176) K14(-8.463,5.658) K29(-20.725,5.754) K30(-21.376,5.754) K31(-22.077,5.754) K32(-22.727,5.754) K33(-23.377,5.754) K34(-24.027,5.754) K35(-24.678,5.754) K36(-25.328,5.754) K37(-25.978,5.754) K38(-26.628,5.754) L1(0,6.475) L2(-0.65,6.475) L3(-1.3,6.475) L4(-1.951,6.475) L5(-2.601,6.475) L6(-3.251,6.424) L7(-3.911,6.395) L8(-4.561,6.344) L9(-5.212,6.319) L10(-5.862,6.319) L11(-6.512,6.319) L12(-7.162,6.319) L13(-7.813,6.319) L14(-8.463,6.319) L29(-20.725,6.541) L30(-21.376,6.541) L31(-22.077,6.541) L32(-22.727,6.541) L33(-23.377,6.541) L34(-24.027,6.541) L35(-24.678,6.541) L36(-25.328,6.541) L37(-25.978,6.541) L38(-26.628,6.541) M1(0,7.212) M2(-0.65,7.212) M3(-1.3,7.212) M4(-1.951,7.212) M5(-2.601,7.212) M6(-3.251,7.263) M7(-3.911,7.233) M8(-4.561,7.233) M9(-5.212,7.233) M10(-5.862,7.233) M11(-6.512,7.233) M12(-7.162,7.233) M13(-7.813,7.233) M14(-8.463,7.233) M29(-20.725,7.329) M30(-21.376,7.329) M31(-22.077,7.329) M32(-22.727,7.329) M33(-23.377,7.329) M34(-24.027,7.329) M35(-24.678,7.329) M36(-25.328,7.329) M37(-25.978,7.329) M38(-26.628,7.329) N1(0,8.101) N2(-0.65,8.101) N3(-1.3,8.101) N4(-1.951,8.101) N5(-2.601,8.101) N6(-3.251,8.101) N7(-3.911,8.147) N8(-4.561,8.147) N9(-5.212,8.147) N10(-5.862,8.147) N11(-6.512,8.147) N12(-7.162,8.147) N13(-7.813,8.147) N14(-8.463,8.147) N29(-20.725,8.116) N30(-21.376,8.116) N31(-22.077,8.116) N32(-22.727,8.116) N33(-23.377,8.116) N34(-24.027,8.116) N35(-24.678,8.116) N36(-25.328,8.116) N37(-25.978,8.116) N38(-26.628,8.116) P1(0,8.99) P2(-0.65,8.99) P3(-1.3,8.99) P4(-1.951,8.99) P5(-2.601,8.99) P6(-3.251,8.939) P7(-3.911,9.062) P8(-4.561,9.062) P9(-5.212,9.062) P10(-5.862,9.062) P11(-6.512,9.062) P12(-7.162,9.062) P13(-7.813,9.062) P14(-8.463,9.062) P29(-20.725,8.903) P30(-21.376,8.903) P31(-22.077,8.903) P32(-22.727,8.903) P33(-23.377,8.903) P34(-24.027,8.903) P35(-24.678,8.903) P36(-25.328,8.903) P37(-25.978,8.903) P38(-26.628,8.903) R1(0,9.726) R2(-0.65,9.726) R3(-1.3,9.726) R4(-1.951,9.726) R5(-2.601,9.726) R6(-3.251,9.777) R7(-3.911,9.976) R8(-4.561,9.976) R9(-5.212,9.976) R10(-5.862,9.976) R11(-6.512,9.976) R12(-7.162,9.976) R13(-7.813,9.976) R14(-8.463,9.976) R29(-20.725,9.691) R30(-21.376,9.691) R31(-22.077,9.691) R32(-22.727,9.691) R33(-23.377,9.691) R34(-24.027,9.691) R35(-24.678,9.691) R36(-25.328,9.691) R37(-25.978,9.691) R38(-26.628,9.691) T1(0,10.615) T2(-0.65,10.615) T3(-1.3,10.615) T4(-1.951,10.615) T5(-2.601,10.615) T6(-3.251,10.615) T7(-3.911,10.891) T8(-4.561,10.891) T9(-5.212,10.891) T10(-5.862,10.891) T11(-6.512,10.891) T12(-7.162,10.891) T13(-7.813,10.891) T14(-8.463,10.891) T29(-20.725,10.478) T30(-21.376,10.478) T31(-22.077,10.478) T32(-22.727,10.478) T33(-23.377,10.478) T34(-24.027,10.478) T35(-24.678,10.478) T36(-25.328,10.478) T37(-25.978,10.478) T38(-26.628,10.478) U1(0,11.504) U2(-0.65,11.504) U3(-1.3,11.504) U4(-1.951,11.504) U5(-2.601,11.504) U6(-3.251,11.454) U29(-20.725,11.266) U30(-21.376,11.266) U31(-22.077,11.266) U32(-22.727,11.266) U33(-23.377,11.266) U34(-24.027,11.266) U35(-24.678,11.266) U36(-25.328,11.266) U37(-25.978,11.266) U38(-26.628,11.266) V1(0,12.241) V2(-0.65,12.241) V3(-1.3,12.241) V4(-1.951,12.241) V5(-2.601,12.241) V6(-3.251,12.292) V7(-3.911,11.805) V8(-4.561,11.805) V9(-5.212,11.805) V10(-5.862,11.805) V11(-6.512,11.805) V12(-7.162,11.805) V13(-7.813,11.805) V14(-8.463,11.805) V29(-20.725,12.053) V30(-21.376,12.053) V31(-22.077,12.053) V32(-22.727,12.053) V33(-23.377,12.053) V34(-24.027,12.053) V35(-24.678,12.053) V36(-25.328,12.053) V37(-25.978,12.053) V38(-26.628,12.053) W1(0,13.13) W2(-0.65,13.13) W3(-1.3,13.13) W4(-1.951,13.13) W5(-2.601,13.13) W6(-3.251,13.13) W7(-3.911,12.719) W8(-4.561,12.719) W9(-5.212,12.719) W10(-5.862,12.719) W11(-6.512,12.719) W12(-7.162,12.719) W13(-7.813,12.719) W14(-8.463,12.719) W29(-20.725,12.84) W30(-21.376,12.84) W31(-22.077,12.84) W32(-22.727,12.84) W33(-23.377,12.84) W34(-24.027,12.84) W35(-24.678,12.84) W36(-25.328,12.84) W37(-25.978,12.84) W38(-26.628,12.84) Y7(-3.911,13.634) Y8(-4.561,13.634) Y9(-5.212,13.634) Y10(-5.862,13.634) Y11(-6.512,13.634) Y12(-7.162,13.634) Y13(-7.813,13.634) Y14(-8.463,13.634) Y29(-20.725,13.628) Y30(-21.376,13.628) Y31(-22.077,13.628) Y32(-22.727,13.628) Y33(-23.377,13.628) Y34(-24.027,13.628) Y35(-24.678,13.628) Y36(-25.328,13.628) Y37(-25.978,13.628) Y38(-26.628,13.628)
