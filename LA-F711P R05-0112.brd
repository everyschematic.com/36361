# Allegro board LA-F711P R05-0112.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+3.3V_VDD_PIC on BOTTOM (solid shape): 27.7,101.93 28.05,101.52 28.4,101.93 31.86,101.93 32.04,101.75 32.04,101.32 31.69,100.97 30.7,100.97 30.4,100.67 30.4,100.44 30.34,100.38 28.71,100.38 28.6,100.49 27.85,100.49 27.73,100.38 26.81,100.38 26.29,100.9 26.29,101.37 26.69,101.77 27.04,101.77 27.24,101.77 27.39,101.89 27.41,101.93
+3.3V_VDD_PIC on IN3 (solid shape): 27.99,100.89 27.99,100.53 27.81,100.35 25.57,100.35 24.35,99.14 24.35,97.08 24.96,96.47 24.96,96.39 24.76,96.19 24.08,96.19 23.19,97.08 23.19,99.16 25.19,101.17 27.71,101.17
+3.3V_VDD_PIC_PDA on TOP (solid shape): outline of 195 points within 25.37,84.76 29.27,90.32
+3.3V_WLAN on TOP (solid shape): 304.82,41.86 304.82,39.6 303.86,38.63 302.81,38.63 302.56,38.89 302.56,40.54 303.2,41.17 303.2,42.14 303.32,42.27 304.42,42.27
+3.3V_WLAN on BOTTOM (solid shape): 304.82,41.64 304.82,37.54 304.68,37.4 303.29,37.4 303.07,37.62 303,37.62 302.94,37.63 302.89,37.64 301.64,37.64 301.59,37.64 301.54,37.62 301.42,37.74 301.42,38.76 302.08,39.42 302.3,39.52 302.41,39.75 303.07,40.41 303.07,42 303.08,42 303.27,42.19 304.28,42.19
+3.3V_WLAN on TOP: 298.46,13.96 295.39,10.89 295.39,10.42 294.65,9.68 293.08,9.68 293.01,9.61 292.16,9.61 292.16,10.13 291.66,10.13 291.66,9.68 291.36,9.68 291.36,10.13 290.86,10.13 290.86,9.68 290.48,9.68 290.48,11.12 290.5,11.15 290.55,11.18 290.6,11.17 290.63,11.16 291.06,11.25 291.08,11.68 291.87,12.47 291.87,16.24 293.21,17.59 296.53,17.59 296.84,17.9 296.84,19.29 296.82,19.32 296.82,20.05 297.03,20.26 298.29,20.26 298.46,20.09
+3.3V_WLAN on BOTTOM: 297.05,18.29 297.05,20.58 298.57,22.1 300.53,22.1 301.39,21.25 301.44,21.16 301.53,21.1 301.63,21.01 305.38,21.01 305.85,20.53 305.85,19.74 306.13,19.46 306.13,17.95 305.99,17.8 304.45,17.8 304.12,18.14 303.39,18.14 302.88,17.63 297.71,17.63
+3.3V_WLAN_UZ4 on TOP (solid shape): 289.53,9.48 294.79,9.48 295.19,9.07 295.19,7.52 295,7.33 294.24,7.33 294.13,7.21 291.96,7.21 291.78,7.28 291.6,7.21 287.47,7.21 287.42,7.26 287.42,8.08 288.03,8.69 288.03,9.65 288.11,9.73 289.28,9.73
+3.3V_WWAN on TOP (solid shape): 309.7,65.4 309.78,65.4 309.83,65.38 309.87,65.37 310.35,65.37 310.35,65.04 310.35,65 310.37,64.95 310.37,64.85 311.08,64.85 311.08,64.95 311.1,65 311.1,65.04 311.1,65.37 311.55,65.37 311.55,65.04 311.55,65 311.57,64.95 311.57,64.85 312.28,64.85 312.28,64.95 312.3,65 312.3,65.04 312.3,65.37 312.91,65.37 312.93,65.4 313.46,65.4 313.93,64.92 313.93,63.21 313.55,62.83 308.26,62.83 307.9,63.19 307.9,65.01 308.06,65.17 308.92,65.17 309.19,65.43 309.7,65.43
+3.3V_WWAN on BOTTOM (solid shape): outline of 883 points within 309.65,57.3 348.66,70.64
+3.3V_WWAN on BOTTOM: 356.68,49.4 358.21,49.4 358.33,49.52 358.33,50.9 358.21,51.02 356.99,51.02 356.62,50.65 356.62,49.45
+3.3V_WWAN on IN1: 356.76,51.84 362.95,51.84 363.72,51.07 363.72,49.42 363.11,48.81 356.71,48.81 355.91,49.61 355.91,50.99
+3.3V_WWAN_UZ2 on TOP (solid shape): 313.44,69.72 313.44,69.64 313.38,69.58 312.78,69.58 312.78,69.43 313.37,69.43 313.44,69.35 313.44,66.09 312.85,65.5 312.17,65.5 312.17,65.04 312.16,65 312.12,64.99 311.73,64.99 311.69,65 311.68,65.04 311.68,65.5 310.97,65.5 310.97,65.04 310.96,65 310.92,64.99 310.53,64.99 310.49,65 310.48,65.04 310.48,65.5 309.87,65.5 309.84,65.52 309.82,65.55 309.82,67.51 310.24,67.92 310.92,67.92 311.11,68.11 311.11,69.78 311.12,69.79 311.81,69.79 311.81,69.8 311.84,69.83 313.33,69.83
+5V_ALW on TOP (solid shape): 263.95,6.63 263.95,5.36 263.83,5.23 263.04,5.23 262.57,4.76 261.25,4.76 261.1,4.91 261.1,6.54 261.31,6.76 263.83,6.76
+5V_ALW on TOP (solid shape): 286.08,5.87 286.08,4.98 286,4.9 286,4.54 285.7,4.25 282.97,4.25 282.8,4.42 282.8,5.69 283.01,5.9 286.04,5.9
+5V_ALW on TOP (solid shape): 78.23,101.55 78.23,101.35 78.23,101.35 78.23,100.59 77.96,100.32 77.69,100.32 77.66,100.29 77.66,99.05 77.59,98.98 76.09,98.98 75.98,99.09 75.98,99.37 76.15,99.54 76.58,99.54 76.7,99.66 76.7,100.85 76.76,100.91 77.59,100.91 77.65,100.97 77.65,101.29 77.65,101.47 77.85,101.67 78.12,101.67
+5V_ALW on TOP (solid shape): 346.63,71.02 346.63,62.25 345.61,61.24 343.26,61.24 342.4,60.38 341.03,60.38 340.61,59.96 332.93,59.96 332.01,60.88 332.01,61 330.78,62.23 330.78,64.94 332.85,67.02 332.85,68.54 333.55,69.24 335.69,69.24 335.78,69.15 335.91,69.11 336.06,68.96 336.06,68 336.42,67.63 338.6,67.63 338.82,67.86 339.61,67.86 339.63,67.83 339.63,66.46 339.74,66.36 339.74,65.77 339.62,65.64 339.01,65.64 339,65.65 338.92,65.65 338.84,65.57 337.91,65.57 337.61,65.27 334.95,65.27 333.6,63.92 333.6,63.16 334.48,62.28 338.64,62.28 339.76,63.4 341.3,63.4 342.18,64.29 344.22,64.29 344.6,64.67 344.6,68.6 344.09,69.11 344.07,69.11 343.85,69.22 343.63,69.11 341.3,69.11 341.3,69.75 341.42,69.87 342.57,69.87 344.09,71.4 346.25,71.4
+5V_ALW on BOTTOM (solid shape): 35.89,103.89 35.89,103.17 35.28,102.56 34.01,102.56 33.75,102.82 33.75,103.78 33.93,103.96 35.81,103.96
+5V_ALW on BOTTOM (solid shape): 100.78,122.35 101.69,122.35 101.9,122.14 101.9,120.65 101.52,120.27 98.07,120.27 97.51,120.83 97.51,122.05 97.81,122.35 100.78,122.35
+5V_ALW on BOTTOM (solid shape): 138.35,125.88 138.35,124.19 138.29,124.13 134.18,124.13 134.06,124.26 134.06,125.59 134.44,125.97 138.26,125.97
+5V_ALW on BOTTOM (solid shape): 23.41,96.29 23.41,94.84 23.62,94.64 24.25,94.64 24.46,94.44 24.46,93.75 23.97,93.27 22.17,93.27 22.04,93.4 22.04,96.37 22.22,96.54 23.16,96.54
+5V_ALW on BOTTOM (solid shape): 39.32,76.15 40.02,76.15 40.02,76.7 40.52,76.7 40.52,76.15 41.32,76.15 41.32,75.13 40.38,74.19 37.51,74.19 36.62,75.08 36.62,75.9 36.88,76.15 38.82,76.15 38.82,76.7 39.32,76.7
+5V_ALW on BOTTOM (solid shape): 169.18,69.91 169.18,68.45 165.58,64.85 165.53,64.85 162.08,61.4 160.13,61.4 160.13,61.4 157.78,61.4 157.74,61.44 157.74,62.65 157.77,62.67 157.77,64.53 163.47,70.23 168.86,70.23
+5V_ALW on TOP: 241.73,6.43 240.43,7.73 240.43,11.96 239.75,12.64 239.75,20.52 241.28,22.06 246.74,22.06 246.93,21.87 246.93,20.47 250.95,16.46 250.95,12.93 250.11,12.1 250.11,11.96 249.98,11.84 249.98,11.82 249.95,11.74 249.87,11.72 249.48,11.36 249.87,11.01 249.95,10.98 249.98,10.9 249.98,6.6 249.81,6.43
+5V_ALW on BOTTOM: 324.79,79.15 332.53,79.15 337.36,74.32 337.36,68.48 336.33,67.45 334.07,67.45 328.72,72.8 324.28,72.8 322.93,71.45 320.47,71.45 319.44,70.42 318.59,70.42 318.53,70.42 318.46,70.42 318.29,70.33 318.19,70.16 318.18,70.13 314.46,70.13 314.37,70.19 314.38,70.29 314.09,70.86 313.81,70.29 313.82,70.19 313.73,70.13 312.57,70.13 312.48,70.19 312.49,70.29 312.21,70.86 311.92,70.29 311.93,70.19 311.84,70.13 309.93,70.13 307.51,67.72 303.2,67.72 302.69,68.22 302.69,71.4 311.07,79.78 324.15,79.78
+5V_ALW on BOTTOM: 278.86,2.06 276.3,4.62 276.3,5.85 274.1,8.05 269.9,8.05 263.95,2.11 257.43,2.11 257.41,2.11 244.01,2.11 243.81,2.31 243.81,7.87 245.12,9.18 252.92,9.18 253.52,8.57 259.13,8.57 261.67,11.11 261.84,11.11 262.19,11.45 264.88,11.45 264.9,11.47 265.72,11.47 266,11.5 266.18,11.71 266.18,11.73 266.38,11.92 267.19,11.92 268.58,13.31 276.35,13.31 278.13,11.52 279.55,11.52 282.42,8.66 282.42,7.37 282.41,7.36 282.41,7.17 283.47,6.11 286.83,6.11 287.19,5.74 287.19,4.72 287.18,4.71 287.18,4.53 286.24,3.59 284.6,3.59 283.07,2.06
+5V_ALW on VCC: 227.36,19.71 224.9,22.16 224.9,39.44 215.93,48.41 173.89,48.41 159.3,63 159.3,87.13 132.49,113.94 123.16,113.94 123.03,113.82 116.61,113.82 116.48,113.94 106.3,113.94 104.06,111.7 104.06,104.93 73.41,104.93 72.08,103.59 65.09,103.59 62.55,101.05 54.55,101.05 41.83,88.33 41.83,80.39 39.61,78.17 39.61,75.63 37.79,73.81 35.46,73.81 29.74,79.53 22.38,79.53 18.59,83.32 18.59,85.9 20.24,87.55 20.24,94.41 21.49,95.66 27.61,95.66 27.61,99.3 32.6,104.29 43.4,104.29 47.16,108.06 47.16,110.79 60.86,124.48 95.28,124.48 97.05,126.26 119.28,126.26 120.8,127.79 149.55,127.79 177.97,99.36 177.97,76.63 187.91,66.7 220.61,66.7 227.35,54.96 237.42,45.92 247.25,41.16 257.94,38.94 284.81,50.5 297.51,76.86 304.11,76.86 304.47,76.5 304.47,58.93 291.45,45.91 291.45,45.41 287.66,41.62 287.15,41.62 279.98,34.44 268.67,34.44 253.94,19.71
+5V_ALW on IN2: 293.84,6.26 293.85,6.23 294.18,6.02 294.5,6.23 294.52,6.26 295.09,6.26 295.21,6.14 297.21,6.14 298.83,4.52 310.58,4.52 310.85,4.79 312.79,4.79 313.1,4.6 313.42,4.79 315.62,4.79 315.91,4.62 316.21,4.77 316.22,4.79 316.29,4.79 316.61,4.6 316.92,4.79 317.22,4.79 317.32,4.77 317.42,4.79 319.16,4.79 319.17,4.78 319.32,4.75 319.48,4.78 319.49,4.79 324.28,4.79 326.75,7.26 333.55,7.26 333.93,6.88 333.93,5.74 333.55,5.36 330.12,5.36 326.62,1.85 296.7,1.85 295.78,2.77 291.53,2.77 290.59,1.83 278.61,1.83 275.45,4.98 270.55,4.98 268.13,2.56 261.88,2.56 261.09,3.36 261.09,5.28 261.14,5.34 266.84,5.34 269.72,8.22 274.9,8.22 276.86,6.26 286.56,6.26 286.73,6.22 286.89,6.26
+5V_ALW on IN3: 296.46,6.53 296.72,6.63 297.08,6.63 298.48,5.23 298.52,5.23 298.65,5.1 302.31,5.1 302.54,5.33 303.63,5.33 305,3.96 327.19,3.96 329.6,6.37 333.68,6.37 333.93,6.12 333.93,5.49 333.17,4.72 331.06,4.72 328.77,2.44 297.1,2.44 295.7,3.83 294.81,3.83 294.13,4.52 291.26,4.52 290.32,5.46 289.96,5.46 289.72,5.59 289.47,5.52 289.4,5.5 289.34,5.52 289.11,5.61 288.87,5.53 288.8,5.51 288.74,5.54 288.44,5.64 288.18,5.46 287.83,5.46 286.71,4.34 286.64,4.34 286.36,4.06 283.23,4.06 282.83,4.47 282.83,5.43 285.34,5.43 285.99,6.09 286.29,6.09 286.43,6.22 286.69,6.22 286.96,6.31 287.08,6.56 287.08,6.58 287.89,7.39 294.89,7.39 295.38,6.9 295.37,6.87 295.57,6.42 296.03,6.62 296.11,6.68 296.2,6.64
+5V_ALW2 on TOP (solid shape): 122.75,131.37 122.75,131.24 121.99,130.48 120.27,130.48 120.08,130.67 120.08,131.24 120.21,131.37 121.35,131.37 121.42,131.43 122.69,131.43
+5V_ALW_PDA on BOTTOM (solid shape): 36.38,86.08 36.38,85.8 36.64,85.55 37.19,85.55 37.32,85.42 37.37,85.42 37.37,85.41 38.13,85.41 38.13,85.42 38.28,85.42 38.28,85.41 38.79,85.41 39.44,84.76 39.44,78.6 39.91,78.13 40.69,78.13 41.32,77.49 41.32,76.33 41.31,76.3 41.27,76.28 40.7,76.28 40.66,76.3 40.65,76.33 40.65,76.83 39.9,76.83 39.9,76.33 39.88,76.3 39.84,76.28 39.5,76.28 39.46,76.3 39.45,76.33 39.45,76.83 38.7,76.83 38.7,76.33 38.68,76.3 38.64,76.28 36.95,76.28 36.48,76.75 36.48,83.63 35.73,84.38 35.66,84.38 35.23,84.81 35.23,84.85 35.27,84.9 35.48,85.07 35.48,85.34 35.48,85.35 35.48,85.4 35.24,85.64 35.24,86.33 35.23,86.33 35.23,86.67 35.3,86.75 35.72,86.75
+5V_ALW_PDA on IN3: 34.31,89.45 36.9,89.45 37.36,88.99 37.36,85.7 36.89,85.23 35.92,85.23 34.91,86.25 34.91,88.72 34.76,88.87 34.21,88.87 34.12,88.96 34.12,89.26
+5V_ALWP on TOP (solid shape): 135.56,133.45 135.56,132.23 135.96,131.83 136.65,131.83 136.78,131.7 136.78,128.5 136.65,128.37 133.88,128.37 133.68,128.57 133.68,133.38 133.88,133.58 135.43,133.58
+5V_ALWP on BOTTOM (solid shape): 135.64,133.39 135.64,132.13 135.92,131.85 136.7,131.85 137.03,131.52 137.03,128.5 138.38,127.15 138.38,126.75 138.3,126.67 131.21,126.67 130.72,127.16 130.72,133.48 130.89,133.65 135.38,133.65
+5V_HDD on BOTTOM (solid shape): 265.05,18.9 265.05,18.19 264.84,17.98 264.84,16.92 264.84,16.91 264.84,16.22 264.84,16.04 264.84,16.04 264.84,15.62 263.48,14.27 263.48,12.78 263.41,12.7 262.31,12.7 262.21,12.8 262.21,15.05 263.19,16.03 263.19,19.2 263.44,19.46 264.49,19.46
+5V_HDD on TOP: 264.07,12.27 263.94,12.13 263.54,12.13 263.02,12.16 262.95,11.65 262.95,11.27 262.72,11.04 261.5,11.04 261.12,10.66 260.62,10.66 260.62,10.62 260.6,10.59 260.6,10.17 260.58,10.14 260.55,10.12 260.47,10.12 260.43,10.14 260.42,10.17 260.42,10.59 260.41,10.59 260.41,10.64 260.36,10.69 257.58,10.69 257.35,10.92 257.35,13.46 260.97,17.09 261,17.08 261.44,17.36 261.13,17.78 261.08,17.78 261.08,19.19 261.43,19.54 262.21,19.54 262.21,19 262.65,19 262.65,19.54 264.41,19.54 265.05,18.9 265.05,17.09 265.73,16.41 265.73,13.79 264.21,12.27
+5V_HDD_UZ23 on TOP (solid shape): 260.29,10 260.72,10 260.72,10.46 261.57,10.46 262.12,9.91 263.57,9.91 263.7,9.78 263.7,9.3 263.93,9.07 263.93,8.18 263.78,8.03 257.35,8.03 257.22,8.15 257.22,10.21 257.48,10.46 260.29,10.46
+5V_PD_VDD on BOTTOM (solid shape): 33.5,105.66 33.5,103.23 33.42,103.15 32.81,103.15 32.75,103.09 32.75,102.96 33.19,102.51 33.73,102.51 34.21,102.03 34.59,102.03 34.72,101.9 35.58,101.9 35.76,101.73 35.76,101.07 35.66,100.96 35.12,100.96 35.05,101.04 35.05,101.27 34.95,101.37 32.79,101.37 31.85,102.31 30.98,102.31 30.86,102.44 30.86,105.46 30.92,105.53 31.69,105.53 32,105.84 33.32,105.84
+5V_RUN on TOP (solid shape): 295.23,56.74 295.23,56.2 294.32,55.28 293.92,55.28 293.16,56.04 293.16,56.57 294.08,57.48 294.5,57.48
+5V_RUN on TOP (solid shape): 142.24,103.83 142.24,103.78 142.54,103.48 142.54,101.12 141.14,99.72 139.11,99.72 137.31,97.92 128.32,97.92 128.09,98.15 128.09,100.56 128.65,101.12 129.05,101.12 129.43,100.74 129.43,99.62 129.82,99.24 136.09,99.24 140.13,103.28 140.13,103.66 140.64,104.16 141.91,104.16
+5V_RUN on TOP (solid shape): 210.31,67.49 210.31,65.83 209.58,65.1 209.18,65.1 207.66,66.62 205.41,66.62 205.18,66.85 205.18,68.28 205.56,68.54 205.18,68.8 205.18,69.35 205.37,69.54 208.26,69.54
+5V_RUN on BOTTOM (solid shape): 125.14,123.93 125.14,122.71 123.72,121.28 123.31,121.28 123.24,121.36 123.24,124.1 123.39,124.26 124.81,124.26
+5V_RUN on BOTTOM (solid shape): 209.9,69.55 209.9,67.4 209.7,67.2 208.07,67.2 207.78,67.49 207.78,69.6 207.95,69.77 209.68,69.77
+5V_RUN on BOTTOM (solid shape): 295.49,57.57 295.49,57.24 294.84,56.59 294.29,56.59 293.87,57.01 293.87,57.31 294.47,57.91 295.14,57.91
+5V_RUN on BOTTOM (solid shape): 354.25,86.25 354.25,85.2 354.11,85.06 352.9,85.06 352.17,85.8 352.17,86.07 352.76,86.66 353.83,86.66
+5V_RUN on IN1 (solid shape): 209.95,70.92 209.95,67.56 209.32,66.93 206.17,66.93 205.25,67.84 205.25,71.48 205.28,71.5 209.37,71.5
+5V_RUN on IN1 (solid shape): 127.68,122.02 141.25,122.02 161.16,102.11 161.16,98.81 159.05,98.81 156.22,101.64 154.47,101.64 154.4,101.7 153.89,101.7 152.62,102.97 152.62,105.23 138.45,119.4 126.87,119.4 126.86,119.39 124.9,119.39 123.24,121.06 123.24,123.16 123.72,123.65 126.06,123.65
+5V_RUN on IN2 (solid shape): 295.75,56.93 295.75,56.58 295.35,56.17 294.69,56.17 293.95,56.91 293.95,57.3 294.45,57.8 294.89,57.8
+5V_RUN on TOP: 268.15,20.77 277.31,20.77 278.41,19.67 278.33,19.28 278.67,19.06 278.67,11.13 279.21,10.59 280.44,10.59 280.48,10.59 281.16,10.59 281.19,10.59 282.11,10.59 282.34,10.36 282.34,10.17 282.34,10.15 282.31,10.13 282.31,9.74 282.29,9.72 281.78,9.72 281.78,9.17 282.29,9.17 282.29,8.92 281.78,8.92 281.78,8.37 282.29,8.37 282.29,5.87 281.88,5.46 278.51,5.46 278.3,5.67 278.3,6.6 270.64,14.26 270.64,17.23 269.68,18.2 267.04,18.2 266.92,18.08 266.91,18.08 266.91,16.33 266.84,16.26 265.98,16.26 265.86,16.38 265.86,18.97 265.12,19.71 264.18,19.71 264.16,19.68 261.11,19.68 261.03,19.76 261.03,22.1 261.04,22.11 261.04,23.15 261.41,23.52 262.89,23.52 263.13,23.34 263.43,23.41 264.84,22 264.84,21.94 265.57,21.94 265.58,21.91 265.84,21.7 266.16,21.79 266.23,21.82 266.3,21.79 266.53,21.69 266.77,21.77 266.83,21.8 266.9,21.77 267.04,21.7 267.19,21.7 267.22,21.7
+5V_RUN on TOP: 331.45,9.05 331.45,4.43 328.34,1.32 292.4,1.32 292.31,1.37 292.32,1.48 292.28,1.92 291.84,1.98 291.74,1.98 291.69,2.07 291.69,3.73 291.87,3.91 300.25,3.91 301.01,4.67 312.88,4.67 313.1,4.6 313.32,4.67 315.74,4.67 315.92,4.62 316.11,4.67 316.39,4.67 316.51,4.61 316.65,4.6 316.97,3.99 317.03,4.67 323.44,4.67 326.26,7.49 326.26,12.12 327.43,13.28 327.43,17.23 327.7,17.5 327.78,17.5 327.78,17.59 327.8,17.6 327.8,19.86 330.89,19.86 331.67,19.08 332.13,19.08 332.13,18.46 332.28,18.46 332.28,19.08 332.5,19.08 332.53,19.05 332.53,17.28 332.45,17.2 332.45,16.35 331.45,15.35 331.45,9.74 331.42,9.73 331.19,9.4 331.42,9.06
+5V_RUN on BOTTOM: 141.63,100.91 140.41,102.13 140.41,103.76 140.58,103.93 142.21,103.93 143.66,102.49 152.45,102.49 153.34,103.38 154.12,103.38 154.76,102.74 154.76,102.31 153.36,100.91
+5V_RUN on IN3: 281.72,4.28 282.24,3.76 286.69,3.76 287.14,4.22 293.87,4.22 294.6,3.49 295.16,3.49 295.58,3.07 295.58,1.3 295.56,1.28 278.5,1.28 278.22,1.56 278.22,6.16 278.49,6.44 281.36,6.44 281.72,6.08
+5V_RUN_AUDIO on TOP (solid shape): outline of 213 points within 324.84,17.63 334.41,33.32
+5V_RUN_AUDIO_UZ5 on TOP (solid shape): 331.38,22.25 331.81,22.25 332.11,22.55 332.43,22.55 332.53,22.45 332.53,20.57 332.51,20.55 332.33,20.55 332.3,20.56 332.28,20.6 332.28,21.11 332.13,21.11 332.13,20.6 332.12,20.56 332.08,20.55 328.49,20.55 328.19,20.85 328.19,21.54 328.19,22.63 328.21,22.66 330.97,22.66
+5V_RUN_PVDD_L on TOP: 337.13,35.92 337.7,36.5 338.66,36.5 338.72,36.44 338.72,36.31 338.66,36.25 338.44,36.25 338.43,36.25 337.83,36.25 337.39,35.81 337.39,34.44 336.58,33.63 335.35,33.63 334.82,33.11 331.96,33.11 331.23,33.83 331.23,37.97 331.93,38.66 331.93,38.67 332.12,38.86 332.12,39.49 332.37,39.74 333.17,39.74 333.26,39.65 333.8,39.65 333.93,39.53 333.93,39.4 334.18,39.14 334.43,39.14 334.91,38.66 336.05,38.66 336.24,38.47 338.66,38.47 338.72,38.41 338.72,38.34 338.66,38.28 333.64,38.28 333.63,38.27 333.41,38.27 332.82,37.69 332.82,35.26 333.48,34.6 336.37,34.6 337.13,35.36
+5V_RUN_UZ4 on TOP (solid shape): 285.42,9.68 286.03,9.68 286.13,9.58 286.13,8.87 286.1,8.85 285.98,8.63 286.08,8.41 286.08,8.16 286.05,8.13 286.05,7.29 285.98,7.22 284.01,7.22 283.46,7.77 282.62,7.77 282.44,7.95 282.44,8.49 281.91,8.49 281.91,8.79 282.44,8.79 282.44,9.29 281.91,9.29 281.91,9.59 282.44,9.59 282.44,10.08 282.65,10.29 284.81,10.29
+5V_TBT_VBUS on BOTTOM (solid shape): 36.93,104.42 36.88,104.37 34.31,104.37 34.24,104.44 34.24,107.62 34.67,108.05 36.93,108.05
+5V_TBTA_VBUS_D on BOTTOM (solid shape): 37.33,111.33 37.33,109.24 36.94,108.85 34.3,108.85 34.08,109.07 34.08,109.83 33.93,109.98 33.93,111.33 34.13,111.53 37.13,111.53
+5V_TSP on TOP (solid shape): 128.49,102.69 128.49,101.8 128.27,101.57 127.35,101.57 125.83,103.1 124.18,103.1 124,103.28 123.49,103.28 123.36,103.4 123.36,104.42 123.8,104.85 126.34,104.85
+5V_TSP on BOTTOM (solid shape): 124.71,106.48 124.71,104.27 124.56,104.11 123.97,104.11 123.52,104.56 123.52,105.67 123.52,105.67 123.52,106.96 123.6,107.04 124.16,107.04
+5V_USB_CHG_PWR on TOP (solid shape): 339.64,71.81 339.64,70.13 339.57,70.06 337.83,70.06 337.61,70.28 337.61,72.14 337.76,72.29 339.16,72.29
+5V_USB_CHG_PWR on BOTTOM (solid shape): 357.76,66.01 357.76,65.13 357.74,65.11 357.74,63.91 357.02,63.18 354.91,63.18 354.76,63.04 354.76,58 354.34,57.57 352.45,57.57 352.03,58 352.03,65.62 352.32,65.91 354.94,65.91 355.47,66.45 357.32,66.45
+5V_USB_CHG_PWR on IN2 (solid shape): 355.25,59.2 355.25,57.48 355.02,57.26 349.24,57.26 349.14,57.36 349.14,59.89 349.42,60.17 354.29,60.17
+5V_USB_CHG_PWR on IN2 (solid shape): 345.34,72.01 345.34,70.75 344.73,70.13 337.84,70.13 337.54,70.43 337.54,72.23 338.1,72.79 344.56,72.79
+DV33_18 on TOP (solid shape): 22.22,67.16 22.22,66.62 22.12,66.52 20.57,66.52 20.27,66.83 19.53,66.83 19.5,66.85 19.5,67.03 21.52,67.03 21.68,67.18 22.2,67.18
+GND_CHASSIS on TOP (solid shape): 339.11,118.67 339.31,118.67 339.42,118.57 339.42,117.07 339.1,116.75 327.36,116.75 326.69,117.42 326.69,118.62 326.74,118.67 330.73,118.67 330.73,118.67 339.11,118.67
+GND_CHASSIS on BOTTOM (solid shape): 341.14,118.34 341.14,116.53 340.8,116.19 338.23,116.19 338.15,116.28 338.15,118.36 338.3,118.52 340.97,118.52
+VBUS_DC_SS on TOP (solid shape): 51.1,118.64 51.1,115.47 50.34,114.71 50.34,111.52 50.33,111.52 50.21,111.4 49.92,111.4 49.67,111.15 46.15,111.15 45.84,111.45 45.84,115.93 45.9,115.98 45.91,115.98 47.6,116.86 48.47,118.55 48.81,118.9 50.85,118.9
+VCC_CORE on TOP (solid shape): 114.78,64.04 114.78,62.87 115.6,62.05 115.61,62.05 115.61,61.88 115.55,61.73 115.57,61.57 115.57,61.57 115.57,60.88 115.4,60.72 115.07,60.72 115.02,60.67 114.68,60.67 114.6,60.74 114.6,61.56 114.3,61.85 114.3,62.44 114.19,62.55 114.19,64.02 114.26,64.08 114.74,64.08
+VCC_CORE on TOP (solid shape): outline of 2910 points within 72.11,60.28 113.27,91.59
+VCC_CORE on BOTTOM (solid shape): 115.38,62.27 115.38,61.88 115.52,61.74 115.52,61.52 115.8,61.25 115.92,61.25 116.01,61.16 116.01,60.93 115.87,60.78 114.57,60.78 114.42,60.93 114.42,61.9 114.3,62.02 114.3,62.28 114.45,62.44 115.21,62.44
+VCC_CORE on BOTTOM (solid shape): outline of 2992 points within 69,72.91 113.28,91.59
+VCC_CORE on BOTTOM: 100.49,60.74 100.19,61.03 99.47,61.03 99.23,60.79 97.15,60.79 97.14,60.82 96.85,61.01 96.56,60.82 96.54,60.79 96.25,60.79 96.19,60.86 96.19,61.06 96.86,61.74 96.86,62.47 97,62.61 98.28,62.61 98.28,62.6 113.01,62.6 113.24,62.38 113.24,60.99 113.03,60.78 106.53,60.78 106.51,60.79 106.21,60.79 106.21,60.79 103.43,60.79 102.58,61.64 102.29,61.64 101.39,60.74
+VCC_CORE on IN1: 103.78,61.49 103.51,61.76 102.85,61.76 101.52,63.09 96.31,63.09 96.31,80.27 96.58,80.54 112.1,80.54 112.95,79.69 112.95,69.05 114.41,67.59 114.41,64.4 112.91,62.9 112.91,61.9 112.73,61.72 111.77,61.72 111.77,61.49
+VCC_CORE on IN1: 75.34,85.46 75.33,85.47 73.81,85.47 73.45,85.83 72.28,85.83 71.95,86.16 71.95,90.27 72.28,90.6 79.07,90.6 79.24,90.78 98.27,90.78 98.83,91.34 103.77,91.34 104.69,90.41 104.69,85.22 104.45,84.98 97.47,84.98 97.19,84.69 89.45,84.69 88.66,85.48 79.96,85.48 79.94,85.46
+VCC_CORE on VCC: 103.15,60.98 102.9,61.24 96.31,61.24 96.31,80.46 94.26,82.51 71.99,82.51 71.99,90.15 72.61,90.77 109.1,90.77 109.9,89.96 109.9,85.07 112.95,82.03 112.95,73.28 112.7,73.03 112.7,69.64 114.22,68.12 114.22,61.34 113.86,60.98
+VCC_CORE on IN2: 103.03,61.05 102.66,61.42 102.66,61.45 97.54,61.45 96.31,62.69 96.31,80.21 96.1,80.43 96.1,80.68 94.36,82.42 72.64,82.42 71.85,83.21 71.85,90.28 72.48,90.91 72.48,90.92 72.6,91.05 98.67,91.05 99.02,91.4 105.34,91.4 109.91,86.84 109.91,85.08 110.87,84.12 110.87,83.49 111.83,82.52 111.85,82.52 112.97,81.41 112.97,69.55 114.46,68.06 114.46,62.62 114.78,62.31 114.79,62.31 114.82,62.28 114.82,61.89 113.98,61.05
+VCC_CORE on IN3: 96.58,80.35 112.52,80.35 113.28,79.59 113.28,75.07 113.14,74.93 113.14,72.83 113.01,72.71 113.01,69.35 115.19,67.18 115.19,62.04 114.78,61.63 96.91,61.63 96.1,62.45 96.1,79.87
+VCC_CORE on IN3: 103.98,91.74 99.54,91.74 99.54,91.74 99.37,91.74 97.97,90.35 96.9,90.35 96.57,90.68 93.11,90.68 92.68,90.25 90.65,90.25 90.39,90.5 77.57,90.5 77.31,90.25 75.59,90.25 75.23,90.6 72.46,90.6 72.16,90.3 72.16,86.63 73.2,85.58 78.85,85.58 78.99,85.45 96.06,85.45 96.27,85.65 104.16,85.65 104.42,85.91 104.42,91.31
+VCC_GT on TOP (solid shape): 68.87,74.56 68.87,72.96 69.24,72.59 69.24,68 68.88,67.64 67.15,67.64 66.89,67.39 66.89,66.18 66.89,66.18 66.89,65.8 65.87,64.78 65.87,63.65 65.62,63.4 64.59,63.4 64.28,63.4 64.18,63.4 63.17,62.38 58.09,62.38 57.96,62.25 57.96,60.35 57.58,59.97 56.18,59.97 55.42,60.73 55.42,64.67 55.42,67.66 58.27,70.51 60.88,70.51 64.23,73.86 64.23,74.7 64.76,75.23 68.2,75.23
+VCC_GT on BOTTOM (solid shape): 94.85,62.45 94.85,61.56 94.66,61.37 92.57,61.37 92.5,61.43 92.5,61.75 93.01,62.25 93.01,62.45 93.14,62.57 94.73,62.57
+VCC_GT on TOP: 85.48,77.61 85.48,77.62 85.48,78.19 85.48,78.21 85.48,78.53 85.47,78.55 85.46,78.56 84.57,79.46 84.57,80.73 84.73,80.9 95.13,80.9 95.42,80.61 95.42,74.09 95.41,74.09 95.23,73.9 95.23,73.11 95.24,73.11 95.31,73.03 95.31,68.24 95.77,67.78 95.77,62.03 95.42,61.68 95.42,61.68 95.21,61.47 93.12,61.47 93.01,61.58 93.01,62.45 92.63,62.83 92.53,62.73 91.9,62.73 92.38,62.25 92.38,61.81 92.25,61.68 91.36,61.68 90.72,61.05 90.03,61.05 89.96,61.11 89.28,61.79 88.09,61.79 87.99,61.69 87.99,61.11 87.93,61.05 86.72,61.05 86.66,61.11 86.66,62.25 86.28,62.64 85.9,62.64 85.14,61.87 79.41,61.87 78.93,62.36 78.93,63.94 79.33,64.35 82.85,64.35 82.98,64.48 82.98,64.54 83.49,65.05 83.49,71.84 83.74,72.1 85.39,72.1 85.77,72.48 85.77,73.81 85.39,74.19 85.39,75.15 85.48,75.23
+VCC_GT on BOTTOM: 56.31,59.84 55.42,60.73 55.42,67.26 58.54,70.38 60.75,70.38 62.91,72.54 62.91,75.21 64.87,77.16 68.7,77.16 69.58,76.29 69.58,69.79 69.37,69.57 68.84,69.57 68.59,69.32 68.59,68.08 68.17,67.67 67.2,67.67 66.98,67.44 66.98,66.32 65.96,65.3 64.66,65.3 64.36,65 64.36,63.58 62.48,61.7 60.04,61.7 59.33,60.99 59.33,60.3 58.87,59.84
+VCC_GT on BOTTOM: outline of 230 points within 79.37,60.79 95.45,81.24 ; 2 cut-outs
+VCC_GT on IN1: 63.15,64.3 63.15,64.08 58.38,59.31 55.77,59.31 55.75,59.31 55.73,59.32 55.03,60.03 55.02,60.05 55.01,60.07 55.01,69.02 58.36,72.37 63.24,72.37 65.58,74.7 65.58,75.23 66.03,75.69 72.63,75.69 77.36,80.42 94.9,80.42 95.72,79.6 95.72,62.08 95.49,61.85 87.23,61.85 85.09,63.99 84.27,63.99 83.48,64.79 83.49,64.79 83.49,70.05 83.65,70.22 83.65,74.46 83.33,74.78 77.26,74.78 75.02,72.54 71.39,72.54
+VCC_GT on VCC: 55.78,60.22 55.16,60.84 55.16,64.63 56.18,65.64 56.18,68.37 57.7,69.9 57.7,72.44 67.27,82 94.05,82 95.8,80.25 95.8,61.24 84.73,61.24 84.1,61.87 83.21,61.87 82.32,62.76 74.74,62.76 72.2,60.22
+VCC_GT on IN2: 56.18,60.1 55.8,60.48 55.8,68.99 66.17,79.36 73.43,79.36 76.1,82.03 93.99,82.03 95.79,80.23 95.79,62.06 94.94,61.21 90.54,61.21 90.43,61.22 90.34,61.21 89.58,61.21 89.52,61.22 89.47,61.21 88.69,61.21 88.6,61.22 88.52,61.21 87.79,61.21 87.69,61.22 87.59,61.21 86.21,61.21 86.2,61.28 85.89,61.58 85.55,61.31 85.54,61.29 85.45,61.2 84.02,61.2 82.15,63.07 80.41,63.07 78.67,61.33 78.67,61.26 78.09,61.26 76.83,60.01 72.26,60.01 71.48,59.23 63.47,59.23 62.61,60.1
+VCC_GT on IN3: 56.45,58.76 55.15,60.06 55.14,60.08 55.13,60.1 55.13,68.08 58.57,71.53 62.22,71.53 64.38,73.68 64.38,74.25 64.37,74.26 64.37,76.1 65.38,77.11 69.76,77.11 69.78,77.12 69.8,77.12 69.9,77.12 69.94,77.11 71.63,76.62 73.32,77.11 73.36,77.12 75.03,77.12 75.05,77.13 75.07,77.14 77.48,79.55 77.5,79.56 77.52,79.56 80.24,79.56 80.26,79.57 80.27,79.58 80.58,79.88 80.6,79.89 80.78,79.99 80.88,80.17 80.88,80.19 81.2,80.51 81.22,80.52 81.24,80.52 81.85,80.52 81.88,80.52 82.58,80.52 82.65,80.54 83.09,80.54 83.17,80.48 83.17,80.38 83.15,80.35 83.13,80.3 83.21,79.94 83.57,79.84 83.8,80.06 83.76,80.38 83.76,80.48 83.84,80.54 85.41,80.54 85.43,80.54 85.44,80.55 85.76,80.87 85.78,80.88 85.8,80.89 94.92,80.89 95.42,80.38 95.42,79.78 95.53,79.67 95.53,62.52 94.32,61.32 83.81,61.32 82.47,62.66 78.61,62.66 78.6,62.65 75.6,62.65 73.07,60.12 65.3,60.12 63.94,58.76 ; 1 cut-out
+VCC_SA on TOP: 113.46,79.53 113.46,80.34 113.44,80.35 113.44,81.71 111.02,84.14 111.02,86.75 110.32,87.45 110.32,89.03 111.62,90.33 114.99,90.33 116.34,91.68 117.05,91.68 117.71,91.02 117.71,90.7 118.09,90.32 118.09,87.19 117.55,86.65 117.55,83.74 117.55,83.73 117.55,83.55 117.39,83.4 117.39,80.35 116.38,79.34 116.38,77.2 116.33,77.19 116.07,76.95 116.15,76.6 116.18,76.52 116.16,76.44 116.08,76.21 116.16,75.99 116.17,75.98 116.18,75.94 116.16,75.89 116.16,75.89 116.07,75.76 116.04,75.61 115.61,75.17 115.61,75.15 114.96,74.5 114.96,73.56 114.9,73.5 114.1,73.5 113.87,73.27 113.87,72.86 113.76,72.76 113.26,72.76 113.21,72.81 113.21,74.73 113.46,74.98 113.46,75.53
+VCC_SA on BOTTOM: 117.88,89.69 112.44,89.69 110.94,88.19 110.49,88.19 110.31,88.01 110.31,86.92 110.31,86.92 110.36,86.87 110.91,86.87 111.03,86.75 111.03,85.04 111.16,84.91 111.62,84.91 111.62,84.91 111.93,84.91 112.12,84.71 112.12,84.12 112.45,83.79 112.45,82.7 113.38,81.78 113.38,81.06 113.86,80.58 113.86,79.18 113.45,78.77 113.45,72.94 113.58,72.8 114.69,72.8 115.57,73.69 116.32,73.69 116.64,74.01 116.64,74.32 115.63,75.33 115.63,77.7 115.03,78.3 115.03,79.73 114.4,80.37 114.4,81.55 115.64,82.8 115.64,83.91 115.88,84.15 116.84,84.15 117.62,84.94 117.62,86.72 118.11,87.2 118.11,89.46
+VCC_SA on IN1: 111.83,89.7 116.71,89.7 117.18,89.23 117.18,86.33 116.62,85.78 116.62,84.51 115.58,83.46 115.58,81.01 115.59,81 115.59,80.56 114.96,79.92 114.96,77.85 115.21,77.6 115.21,75.4 114.94,75.13 114.94,74.21 114.73,73.99 113.46,73.99 113.46,82.22 113.32,82.36 113.29,82.36 112.5,83.15 112.5,83.95 111.2,85.25 111.2,89.06
+VCC_SA on VCC: 113.46,73.43 113.46,82.24 110.41,85.28 110.41,89.75 117.04,89.75 117.33,89.45 117.33,79.82 116.57,79.06 116.57,73.43
+VCC_SA on IN2: 119.93,85.64 119.62,85.32 119.62,82.04 119.49,81.91 119,81.64 119.38,81.23 119.44,81.21 119.48,81.15 119.51,81.06 119.56,80.99 119.59,80.92 119.56,80.85 119.52,80.81 119.5,80.77 119.44,80.72 119.37,80.72 118.92,80.47 119.2,80.03 119.28,79.96 119.25,79.86 119.03,79.64 119.01,79.64 118.82,79.54 118.72,79.34 118.71,79.32 118.66,79.27 117.9,79.27 117.65,79.02 117.65,78.94 117.65,78.93 117.63,78.82 117.65,78.72 117.65,78.71 117.65,78.51 117.56,78.42 117.49,78.39 117.42,78.42 116.91,78.43 116.91,77.92 116.94,77.85 116.91,77.78 116.34,77.2 116.33,77.2 116.1,77 116.12,76.7 116.12,76.41 116.12,76.4 116.09,76.26 116.12,76.13 116.12,76.12 116.12,75.82 116.12,75.8 116.11,75.79 116.03,75.57 116.11,75.35 116.12,75.33 116.12,75.31 116.12,74.46 115.82,74.15 114.02,74.15 113.56,74.61 113.56,82.21 111.34,84.43 111.34,89.12 113.94,91.72 118.72,91.72 119.85,90.58 119.88,90.51 119.85,90.44 119.76,90.16 119.91,89.9 119.93,89.88 119.93,89.86
+VCC_SA on IN3: 113.61,79.76 115.15,79.76 116.05,78.85 116.05,74.59 115.69,74.23 114.11,74.23 113.54,74.8 113.54,79.69
+VCC_SFR_OC on TOP (solid shape): 75.17,62.66 75.17,61.84 74.36,61.03 73.42,61.03 72.89,60.5 71.5,60.5 71.45,60.55 71.45,61.36 72.55,62.46 72.55,62.47 72.89,62.81 75.02,62.81
+VCC_SFR_OC on BOTTOM (solid shape): 73.48,62.38 74.04,62.38 74.45,61.97 74.45,61.18 74.34,61.07 72.67,61.07 72.32,61.41 71.66,61.41 71.54,61.53 71.54,63.38 71.73,63.58 72.29,63.58
+VDDA_AVDD1 on TOP (solid shape): 346.71,46.09 346.71,44.06 345.66,43 345.04,43 344.76,42.72 344.76,42.39 344.05,41.68 343.58,41.68 343.45,41.55 343.33,41.68 344.19,42.54 344.19,43.13 344.5,43.43 344.5,43.94 344.6,44.04 345.48,44.04 346.01,44.57 346.01,46.01 346.12,46.13 346.67,46.13
GND on TOP (solid shape): 356.66,39.14 356.66,37.74 354.76,35.84 354.63,35.84 352.22,38.25 354.25,40.28 355.52,40.28
GND on TOP (solid shape): 17.23,40.46 17.23,36.83 17.13,36.73 16.43,36.73 15.72,37.44 15.72,40.77 15.87,40.92 16.77,40.92
GND on TOP (solid shape): 22.23,43.67 22.23,41.99 21.96,41.71 19.18,41.71 18.81,42.09 18.81,43.61 19.09,43.89 22.01,43.89
GND on TOP (solid shape): 38.06,10.31 38.06,7.04 37.85,6.83 36.18,6.83 35.95,7.06 35.95,10.16 36.13,10.34 38.03,10.34
GND on TOP (solid shape): 77.87,6.36 77.87,3.45 77.75,3.33 75.61,3.33 75.09,3.85 75.09,5.96 75.7,6.57 77.67,6.57
GND on TOP (solid shape): 137.74,111.84 137.74,111 137.44,110.69 135.66,110.69 135.35,111 135.35,111.76 135.53,111.94 137.64,111.94
GND on TOP (solid shape): 307.66,65.52 307.66,63.37 307.6,63.32 306.57,63.32 306.3,63.59 306.3,65.63 306.46,65.8 307.38,65.8
GND on TOP (solid shape): 329.53,84.68 329.53,83.84 329.43,83.74 328.16,83.74 328.06,83.84 328.06,85.32 328.11,85.37 328.85,85.37
GND on TOP (solid shape): 359.27,7.84 359.27,6.5 359.14,6.37 356.03,6.37 355.9,6.5 355.9,8.03 356.03,8.15 358.95,8.15
GND on TOP (solid shape): 20.7,2.9 20.7,1.56 20.59,1.46 18.99,1.46 18.74,1.71 18.74,1.9 19.84,3 20.6,3
GND on TOP (solid shape): 26.46,2.21 26.46,1.55 26.13,1.22 24.41,1.22 24.28,1.35 24.28,2.84 24.33,2.9 25.78,2.9
GND on TOP (solid shape): 90.42,121.97 92.12,121.97 92.3,121.79 92.3,120.22 91.84,119.76 89.68,119.76 89.2,120.24 89.2,121.69 89.71,122.2 90.19,122.2
GND on TOP (solid shape): 100.5,26.57 100.5,24.03 100.12,23.65 99.74,23.65 96.69,26.69 89.71,26.69 89.58,26.82 89.58,28.47 90.34,29.23 97.84,29.23
GND on TOP (solid shape): 123.72,9.52 123.72,8.56 123.62,8.46 121.54,8.46 121.26,8.74 121.26,9.75 121.33,9.83 123.41,9.83
GND on TOP (solid shape): 179.24,22 179.24,21.36 179.12,21.23 178.35,21.23 178.15,21.44 177.77,21.44 177.55,21.65 177.55,22.44 177.69,22.58 178.66,22.58
GND on TOP (solid shape): 311.77,32.73 311.77,32.03 311.67,31.93 310.29,31.93 310.21,32.02 310.21,32.42 310.31,32.52 310.8,32.52 311.2,32.92 311.58,32.92
GND on TOP (solid shape): 20.11,63.34 20.11,61.24 19.72,60.86 18.64,60.86 18.52,60.99 18.52,63.4 18.58,63.47 19.98,63.47
GND on TOP (solid shape): 92.35,60.07 92.35,59.17 92.35,59.17 92.35,58.8 92.26,58.71 91.35,58.71 91.08,58.98 91.08,59.92 91.34,60.18 92.24,60.18
GND on TOP (solid shape): 35.67,30.11 35.67,26.38 34.46,25.17 34.46,23.65 33.96,23.14 30.78,23.14 29.96,23.96 29.96,30.51 30.59,31.14 34.64,31.14
GND on TOP (solid shape): 92.66,63.52 92.66,62.8 92.88,62.57 92.88,61.53 92.79,61.44 92.19,61.44 91.61,62.01 91.61,63.47 91.7,63.56 92.62,63.56
GND on TOP (solid shape): 95.28,71.94 95.74,71.94 95.8,71.88 95.8,68.1 95.55,67.84 94.73,67.84 94.6,67.97 94.6,71.27 94.79,71.46 94.79,71.88 94.86,71.95 95.27,71.95
GND on TOP (solid shape): 196.59,8.86 196.59,8.18 196.39,7.98 194.18,7.98 194.03,7.82 193.67,7.82 193.47,8.03 193.47,8.74 193.68,8.95 194.12,8.95 194.57,9.41 196.05,9.41
GND on TOP (solid shape): 328.38,47.84 328.99,47.23 328.99,46.68 328.98,46.67 328.46,46.67 327.78,46 327.19,46 327.11,46.08 327.11,47.78 327.19,47.85 328.38,47.85
GND on TOP (solid shape): 337.56,64.77 337.56,64.1 337.3,63.84 336.72,63.84 336.13,63.25 334.14,63.25 333.93,63.46 333.93,63.81 334.99,64.86 337.47,64.86
GND on TOP (solid shape): 91.99,7.39 91.99,6.88 91.61,6.5 90.98,6.5 90.72,6.25 90.72,6.08 90.42,5.78 89.77,5.78 89.71,5.84 89.71,6.88 90.34,7.52 91.87,7.52
GND on TOP (solid shape): 99.74,66.51 99.74,64.1 99.17,63.52 97.77,63.52 97.66,63.41 97.66,62.79 97.62,62.75 97.15,62.75 96.31,63.59 96.31,66.19 96.82,66.7 99.55,66.7
GND on TOP (solid shape): 201.13,34 202.21,34 202.4,33.81 202.4,33.43 202.34,33.37 201.2,33.37 201,33.18 200.37,33.18 200.31,33.24 200.31,34.26 200.37,34.32 200.81,34.32
GND on TOP (solid shape): 306.79,40.59 307.29,40.59 307.34,40.54 307.34,39.88 307.08,39.62 306.5,39.62 306.09,39.22 305.74,39.22 305.61,39.34 305.61,41.08 305.72,41.2 306.18,41.2
GND on TOP (solid shape): 109.27,65.14 109.27,64.35 109.27,62.57 109.25,62.56 108.89,62.56 108.87,62.57 108.31,62.57 108.25,62.51 107.73,62.51 107.64,62.59 107.64,65.22 107.77,65.35 109.06,65.35
GND on TOP (solid shape): 200.56,16.35 200.56,15.34 200.43,15.21 200.05,15.21 199.42,15.84 198.27,15.84 198.21,15.91 198.21,16.67 198.27,16.73 200.18,16.73
GND on TOP (solid shape): 311.05,72.29 311.05,71.45 310.94,71.35 310.94,68.24 310.93,68.2 310.89,68.19 309.48,68.19 309.39,68.29 309.39,72.44 309.53,72.59 310.76,72.59
GND on TOP (solid shape): 44.34,8.84 44.34,7.42 44.09,7.16 43.61,7.16 42.41,8.36 42.26,8.36 42.21,8.31 41.09,8.31 40.84,8.56 40.13,8.56 40.05,8.64 40.05,9.58 40.56,10.08 43.1,10.08
GND on TOP (solid shape): 31.7,62.92 31.7,62.05 31.26,61.62 30.56,61.62 30.4,61.66 30.24,61.62 29.18,61.62 28.83,61.98 28.83,63.09 29.23,63.5 31.11,63.5
GND on TOP (solid shape): 139.21,131.77 139.21,130.45 139.65,130.02 139.65,128.4 139.56,128.31 139.05,128.31 139.04,128.3 137.16,128.3 137.08,128.37 137.08,131.65 136.78,131.95 136.27,131.95 136.19,132.03 136.19,133.5 136.22,133.53 137.46,133.53
GND on TOP (solid shape): 171.45,25.48 171.45,24.61 170.84,24 170.84,23.62 170.46,23.24 170.46,21.54 170.11,21.2 166.58,21.2 166.37,21.41 166.37,25.35 166.92,25.91 171.01,25.91
GND on TOP (solid shape): 16.55,64.04 16.55,63.59 16.3,63.34 16.3,62.45 16.04,62.2 13.63,62.2 13.37,62.45 13.37,63.09 13.5,63.21 14.07,63.21 14.45,63.59 15.41,63.59 15.54,63.73 15.54,63.93 15.78,64.17 16.42,64.17
GND on TOP (solid shape): 97.84,74.95 97.84,73.56 97.96,73.43 98.03,73.43 98.15,73.3 98.15,73.05 98.03,72.92 97.33,72.92 97.2,73.05 97.2,73.37 97.01,73.56 96.88,73.56 96.82,73.62 96.82,74.51 97.39,75.08 97.39,75.15 97.65,75.15
GND on TOP (solid shape): 102.45,65.29 102.45,64.66 102.73,64.37 102.88,64.37 103.12,64.14 103.12,62.63 103.07,62.58 102.46,62.58 102.34,62.46 101.43,62.46 101.42,62.48 101.42,63.93 101.42,63.94 101.41,63.96 101.41,65.47 101.51,65.57 102.17,65.57
GND on TOP (solid shape): 150.67,130.33 150.67,129.06 149.84,128.23 149.84,125.82 149.59,125.56 147.49,125.56 146.8,124.87 145.78,124.87 145.65,124.99 145.65,125.5 145.91,125.75 146.54,125.75 147.05,126.26 148,126.26 148.19,126.45 148.19,130.39 148.32,130.52 150.48,130.52
GND on TOP (solid shape): 250.68,35.64 253.66,35.64 254.67,34.63 254.67,34.07 254.44,33.84 253.15,33.84 252.8,34.19 252.8,34.71 252.62,34.89 249.78,34.89 249.53,34.63 248.2,34.63 247.93,34.91 247.93,35.9 248.04,36.02 250.3,36.02
GND on TOP (solid shape): 324.53,79.53 324.53,79.35 324.71,79.17 324.71,78.71 324.23,78.23 323.9,78.23 323.87,78.26 323.72,78.26 323.68,78.3 323.65,78.35 323.61,78.39 323.24,78.76 323.24,79.7 323.3,79.77 324.29,79.77
GND on TOP (solid shape): 66.93,115.89 71.76,115.89 72.06,115.59 72.06,113.05 71.55,112.55 67.36,112.55 66.72,111.91 64.69,111.91 64.44,112.17 64.44,113.56 64.56,113.69 65.58,113.69 65.71,113.82 65.71,115.72 65.58,115.85 65.58,116.48 65.71,116.61 66.21,116.61
GND on TOP (solid shape): 66.89,4.82 66.89,3.5 66.58,3.2 59.05,3.2 59.04,3.21 58.71,3.21 58.34,3.58 58.34,4.72 58.47,4.85 63.85,4.85 63.98,4.98 66.73,4.98
GND on TOP (solid shape): 15.86,21.61 15.86,18 15.48,17.61 13.22,17.61 13.19,17.58 12.21,17.58 12.16,17.63 12.16,21.34 12.32,21.49 12.56,21.49 13,21.93 15.54,21.93
GND on TOP (solid shape): 81.78,8.13 81.78,7.9 82.01,7.67 86.58,7.67 87.39,6.86 87.4,6.86 87.46,6.79 87.95,6.79 88.14,6.6 88.14,6 88.08,5.94 86.65,5.94 86.21,6.37 81.86,6.37 81.68,6.55 80.11,6.55 79.75,6.91 79.75,7.39 80.67,8.31 81.61,8.31
GND on TOP (solid shape): 100.06,62.89 100.06,62.06 99.93,61.93 99.93,60.74 99.64,60.45 98.97,60.45 98.88,60.54 98.88,61.98 98.92,62.01 99.45,62.01 99.56,62.13 99.56,62.61 99.41,62.76 99.03,62.76 98.98,62.81 98.98,63.09 99.03,63.15 99.8,63.15
GND on TOP (solid shape): 100.19,74.89 100.19,73.62 100.38,73.43 100.5,73.43 100.63,73.3 100.63,73.05 100.5,72.92 99.74,72.92 99.55,73.11 99.55,73.49 99.49,73.56 99.23,73.56 99.17,73.62 99.17,74.51 99.23,74.57 99.42,74.57 99.55,74.7 99.55,75.08 99.61,75.15 99.93,75.15
GND on TOP (solid shape): 338.4,33.49 338.4,33.11 338.12,32.83 338.12,32.46 337.72,32.06 337.72,31.95 337.61,31.84 337.61,31.39 337.61,31.36 337.26,31.01 337.1,31.01 337.01,31.11 337.01,31.62 336.81,31.82 336.81,32.11 336.76,32.15 336.76,32.64 337.11,32.99 337.11,33.34 337.33,33.57 338.32,33.57
GND on TOP (solid shape): 104.89,74.95 104.89,73.56 104.76,73.43 104.76,73.11 104.63,72.99 104.63,67.72 104.5,67.59 104.12,67.59 103.93,67.78 103.93,72.86 103.74,73.05 103.74,73.43 103.87,73.56 103.87,74.51 103.93,74.57 104.12,74.57 104.25,74.7 104.25,75.02 104.38,75.15 104.69,75.15
GND on TOP (solid shape): 35.86,3.83 35.86,1.35 35.68,1.17 26.72,1.17 26.69,1.19 26.69,2.26 28.55,2.26 28.55,2.27 28.6,2.27 28.77,2.44 28.77,3.03 28.95,3.21 33.54,3.21 33.79,3.47 33.79,3.77 33.94,3.92 35.77,3.92
GND on TOP (solid shape): 220.9,25.17 221.85,25.17 222.36,24.66 222.36,24.09 222.3,24.03 221.85,24.03 221.73,23.9 220.46,23.9 220.14,23.58 219.69,23.58 219.63,23.65 219.63,23.84 219.06,23.84 218.99,23.9 218.99,24.22 219.06,24.28 220.07,24.28 220.26,24.47 220.26,24.92 219.57,25.62 218.99,25.62 218.8,25.42 218.23,25.42 218.23,25.93 218.42,26.12 219.95,26.12
GND on TOP (solid shape): 343.96,6.27 343.97,6.25 343.97,6.24 343.99,6.03 344.12,5.88 344.14,5.86 344.14,5.83 344.14,5.01 344.15,5.01 344.15,4.94 344.11,4.9 343.67,4.9 343.43,5.14 342.63,5.14 342.46,5.31 342.46,6.23 342.62,6.39 343.85,6.39
GND on TOP (solid shape): 121.13,90.55 127.28,90.55 128.42,89.41 129.31,89.41 129.46,89.26 129.46,88.62 129.57,88.51 129.57,87.13 131.24,85.47 131.24,80.06 130.43,79.25 127.61,79.25 126.69,80.16 126.69,85.52 125.37,86.84 122.3,86.84 122.29,86.84 118.96,86.84 118.65,87.15 118.65,89.41 118.8,89.56 118.8,90.44 119.01,90.64 121.04,90.64
GND on TOP (solid shape): 90.79,73.49 90.79,71.65 91.11,71.34 91.36,71.34 91.42,71.27 91.42,67.67 91.49,67.61 91.91,67.61 91.95,67.56 91.95,66.19 91.86,66.1 90.87,66.1 90.53,66.43 90.53,67.76 90.45,67.84 89.9,67.84 89.84,67.91 89.84,71.27 89.58,71.53 89.58,72.99 89.65,73.05 89.84,73.05 90.03,73.24 90.03,73.56 90.15,73.68 90.6,73.68
GND on TOP (solid shape): 111.24,75.08 111.24,74.81 111.51,74.54 112.55,74.54 112.61,74.48 112.61,73.67 112.53,73.6 112.24,73.6 112.23,73.6 111.52,73.6 111.39,73.47 111.39,73.01 111.3,72.92 111.02,72.92 110.92,73.02 110.92,73.49 110.92,73.49 110.92,74.67 110.82,74.67 110.67,74.82 110.67,74.87 110.67,74.91 110.67,74.96 110.67,75.03 110.79,75.15 111.17,75.15
GND on TOP (solid shape): 124,102.89 125.78,102.89 126.28,102.39 126.28,100.86 126.16,100.74 125.65,100.74 125.46,100.93 125.46,101.06 125.3,101.23 125.3,101.26 125.18,101.49 124.92,101.52 124.88,101.51 124.63,101.75 123.62,101.75 123.36,102.01 123.36,103 123.43,103.06 123.83,103.06
GND on TOP (solid shape): 102.54,74.95 102.54,73.56 102.28,73.3 102.28,72.99 102.47,72.8 102.73,72.8 102.79,72.73 102.79,71.34 102.73,71.27 102.35,71.27 102.28,71.21 102.28,67.78 102.29,67.77 102.29,66.47 102.25,66.42 101.47,66.42 101.39,66.5 101.39,72.86 101.52,72.99 101.52,74.51 101.58,74.57 101.77,74.57 101.9,74.7 101.9,75.08 101.96,75.15 102.35,75.15
GND on TOP (solid shape): 19.35,104.11 19.42,104.08 23.99,99.51 27.18,99.51 29.95,96.74 29.95,96.45 29.88,96.32 29.87,96.17 29.76,96.06 29.59,96.06 29.45,96.2 29.45,96.92 27.1,99.27 23.7,99.27 19.2,103.77 19.2,104 19.24,104.03 19.27,104.07
GND on TOP (solid shape): 93.62,73.67 93.62,73.17 93.69,73.1 93.74,73.11 93.96,73.11 94.09,72.99 94.09,72.29 93.96,72.16 93.58,72.16 93.46,72.03 93.46,71.92 93.45,71.91 93.4,71.78 93.4,71.65 93.38,71.56 93.3,71.53 92.95,71.53 92.82,71.65 92.82,72.99 92.57,73.24 92.57,73.56 92.63,73.62 92.82,73.62 92.9,73.7 93.6,73.7
GND on TOP (solid shape): 24.37,97.95 25.32,97.95 25.57,97.84 25.83,97.95 25.95,97.95 25.96,97.88 25.98,97.79 26.03,97.71 26.03,97.38 26.54,96.88 26.54,95.38 26.39,95.24 26.04,95.24 25.87,95.41 25.87,96.08 23.9,98.04 23.1,98.04 23.1,98.04 22.73,98.04 22.67,98.09 22.64,98.26 22.78,98.35 23.96,98.35
GND on TOP (solid shape): 24.39,39.53 24.39,33.59 25.17,32.82 25.17,29.62 23.87,28.32 22.1,28.32 21.8,28.02 21.8,24.2 20.96,23.36 19.4,23.36 19.01,23.75 19.01,27.05 18.97,27.09 18.97,28.4 19.12,28.55 20.3,28.55 20.6,28.84 20.6,30.31 20.6,30.32 20.6,30.87 20.81,31.08 22.04,31.08 22.34,30.78 22.34,29.89 22.49,29.74 24.15,29.74 24.41,30 24.41,31.6 23.36,32.64 23.36,35.76 22.84,36.28 21.09,36.28 20.71,36.66 20.71,39.79 20.98,40.06 23.87,40.06
GND on TOP (solid shape): 113.92,72.43 113.92,70.27 113.41,69.76 113.41,68.08 113.57,67.91 114.43,67.91 114.64,67.71 114.74,67.71 114.81,67.64 114.81,64.5 114.68,64.36 114.05,64.36 113.94,64.25 113.94,62.56 114.11,62.4 114.11,61.88 114.41,61.58 114.41,60.59 114.28,60.46 113.48,60.46 113.39,60.54 113.39,62.18 113.02,62.55 112.38,62.55 112.36,62.57 112.36,64.33 112.44,64.41 112.44,70.41 112.32,70.54 112.32,70.54 112.14,70.72 111.59,70.72 111.58,70.73 111.58,71.39 111.6,71.42 112.56,71.42 112.79,71.65 112.79,72.56 112.82,72.59 113.76,72.59
GND on TOP (solid shape): 88.31,73.56 88.31,73.19 88.26,73.19 88.26,73.12 88.18,73.05 88.18,71.91 88.3,71.79 88.29,71.76 88.27,71.68 88.28,71.59 88.28,71.56 88.28,71.45 88.17,71.34 88.17,67.89 88.41,67.65 88.41,66.43 88.98,65.87 88.98,65.14 89.14,64.99 89.14,62.7 89.07,62.64 87.68,62.64 87.55,62.76 87.55,65.07 87.43,65.19 87.13,65.19 87.04,65.28 87.04,67.6 87.06,67.62 87.26,67.62 87.55,67.91 87.55,71.21 87.23,71.53 87.04,71.53 86.98,71.59 86.98,72.99 87.04,73.05 87.21,73.05 87.3,73.04 87.39,73.05 87.55,73.05 87.68,73.18 87.68,73.56 87.8,73.68 88.18,73.68
GND on TOP (solid shape): 336.7,33.51 336.73,33.49 336.75,33.45 336.75,33.13 336.58,32.97 336.43,32.97 336.38,32.92 335.62,32.92 335.62,32.03 336.38,32.03 336.45,31.96 336.45,31.67 336.65,31.47 336.65,30.75 336.06,30.75 335.85,30.55 335.85,30.28 335.5,30.28 335.5,29.46 335.71,29.46 335.71,28.85 335.85,28.71 335.85,28.25 335.71,28.11 335.71,25.41 335.75,25.36 335.75,24.91 335.94,24.73 335.94,22.99 335.75,22.8 334.5,22.8 334.36,22.94 332.71,22.94 332.47,22.7 331.99,22.7 331.72,22.44 331.56,22.44 331.5,22.49 331.5,22.79 334.54,25.83 334.54,31.75 333.93,32.36 332.51,32.36 332.31,32.55 331.58,32.55 331.53,32.61 331.53,32.93 331.58,32.98 334.87,32.98 335.4,33.51
GND on TOP (solid shape): 106.53,74.96 106.53,74.73 106.54,74.66 106.58,74.6 106.62,74.56 106.68,74.52 106.75,74.51 107.04,74.51 107.06,74.49 107.23,74.49 107.23,73.62 107.17,73.56 107.17,73.17 107.17,73.13 107.17,71.4 107.11,71.34 106.66,71.34 106.6,71.4 106.6,72.8 106.47,72.92 106.22,72.92 106.09,73.05 106.09,73.43 106.16,73.49 106.2,73.49 106.2,73.53 106.28,73.62 106.28,74.57 106.2,74.66 106.19,74.67 106.16,74.7 106.06,74.7 106.04,74.75 106.02,74.77 105.96,74.98 106.09,75.14 106.12,75.15 106.16,75.19 106.3,75.19
GND on TOP (solid shape): 108.95,74.95 108.95,74.7 108.97,74.68 108.97,74.67 109.11,74.54 109.48,74.54 109.5,74.54 109.52,74.53 109.62,74.53 109.64,74.52 109.65,74.51 109.65,73.34 109.64,73.33 109.6,73.17 109.64,73.01 109.65,73 109.65,72.92 109.75,72.82 109.88,72.82 109.9,72.8 109.9,70.83 109.39,70.32 109.39,65.84 109.31,65.76 108.81,65.76 108.15,66.42 107.84,66.42 107.77,66.49 107.77,67.57 107.81,67.6 107.81,71.02 107.87,71.08 108.19,71.08 108.31,71.21 108.31,72.73 108.5,72.92 108.5,73.49 108.56,73.49 108.56,73.55 108.63,73.62 108.63,74.51 108.56,74.58 108.56,74.67 108.48,74.67 108.48,74.69 108.41,74.73 108.33,74.82 108.31,74.84 108.31,75.02 108.44,75.15 108.76,75.15
GND on TOP (solid shape): 131.49,136.17 131.49,134.05 131.35,133.91 129.03,133.91 128.74,134.2 128.74,135.31 128.47,135.57 127.36,135.57 127.16,135.37 127.16,134.92 127,134.76 125.97,134.76 125.85,134.65 124.79,134.65 124.41,134.26 124.41,131.57 123.97,131.14 123.97,130.07 124.18,129.87 124.18,129.85 124.17,129.78 124.18,129.71 124.18,129.55 124.12,129.36 124.17,129.17 124.17,129.13 124.18,129.08 124.18,128.99 124.13,128.94 124.1,128.88 124,128.78 122.91,128.78 122.86,128.83 122.86,129.59 122.93,129.67 123.39,129.67 123.67,129.95 123.67,129.97 123.72,130.02 123.72,130.23 123.69,130.25 123.69,131.19 123.64,131.24 123.54,131.24 123.52,131.27 123.06,131.27 122.96,131.37 122.96,132.66 123.69,133.4 123.69,134.52 123.59,134.62 123.59,136.3 123.92,136.63 131.03,136.63
GND on TOP (solid shape): 359.38,63.42 359.33,63.41 358.89,62.62 359.58,62.05 370.4,62.05 370.83,61.92 371.12,61.59 371.18,61.42 371.2,61.25 371.2,54.74 371.17,54.62 371.11,54.53 370.7,54.12 370.55,53.89 370.5,53.62 370.5,52.35 370.04,52.35 370.04,53.62 370.13,54.07 370.38,54.44 370.74,54.8 370.74,57.88 370.12,58.5 357.86,58.5 357.12,59.23 357.12,61.42 358.42,62.72 358.54,63.27 358.92,63.7 358.92,63.71 359.38,63.71
GND on TOP (solid shape): 321.2,137.85 321.41,137.76 321.5,137.55 321.5,131.72 321.05,131.72 320.91,131.58 320.06,131.58 319.56,131.08 319.56,130.3 319.2,128.96 318.22,127.99 318.22,121.06 310.05,112.9 296.34,112.9 293.82,110.39 293.82,102.81 295.97,90.98 295.5,90.98 291.55,112.8 292.15,115.09 294.3,116.1 299.6,116.1 300.45,116.45 300.8,117.3 300.8,127.3 301.04,127.86 301.6,128.1 316.9,128.1 318.46,128.74 319.1,130.3 319.1,137.55 319.19,137.76 319.4,137.85
GND on TOP (solid shape): outline of 149 points within 97.53,43.48 100.73,50.34
GND on TOP (solid shape): 358.57,95.73 358.57,92.63 359.74,91.46 364.54,91.46 364.99,91.92 364.99,92.48 365.45,92.48 365.45,90.62 364.95,89.85 365.65,89.25 366.75,89.25 366.96,89.16 367.05,88.95 367.05,84.9 366.96,84.69 366.75,84.6 362.6,84.6 361.2,83.2 362.6,81.8 366.75,81.8 366.96,81.71 367.05,81.5 367.05,80.64 367.14,80.18 367.4,79.79 368.29,78.9 368.47,78.64 368.53,78.34 368.53,77.15 368.29,76.59 367.73,76.35 359.58,76.35 359.37,76.32 359.17,76.22 358.57,76.22 355.77,76.22 353.87,78.13 353.87,85.13 350.64,88.35 350.64,95.82 351.88,97.05 357.25,97.05
GND on TOP (solid shape): 343.96,128.12 344.13,128.1 344.3,128.1 353.6,128.1 354.87,127.57 355.4,126.3 355.4,116.3 356.33,114.03 358.6,113.1 365.25,113.1 366.52,112.57 367.05,111.3 367.05,106.95 366.96,106.74 366.75,106.65 365.65,106.65 364.96,106.08 365.4,105.29 365.45,105.27 365.45,103.33 364.97,103.33 361.47,106.83 355.67,106.83 355.14,107.37 355.14,113.28 355.65,113.79 355.65,114.14 355.12,115.16 354.94,116.3 354.94,126.3 354.55,127.25 353.6,127.64 344.3,127.64 344.13,127.65 343.96,127.66
GND on TOP (solid shape): 211.1,140.1 211.66,139.86 211.9,139.3 211.9,120.06 211.92,119.55 211.98,119.04 219.36,74.98 225.67,58.9 237.94,46.73 247.53,42.09 257.95,39.91 287.88,55.29 296.06,87.93 295.32,92.03 295.78,92.03 296.51,88.01 288.22,55 257.94,39.45 247.4,41.65 237.7,46.35 225.29,58.65 218.91,74.91 211.53,118.96 211.46,119.51 211.44,120.06 211.44,139.3 211.34,139.54 211.1,139.64 209.45,139.64 209.45,140.1
GND on TOP (solid shape): outline of 119 points within 91.48,127.13 210.23,140.3
GND on TOP (solid shape): outline of 181 points within 0.2,0.2 370.2,85.72
GND on TOP (solid shape): outline of 1284 points within 0.25,93.69 80.6,139
GND on BOTTOM (solid shape): 42.25,84.95 42.25,78.68 42.08,78.51 39.8,78.51 39.67,78.64 39.67,85.11 39.8,85.24 41.96,85.24
GND on BOTTOM (solid shape): 66.29,4.42 66.29,3.53 65.96,3.2 64.36,3.2 64.14,3.43 64.14,4.75 64.36,4.98 65.73,4.98
GND on BOTTOM (solid shape): 141.75,63.4 141.75,60.96 141.6,60.81 140.43,60.81 140.25,60.98 140.25,63.42 140.43,63.6 141.55,63.6
GND on BOTTOM (solid shape): 168.72,3.9 168.72,1.88 168.58,1.74 167.67,1.74 167.42,1.99 167.42,3.8 167.56,3.94 168.68,3.94
GND on BOTTOM (solid shape): 341.9,113.35 341.9,111.93 341.39,111.42 338.78,111.42 338.4,111.8 338.4,113.4 338.75,113.76 341.49,113.76
GND on BOTTOM (solid shape): 351.32,45.06 351.32,43.78 350.98,43.43 350.45,43.43 349.09,44.79 349.09,45.33 349.33,45.56 350.83,45.56
GND on BOTTOM (solid shape): 356.24,37.66 356.24,37.32 354.75,35.83 354.62,35.83 352.3,38.15 352.3,38.34 353.6,39.63 354.27,39.63
GND on BOTTOM (solid shape): 12.94,112.04 12.94,111.53 12.92,111.51 12.43,111.51 12.28,111.66 11.54,111.66 11.54,112.1 11.67,112.23 12.75,112.23
GND on BOTTOM (solid shape): 38.05,10.4 38.05,7.17 37.75,6.88 36.04,6.88 35.98,6.95 35.98,10.29 36.15,10.46 37.98,10.46
GND on BOTTOM (solid shape): 62.96,4.74 62.96,3.37 62.79,3.2 59.17,3.2 58.94,3.43 58.94,4.18 59.31,4.55 59.31,4.7 59.46,4.85 62.86,4.85
GND on BOTTOM (solid shape): 70.47,94.09 70.47,91.29 69.78,90.6 66.66,90.6 66.15,91.11 66.15,93.69 66.71,94.25 70.31,94.25
GND on BOTTOM (solid shape): 90.9,123.06 90.9,122 91.79,121.11 91.79,120.7 91.61,120.52 89.84,120.52 89.56,120.8 89.56,123.06 89.68,123.19 90.78,123.19
GND on BOTTOM (solid shape): 306.27,41.08 306.27,37.67 306.16,37.56 305.24,37.56 305.24,37.56 305.16,37.56 305.05,37.67 305.05,41.55 305.18,41.69 305.67,41.69
GND on BOTTOM (solid shape): 320.54,89.03 323.92,89.03 324.28,88.67 324.28,84.86 323.62,84.2 319.6,84.2 319.3,84.51 319.3,88.95 319.58,89.23 320.34,89.23
